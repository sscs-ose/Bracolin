v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
B 2 -210 320 590 720 {flags=graph


ypos1=0
ypos2=2


unity=1




xlabmag=1.0
ylabmag=1.0


dataset=0
unitx=1
logx=0
logy=0







hilight_wave=-1




divx=10
y1=0
y2=0.01


rainbow=0
linewidth_mult=1.0
divy=10
subdivx=4
subdivy=1


x1=3.3
x2=3.3

sim_type=tran




color=4
node=vout}
N -410 -530 -410 -510 {
lab=GND}
N -410 -610 -410 -590 {
lab=VDD}
N -440 -610 -410 -610 {
lab=VDD}
N 620 -380 620 -360 {
lab=VDD}
N 620 -380 630 -380 {
lab=VDD}
N 620 -280 620 -260 {
lab=GND}
N 620 -260 630 -260 {
lab=GND}
N 840 -320 880 -320 {
lab=Vout}
N 680 -320 700 -320 {
lab=Vout}
N 320 -360 420 -360 {
lab=VA_PR1}
N 420 -360 520 -360 {
lab=VA_PR1}
N 880 -320 910 -320 {
lab=Vout}
N 700 -320 760 -320 {
lab=Vout}
N 760 -320 810 -320 {
lab=Vout}
N 420 -280 420 -80 {
lab=VA_PR2}
N 810 -320 810 -80 {
lab=Vout}
N 420 -80 570 -80 {
lab=VA_PR2}
N 630 -80 810 -80 {
lab=Vout}
N 420 -80 420 10 {
lab=VA_PR2}
N 420 10 530 10 {
lab=VA_PR2}
N 810 -80 810 10 {
lab=Vout}
N 680 10 810 10 {
lab=Vout}
N 180 -360 320 -360 {
lab=VA_PR1}
N 270 -360 270 -320 {
lab=VA_PR1}
N 270 -260 270 -180 {
lab=VB_PR1}
N 180 -180 270 -180 {
lab=VB_PR1}
N 1340 -1820 1340 -1790 {
lab=#net1}
N -20 -360 180 -360 {
lab=VA_PR1}
N -20 10 420 10 {
lab=VA_PR2}
N -440 -360 -380 -360 {
lab=Vin_pos}
N -430 10 -380 10 {
lab=Vin_neg}
N -440 10 -430 10 {
lab=Vin_neg}
N 420 -280 520 -280 {
lab=VA_PR2}
N 560 -250 560 -230 {
lab=#net2}
N 560 -170 560 -160 {
lab=GND}
N 1710 -750 1710 -740 {
lab=GND}
N 1660 -750 1660 -740 {
lab=GND}
N 1670 -660 1670 -640 {
lab=VDD}
N 1720 -660 1720 -650 {
lab=VDD}
N 1670 -830 1670 -720 {
lab=#net3}
N 1660 -830 1660 -810 {
lab=#net4}
N 1720 -830 1720 -720 {
lab=#net5}
N 1710 -830 1710 -810 {
lab=#net6}
N 220 -120 220 -90 {
lab=GND}
N 1390 -1830 1400 -1830 {
lab=GND}
N 810 -320 840 -320 {
lab=Vout}
N 1600 -820 1630 -820 {
lab=VDD}
N 1630 -830 1630 -820 {
lab=VDD}
N 1760 -930 1800 -930 {
lab=GND}
N 1270 -1960 1290 -1960 {
lab=VDD}
N 1190 -1820 1190 -1810 {
lab=GND}
N 1050 -1870 1050 -1860 {
lab=GND}
N 1090 -1860 1090 -1840 {
lab=VDD}
N 1220 -1810 1220 -1800 {
lab=VDD}
N -320 -360 -20 -360 {
lab=VA_PR1}
N -320 10 -20 10 {
lab=VA_PR2}
N 1050 -1930 1290 -1930 {
lab=#net7}
N 1090 -1920 1290 -1920 {
lab=#net8}
N 1190 -1880 1290 -1880 {
lab=#net9}
N 1220 -1870 1290 -1870 {
lab=#net10}
N -530 -300 -530 -270 {
lab=GND}
N -530 -360 -440 -360 {
lab=Vin_pos}
N -530 10 -440 10 {
lab=Vin_neg}
N 140 -180 180 -180 {
lab=VB_PR1}
N 1930 -750 1930 -740 {
lab=GND}
N 1880 -750 1880 -740 {
lab=GND}
N 1890 -660 1890 -640 {
lab=VDD}
N 1940 -660 1940 -650 {
lab=VDD}
N 1890 -830 1890 -720 {
lab=#net11}
N 1880 -830 1880 -810 {
lab=#net12}
N 1940 -830 1940 -720 {
lab=#net13}
N 1930 -830 1930 -810 {
lab=#net14}
N 1820 -820 1850 -820 {
lab=VDD}
N 1850 -830 1850 -820 {
lab=VDD}
N 1980 -930 2020 -930 {
lab=GND}
N 2130 -750 2130 -740 {
lab=GND}
N 2080 -750 2080 -740 {
lab=GND}
N 2090 -660 2090 -640 {
lab=VDD}
N 2140 -660 2140 -650 {
lab=VDD}
N 2090 -830 2090 -720 {
lab=#net15}
N 2080 -830 2080 -810 {
lab=#net16}
N 2140 -830 2140 -720 {
lab=#net17}
N 2130 -830 2130 -810 {
lab=#net18}
N 2020 -820 2050 -820 {
lab=VDD}
N 2050 -830 2050 -820 {
lab=VDD}
N 2350 -750 2350 -740 {
lab=GND}
N 2300 -750 2300 -740 {
lab=GND}
N 2310 -660 2310 -640 {
lab=VDD}
N 2360 -660 2360 -650 {
lab=VDD}
N 2310 -830 2310 -720 {
lab=#net19}
N 2300 -830 2300 -810 {
lab=#net20}
N 2360 -830 2360 -720 {
lab=#net21}
N 2350 -830 2350 -810 {
lab=#net22}
N 2240 -820 2270 -820 {
lab=VDD}
N 2270 -830 2270 -820 {
lab=VDD}
N 2400 -930 2440 -930 {
lab=GND}
N 2570 -750 2570 -740 {
lab=GND}
N 2520 -750 2520 -740 {
lab=GND}
N 2530 -660 2530 -640 {
lab=VDD}
N 2580 -660 2580 -650 {
lab=VDD}
N 2530 -830 2530 -720 {
lab=#net23}
N 2520 -830 2520 -810 {
lab=#net24}
N 2580 -830 2580 -720 {
lab=#net25}
N 2570 -830 2570 -810 {
lab=#net26}
N 2460 -820 2490 -820 {
lab=VDD}
N 2490 -830 2490 -820 {
lab=VDD}
N 2620 -930 2660 -930 {
lab=GND}
N 1770 -880 1840 -880 {
lab=#net27}
N 1990 -880 2040 -880 {
lab=#net28}
N 2190 -880 2260 -880 {
lab=#net29}
N 2410 -880 2480 -880 {
lab=#net30}
N 1340 -1640 1340 -1610 {
lab=#net31}
N 1390 -1650 1400 -1650 {
lab=GND}
N 1270 -1780 1290 -1780 {
lab=VDD}
N 1190 -1640 1190 -1630 {
lab=GND}
N 1050 -1690 1050 -1680 {
lab=GND}
N 1090 -1680 1090 -1660 {
lab=VDD}
N 1220 -1630 1220 -1620 {
lab=VDD}
N 1050 -1750 1290 -1750 {
lab=#net32}
N 1090 -1740 1290 -1740 {
lab=#net33}
N 1190 -1700 1290 -1700 {
lab=#net34}
N 1220 -1690 1290 -1690 {
lab=#net35}
N 1340 -1460 1340 -1430 {
lab=#net36}
N 1390 -1470 1400 -1470 {
lab=GND}
N 1270 -1600 1290 -1600 {
lab=VDD}
N 1190 -1460 1190 -1450 {
lab=GND}
N 1050 -1510 1050 -1500 {
lab=GND}
N 1090 -1500 1090 -1480 {
lab=VDD}
N 1220 -1450 1220 -1440 {
lab=VDD}
N 1050 -1570 1290 -1570 {
lab=#net37}
N 1090 -1560 1290 -1560 {
lab=#net38}
N 1190 -1520 1290 -1520 {
lab=#net39}
N 1220 -1510 1290 -1510 {
lab=#net40}
N 1340 -1280 1340 -1250 {
lab=#net41}
N 1390 -1290 1400 -1290 {
lab=GND}
N 1270 -1420 1290 -1420 {
lab=VDD}
N 1190 -1280 1190 -1270 {
lab=GND}
N 1050 -1330 1050 -1320 {
lab=GND}
N 1090 -1320 1090 -1300 {
lab=VDD}
N 1220 -1270 1220 -1260 {
lab=VDD}
N 1050 -1390 1290 -1390 {
lab=#net42}
N 1090 -1380 1290 -1380 {
lab=#net43}
N 1190 -1340 1290 -1340 {
lab=#net44}
N 1220 -1330 1290 -1330 {
lab=#net45}
N 1340 -1250 1340 -1220 {
lab=#net41}
N 1340 -1070 1340 -1040 {
lab=VB_PR1}
N 1390 -1080 1400 -1080 {
lab=GND}
N 1270 -1210 1290 -1210 {
lab=VDD}
N 1190 -1070 1190 -1060 {
lab=GND}
N 1050 -1120 1050 -1110 {
lab=GND}
N 1090 -1110 1090 -1090 {
lab=VDD}
N 1220 -1060 1220 -1050 {
lab=VDD}
N 1050 -1180 1290 -1180 {
lab=#net46}
N 1090 -1170 1290 -1170 {
lab=#net47}
N 1190 -1130 1290 -1130 {
lab=#net48}
N 1220 -1120 1290 -1120 {
lab=#net49}
N 1340 -2000 1340 -1970 {
lab=VA_PR1}
N 1600 -880 1620 -880 {
lab=VA_PR2}
N 2630 -880 2660 -880 {
lab=Vout}
N 2180 -930 2200 -930 {
lab=GND}
N 2660 -880 2730 -880 {
lab=Vout}
N 2880 -880 2910 -880 {
lab=Vout}
N 1340 -1040 1340 -1010 {
lab=VB_PR1}
N 1340 -860 1340 -830 {
lab=VB_PR1}
N 2730 -880 2880 -880 {
lab=Vout}
N 1340 -1010 1340 -860 {
lab=VB_PR1}
N -530 10 -530 50 {
lab=Vin_neg}
N -530 140 -530 170 {
lab=sin}
N -530 230 -530 260 {
lab=#net50}
N -530 110 -530 140 {
lab=sin}
N -530 320 -530 350 {
lab=GND}
C {devices/code_shown.sym} -1670 -390 0 0 {name=MODELS only_toplevel=true
format="tcleval( @value )"
value="
.include $::180MCU_MODELS/design.ngspice
.lib $::180MCU_MODELS/sm141064.ngspice typical
.lib $::180MCU_MODELS/sm141064.ngspice cap_mim
.lib $::180MCU_MODELS/sm141064.ngspice res_typical
.lib $::180MCU_MODELS/sm141064.ngspice moscap_typical
.lib $::180MCU_MODELS/sm141064.ngspice mimcap_typical
"}
C {devices/launcher.sym} -125 235 0 0 {name=h1
descr="Click left mouse button here with control key
pressed to load/unload waveforms in graph."
tclcommand="
xschem raw_read $netlist_dir/[file tail [file rootname [xschem get current_name]]].raw
"
}
C {devices/launcher.sym} -130 290 0 0 {name=h2
descr="Annotate OP" 
tclcommand="set show_hidden_texts 1; xschem annotate_op"
}
C {devices/vsource.sym} -410 -560 0 0 {name=VDD value=3.3}
C {devices/gnd.sym} -410 -510 0 0 {name=l1 lab=GND}
C {devices/lab_wire.sym} -410 -610 0 0 {name=p1 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 630 -380 0 1 {name=p3 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 910 -320 0 1 {name=p5 sig_type=std_logic lab=Vout}
C {devices/gnd.sym} 630 -260 0 0 {name=l7 lab=GND}
C {devices/lab_wire.sym} -430 -360 0 0 {name=p2 sig_type=std_logic lab=Vin_pos}
C {devices/capa.sym} 900 -290 0 0 {name=C2
m=1
value=5p
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 900 -260 0 0 {name=l11 lab=GND}
C {devices/code_shown.sym} -1580 -200 0 0 {name=NGSPICE only_toplevel=true
value="
.option gmin=1e-16
.OPTION ABSTOL=1e-2

*.nodeset v(Vin_neg)=1.65
*.nodeset v(vout)=1.65

.nodeset all=1.65

.param ibias = 1p
.param it_amp = 2p

.control
save all

tran 100n 1u
remzerovec
write TB_TIA_tran.raw
set appendwrite

op
remzerovec 
write TB_filter_tran.raw
set appendwrite


.endc
"}
C {/home/gmaranhao/Desktop/gf180_work/TIA/FoldedCascode.sym} 620 -320 0 0 {name=x1}
C {devices/lab_wire.sym} -420 10 0 0 {name=p4 sig_type=std_logic lab=Vin_neg}
C {/home/gmaranhao/Desktop/gf180_work/TIA/PseudoResistor/PRbiased_net.sym} 1690 -800 3 0 {name=x6}
C {devices/gnd.sym} 1800 -930 0 0 {name=l2 lab=GND}
C {/home/gmaranhao/Desktop/gf180_work/TIA/PseudoResistor/PRbiased_net.sym} 1260 -1900 0 0 {name=x2}
C {devices/isource.sym} 560 -200 0 1 {name=I0 value=0.25u}
C {devices/gnd.sym} 560 -160 0 1 {name=l3 lab=GND}
C {devices/isource.sym} 1710 -780 0 0 {name=I4 value=\{it_amp\}}
C {devices/isource.sym} 1720 -690 2 1 {name=I5 value=\{it_amp\}}
C {devices/isource.sym} 1660 -780 0 1 {name=I6 value=\{ibias\}}
C {devices/isource.sym} 1670 -690 2 0 {name=I7 value=\{ibias\}}
C {devices/gnd.sym} 1660 -740 0 1 {name=l4 lab=GND}
C {devices/gnd.sym} 1710 -740 0 1 {name=l5 lab=GND}
C {devices/lab_wire.sym} 1670 -640 2 1 {name=p28 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1720 -650 2 0 {name=p29 sig_type=std_logic lab=VDD}
C {devices/vsource.sym} 220 -150 0 0 {name=Vcm value=1.65}
C {devices/gnd.sym} 220 -90 0 1 {name=l6 lab=GND}
C {devices/gnd.sym} 1400 -1830 0 1 {name=l8 lab=GND}
C {devices/lab_wire.sym} 1270 -1960 2 1 {name=p7 sig_type=std_logic lab=VDD}
C {devices/isource.sym} 1190 -1850 0 1 {name=I1 value=\{it_amp\}}
C {devices/isource.sym} 1220 -1840 2 1 {name=I2 value=\{it_amp\}}
C {devices/isource.sym} 1050 -1900 0 1 {name=I3 value=\{ibias\}}
C {devices/isource.sym} 1090 -1890 2 1 {name=I8 value=\{ibias\}}
C {devices/gnd.sym} 1050 -1860 0 1 {name=l9 lab=GND}
C {devices/gnd.sym} 1190 -1810 0 1 {name=l10 lab=GND}
C {devices/lab_wire.sym} 1090 -1840 2 1 {name=p8 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1220 -1800 2 0 {name=p9 sig_type=std_logic lab=VDD}
C {devices/vsource.sym} -530 -330 0 0 {name=Vin1 value=1.65}
C {devices/gnd.sym} -530 -270 0 1 {name=l12 lab=GND}
C {/home/gmaranhao/Desktop/gf180_work/TIA/PseudoResistor/PRbiased_net.sym} 1910 -800 3 0 {name=x3}
C {devices/gnd.sym} 2020 -930 0 0 {name=l14 lab=GND
}
C {devices/isource.sym} 1930 -780 0 0 {name=I9 value=\{it_amp\}}
C {devices/isource.sym} 1940 -690 2 1 {name=I10 value=\{it_amp\}}
C {devices/isource.sym} 1880 -780 0 1 {name=I11 value=\{ibias\}}
C {devices/isource.sym} 1890 -690 2 0 {name=I12 value=\{ibias\}}
C {devices/gnd.sym} 1880 -740 0 1 {name=l15 lab=GND}
C {devices/gnd.sym} 1930 -740 0 1 {name=l16 lab=GND}
C {devices/lab_wire.sym} 1890 -640 2 1 {name=p10 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1940 -650 2 0 {name=p11 sig_type=std_logic lab=VDD}
C {/home/gmaranhao/Desktop/gf180_work/TIA/PseudoResistor/PRbiased_net.sym} 2110 -800 3 0 {name=x4
}
C {devices/gnd.sym} 2200 -930 0 0 {name=l17 lab=GND
}
C {devices/isource.sym} 2130 -780 0 0 {name=I13 value=\{it_amp\}
}
C {devices/isource.sym} 2140 -690 2 1 {name=I14 value=\{it_amp\}
}
C {devices/isource.sym} 2080 -780 0 1 {name=I15 value=\{ibias\}
}
C {devices/isource.sym} 2090 -690 2 0 {name=I16 value=\{ibias\}
}
C {devices/gnd.sym} 2080 -740 0 1 {name=l18 lab=GND
}
C {devices/gnd.sym} 2130 -740 0 1 {name=l19 lab=GND
}
C {devices/lab_wire.sym} 2090 -640 2 1 {name=p12 sig_type=std_logic lab=VDD
}
C {devices/lab_wire.sym} 2140 -650 2 0 {name=p13 sig_type=std_logic lab=VDD
}
C {/home/gmaranhao/Desktop/gf180_work/TIA/PseudoResistor/PRbiased_net.sym} 2330 -800 3 0 {name=x5
}
C {devices/gnd.sym} 2440 -930 0 0 {name=l20 lab=GND
}
C {devices/isource.sym} 2350 -780 0 0 {name=I17 value=\{it_amp\}
}
C {devices/isource.sym} 2360 -690 2 1 {name=I18 value=\{it_amp\}
}
C {devices/isource.sym} 2300 -780 0 1 {name=I19 value=\{ibias\}
}
C {devices/isource.sym} 2310 -690 2 0 {name=I20 value=\{ibias\}
}
C {devices/gnd.sym} 2300 -740 0 1 {name=l21 lab=GND
}
C {devices/gnd.sym} 2350 -740 0 1 {name=l22 lab=GND
}
C {devices/lab_wire.sym} 2310 -640 2 1 {name=p14 sig_type=std_logic lab=VDD
}
C {devices/lab_wire.sym} 2360 -650 2 0 {name=p15 sig_type=std_logic lab=VDD
}
C {/home/gmaranhao/Desktop/gf180_work/TIA/PseudoResistor/PRbiased_net.sym} 2550 -800 3 0 {name=x7
}
C {devices/gnd.sym} 2660 -930 0 0 {name=l23 lab=GND
}
C {devices/isource.sym} 2570 -780 0 0 {name=I21 value=\{it_amp\}
}
C {devices/isource.sym} 2580 -690 2 1 {name=I22 value=\{it_amp\}
}
C {devices/isource.sym} 2520 -780 0 1 {name=I23 value=\{ibias\}
}
C {devices/isource.sym} 2530 -690 2 0 {name=I24 value=\{ibias\}
}
C {devices/gnd.sym} 2520 -740 0 1 {name=l24 lab=GND
}
C {devices/gnd.sym} 2570 -740 0 1 {name=l25 lab=GND
}
C {devices/lab_wire.sym} 2530 -640 2 1 {name=p16 sig_type=std_logic lab=VDD
}
C {devices/lab_wire.sym} 2580 -650 2 0 {name=p17 sig_type=std_logic lab=VDD
}
C {/home/gmaranhao/Desktop/gf180_work/TIA/PseudoResistor/PRbiased_net.sym} 1260 -1720 0 0 {name=x8}
C {devices/gnd.sym} 1400 -1650 0 1 {name=l26 lab=GND}
C {devices/lab_wire.sym} 1270 -1780 2 1 {name=p18 sig_type=std_logic lab=VDD}
C {devices/isource.sym} 1190 -1670 0 1 {name=I25 value=\{it_amp\}}
C {devices/isource.sym} 1220 -1660 2 1 {name=I26 value=\{it_amp\}}
C {devices/isource.sym} 1050 -1720 0 1 {name=I27 value=\{ibias\}}
C {devices/isource.sym} 1090 -1710 2 1 {name=I28 value=\{ibias\}}
C {devices/gnd.sym} 1050 -1680 0 1 {name=l27 lab=GND}
C {devices/gnd.sym} 1190 -1630 0 1 {name=l28 lab=GND}
C {devices/lab_wire.sym} 1090 -1660 2 1 {name=p19 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1220 -1620 2 0 {name=p20 sig_type=std_logic lab=VDD}
C {/home/gmaranhao/Desktop/gf180_work/TIA/PseudoResistor/PRbiased_net.sym} 1260 -1540 0 0 {name=x9
}
C {devices/gnd.sym} 1400 -1470 0 1 {name=l29 lab=GND
}
C {devices/lab_wire.sym} 1270 -1600 2 1 {name=p21 sig_type=std_logic lab=VDD
}
C {devices/isource.sym} 1190 -1490 0 1 {name=I29 value=\{it_amp\}
}
C {devices/isource.sym} 1220 -1480 2 1 {name=I30 value=\{it_amp\}
}
C {devices/isource.sym} 1050 -1540 0 1 {name=I31 value=\{ibias\}
}
C {devices/isource.sym} 1090 -1530 2 1 {name=I32 value=\{ibias\}
}
C {devices/gnd.sym} 1050 -1500 0 1 {name=l30 lab=GND
}
C {devices/gnd.sym} 1190 -1450 0 1 {name=l31 lab=GND
}
C {devices/lab_wire.sym} 1090 -1480 2 1 {name=p22 sig_type=std_logic lab=VDD
}
C {devices/lab_wire.sym} 1220 -1440 2 0 {name=p23 sig_type=std_logic lab=VDD
}
C {/home/gmaranhao/Desktop/gf180_work/TIA/PseudoResistor/PRbiased_net.sym} 1260 -1360 0 0 {name=x10
}
C {devices/gnd.sym} 1400 -1290 0 1 {name=l32 lab=GND
}
C {devices/lab_wire.sym} 1270 -1420 2 1 {name=p24 sig_type=std_logic lab=VDD
}
C {devices/isource.sym} 1190 -1310 0 1 {name=I33 value=\{it_amp\}
}
C {devices/isource.sym} 1220 -1300 2 1 {name=I34 value=\{it_amp\}
}
C {devices/isource.sym} 1050 -1360 0 1 {name=I35 value=\{ibias\}
}
C {devices/isource.sym} 1090 -1350 2 1 {name=I36 value=\{ibias\}
}
C {devices/gnd.sym} 1050 -1320 0 1 {name=l33 lab=GND
}
C {devices/gnd.sym} 1190 -1270 0 1 {name=l34 lab=GND
}
C {devices/lab_wire.sym} 1090 -1300 2 1 {name=p25 sig_type=std_logic lab=VDD
}
C {devices/lab_wire.sym} 1220 -1260 2 0 {name=p26 sig_type=std_logic lab=VDD
}
C {/home/gmaranhao/Desktop/gf180_work/TIA/PseudoResistor/PRbiased_net.sym} 1260 -1150 0 0 {name=x11
}
C {devices/gnd.sym} 1400 -1080 0 1 {name=l35 lab=GND
}
C {devices/lab_wire.sym} 1270 -1210 2 1 {name=p27 sig_type=std_logic lab=VDD
}
C {devices/isource.sym} 1190 -1100 0 1 {name=I37 value=\{it_amp\}
}
C {devices/isource.sym} 1220 -1090 2 1 {name=I38 value=\{it_amp\}
}
C {devices/isource.sym} 1050 -1150 0 1 {name=I39 value=\{ibias\}
}
C {devices/isource.sym} 1090 -1140 2 1 {name=I40 value=\{ibias\}
}
C {devices/gnd.sym} 1050 -1110 0 1 {name=l36 lab=GND
}
C {devices/gnd.sym} 1190 -1060 0 1 {name=l37 lab=GND
}
C {devices/lab_wire.sym} 1090 -1090 2 1 {name=p30 sig_type=std_logic lab=VDD
}
C {devices/lab_wire.sym} 1220 -1050 2 0 {name=p31 sig_type=std_logic lab=VDD
}
C {devices/lab_wire.sym} 140 -360 2 1 {name=p32 sig_type=std_logic lab=VA_PR1}
C {devices/lab_wire.sym} 140 -180 2 1 {name=p33 sig_type=std_logic lab=VB_PR1}
C {devices/lab_wire.sym} 1340 -2000 0 0 {name=p34 sig_type=std_logic lab=VA_PR1}
C {devices/lab_wire.sym} 1600 -820 2 1 {name=p6 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1820 -820 2 1 {name=p36 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2020 -820 2 1 {name=p37 sig_type=std_logic lab=VDD
}
C {devices/lab_wire.sym} 2240 -820 2 1 {name=p38 sig_type=std_logic lab=VDD
}
C {devices/lab_wire.sym} 2460 -820 2 1 {name=p39 sig_type=std_logic lab=VDD
}
C {devices/lab_wire.sym} 530 10 2 1 {name=p40 sig_type=std_logic lab=VA_PR2}
C {devices/lab_wire.sym} 1600 -880 2 1 {name=p42 sig_type=std_logic lab=VA_PR2}
C {devices/lab_pin.sym} 2910 -880 0 1 {name=p41 sig_type=std_logic lab=Vout
}
C {devices/lab_wire.sym} 1340 -830 2 1 {name=p49 sig_type=std_logic lab=VB_PR1
}
C {symbols/cap_mim_2p0fF.sym} -350 -360 1 0 {name=C4
W=100e-6
L=100e-6
model=cap_mim_2f0fF
spiceprefix=X
m=1}
C {symbols/cap_mim_2p0fF.sym} -350 10 1 0 {name=C1
W=100e-6
L=100e-6
model=cap_mim_2f0fF
spiceprefix=X
m=1}
C {symbols/cap_mim_2p0fF.sym} 270 -290 0 0 {name=C3
W=10e-6
L=10e-6
model=cap_mim_2f0fF
spiceprefix=X
m=1}
C {symbols/cap_mim_2p0fF.sym} 600 -80 1 0 {name=C5
W=10e-6
L=10e-6
model=cap_mim_2f0fF
spiceprefix=X
m=1}
C {devices/vsource.sym} -280 -530 0 0 {name=VDD1 value="DC 0 TRNOISE (20n 0.5n 0 0)"}
C {devices/vsource.sym} -530 200 0 1 {name=VDD5 value="sin(0 10m 1K 0 0 0)"}
C {devices/lab_pin.sym} -530 140 0 0 {name=p43 sig_type=std_logic lab=sin}
C {devices/gnd.sym} -530 350 0 0 {name=l38 lab=GND}
C {devices/vsource.sym} -530 290 0 1 {name=VDD6 value=1.65}
C {devices/vsource.sym} -530 80 0 1 {name=VDD7 value="sin(0 1m 1MEG 0 0 0)"}
