* NGSPICE file created from SAR_Logic.ext - technology: gf180mcuD

.subckt SAR_Logic VSSD VDDD D clks CK11 CK10 CK9 CK8 CK7 CK6 CK5 CK4 CK3 CK2 CK1
X0 a_99210_19028.t0 a_98226_19028.t4 a_99210_20288# VDDD.t13 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X1 a_60418_19028.t2 a_59294_19028# a_60418_20288# VDDD.t169 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X2 a_126982_19260.t0 a_126162_19260.t2 VDDD.t215 VDDD.t214 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X3 a_45418_19028.t4 clks.t0 VSSD.t157 VSSD.t156 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X4 VSSD.t205 Set a_32058_19028.t1 VSSD.t204 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X5 VSSD.t15 a_119294_19028# a_120418_19028.t1 VSSD.t14 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X6 a_10838_19028.t1 clks.t1 a_10838_20288# VDDD.t57 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X7 a_130838_20288# a_129210_19028.t5 VDDD.t116 VDDD.t115 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X8 VSSD.t251 a_n706_19028# a_418_19028.t3 VSSD.t250 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X9 a_49862_19260# a_45418_19028.t5 VDDD.t230 VDDD.t229 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X10 a_59294_19028# a_51982_19260.t2 a_62058_19028.t0 VDDD.t85 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X11 a_128226_19028.t0 a_126982_19260.t2 a_120418_19028.t2 VDDD.t3 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X12 VSSD.t276 a_74294_19028# a_75418_19028.t4 VSSD.t275 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X13 a_n6774_19028.t3 a_n8838_19260.t2 a_n4162_19028.t4 VDDD.t88 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X14 a_n706_19028# a_n8018_19260.t2 a_2058_19028.t4 VDDD.t111 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X15 a_85838_20288# a_84210_19028.t5 VDDD.t174 VDDD.t173 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X16 a_119294_19028# a_111162_19260.t2 a_122058_19028.t0 VSSD.t277 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X17 a_n6774_19028.t1 a_n8018_19260.t3 D.t1 VDDD.t112 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X18 a_51162_19260.t0 Valid VDDD.t52 VDDD.t51 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X19 VSSD.t155 clks.t2 a_25838_19028.t1 VSSD.t154 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X20 a_145838_19028.t0 a_144210_19028.t5 VSSD.t74 VSSD.t73 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X21 a_111982_19260.t1 a_111162_19260.t3 VSSD.t100 VSSD.t99 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X22 a_44294_19028# a_36982_19260.t2 a_39210_19028.t0 VSSD.t109 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X23 a_54210_19028.t4 Set VSSD.t203 VSSD.t202 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X24 a_74294_19028# a_66162_19260.t2 a_77058_19028.t0 VSSD.t233 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X25 a_66982_19260.t1 a_66162_19260.t3 VSSD.t235 VSSD.t234 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X26 a_45418_20288# clks.t3 VDDD.t59 VDDD.t58 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X27 a_6982_19260.t1 a_6162_19260.t2 VSSD.t237 VSSD.t236 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X28 a_34862_19260# a_30418_19028.t5 VSSD.t283 VSSD.t282 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X29 a_17058_19028.t4 a_15418_19028.t5 VSSD.t262 VSSD.t261 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X30 a_32058_19028.t2 Set a_32058_20288# VDDD.t162 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X31 a_120418_19028.t0 a_119294_19028# a_120418_20288# VDDD.t17 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X32 a_105418_19028.t4 clks.t4 VSSD.t153 VSSD.t152 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X33 a_418_19028.t2 a_n706_19028# a_418_20288# VDDD.t203 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X34 a_8226_19028.t0 a_6982_19260.t2 a_10838_19028.t4 VSSD.t272 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X35 a_75418_19028.t3 a_74294_19028# a_75418_20288# VDDD.t234 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X36 a_109862_19260# a_105418_19028.t5 VDDD.t219 VDDD.t218 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X37 a_119294_19028# a_111982_19260.t2 a_122058_19028.t2 VDDD.t73 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X38 VSSD.t151 clks.t5 a_n4162_19028.t2 VSSD.t150 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X39 VSSD.t201 Set a_47058_19028.t2 VSSD.t200 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X40 VSSD.t13 a_134294_19028# a_135418_19028.t1 VSSD.t12 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X41 a_25838_19028.t2 clks.t6 a_25838_20288# VDDD.t231 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X42 a_44294_19028# a_36162_19260.t2 a_39210_19028.t1 VDDD.t69 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X43 a_145838_20288# a_144210_19028.t6 VDDD.t87 VDDD.t86 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X44 a_54210_20288# Set VDDD.t161 VDDD.t160 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X45 a_74294_19028# a_66982_19260.t2 a_77058_19028.t3 VDDD.t224 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X46 a_111162_19260.t0 Valid VDDD.t50 VDDD.t49 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X47 a_134294_19028# a_126162_19260.t3 a_137058_19028.t2 VSSD.t161 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X48 a_126982_19260.t1 a_126162_19260.t4 VSSD.t160 VSSD.t159 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X49 a_114210_19028.t2 Set VSSD.t199 VSSD.t198 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X50 a_104294_19028# a_96982_19260.t2 a_99210_19028.t3 VSSD.t93 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X51 a_90418_19028.t4 clks.t7 VSSD.t149 VSSD.t148 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X52 a_66162_19260.t0 Valid VDDD.t48 VDDD.t47 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X53 a_59294_19028# a_51982_19260.t3 a_54210_19028.t1 VSSD.t71 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X54 a_6162_19260.t0 Valid VDDD.t46 VDDD.t45 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X55 a_17058_20288# a_15418_19028.t6 VDDD.t211 VDDD.t210 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X56 a_105418_20288# clks.t8 VDDD.t196 VDDD.t195 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X57 a_69210_19028.t2 Set VSSD.t197 VSSD.t196 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X58 a_94862_19260# a_90418_19028.t5 VDDD.t81 VDDD.t80 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X59 a_9210_19028.t4 Set VSSD.t195 VSSD.t194 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X60 a_49862_19260# a_45418_19028.t6 VSSD.t274 VSSD.t273 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X61 a_8226_19028.t2 a_6162_19260.t3 a_10838_19028.t3 VDDD.t222 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X62 a_47058_19028.t3 Set a_47058_20288# VDDD.t159 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X63 a_n4162_19028.t3 clks.t9 a_n4162_20288# VDDD.t197 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X64 a_135418_19028.t2 a_134294_19028# a_135418_20288# VDDD.t16 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X65 a_23226_19028.t1 a_21162_19260.t2 a_15418_19028.t4 VSSD.t211 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X66 a_51162_19260.t1 Valid VSSD.t42 VSSD.t41 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X67 VSSD.t147 clks.t10 a_70838_19028.t3 VSSD.t146 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X68 a_23226_19028.t2 a_21982_19260.t2 a_25838_19028.t0 VSSD.t96 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X69 VSSD.t193 Set a_107058_19028.t4 VSSD.t192 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X70 a_104294_19028# a_96162_19260.t2 a_99210_19028.t2 VDDD.t108 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X71 a_90418_20288# clks.t11 VDDD.t199 VDDD.t198 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X72 a_114210_20288# Set VDDD.t158 VDDD.t157 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X73 a_134294_19028# a_126982_19260.t3 a_137058_19028.t1 VDDD.t15 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X74 a_59294_19028# a_51162_19260.t2 a_54210_19028.t0 VDDD.t129 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X75 a_150418_19028.t2 clks.t12 VSSD.t145 VSSD.t144 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X76 a_62058_19028.t3 a_60418_19028.t5 VSSD.t215 VSSD.t214 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X77 a_69210_20288# Set VDDD.t156 VDDD.t155 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X78 a_126162_19260.t0 Valid VDDD.t44 VDDD.t43 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X79 a_2058_19028.t2 a_418_19028.t5 VSSD.t70 VSSD.t69 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X80 VSSD.t84 a_53226_19028.t4 a_54210_19028.t2 VSSD.t83 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X81 a_119294_19028# a_111982_19260.t3 a_114210_19028.t1 VSSD.t59 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X82 a_9210_20288# Set VDDD.t154 VDDD.t153 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X83 a_21982_19260.t0 a_21162_19260.t3 VDDD.t167 VDDD.t166 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X84 a_129210_19028.t2 Set VSSD.t191 VSSD.t190 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X85 a_154862_19260# a_150418_19028.t3 VDDD.t209 VDDD.t208 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X86 VSSD.t189 Set a_92058_19028.t1 VSSD.t188 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X87 a_109862_19260# a_105418_19028.t6 VSSD.t257 VSSD.t256 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X88 a_23226_19028.t3 a_21982_19260.t3 a_15418_19028.t2 VDDD.t124 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X89 a_70838_19028.t4 clks.t13 a_70838_20288# VDDD.t98 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X90 a_107058_19028.t3 Set a_107058_20288# VDDD.t152 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X91 a_23226_19028.t0 a_21162_19260.t4 a_25838_19028.t3 VDDD.t165 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X92 VSSD.t143 clks.t14 a_130838_19028.t3 VSSD.t142 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X93 a_111162_19260.t1 Valid VSSD.t40 VSSD.t39 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X94 a_40838_19028.t0 a_39210_19028.t5 VSSD.t111 VSSD.t110 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X95 a_38226_19028.t3 a_36162_19260.t3 a_30418_19028.t3 VSSD.t49 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X96 VSSD.t141 clks.t15 a_85838_19028.t1 VSSD.t140 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X97 a_66162_19260.t1 Valid VSSD.t38 VSSD.t37 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X98 a_62058_20288# a_60418_19028.t6 VDDD.t207 VDDD.t206 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X99 a_150418_20288# clks.t16 VDDD.t100 VDDD.t99 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X100 a_6162_19260.t1 Valid VSSD.t36 VSSD.t35 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X101 a_2058_20288# a_418_19028.t6 VDDD.t83 VDDD.t82 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X102 a_54210_19028.t3 a_53226_19028.t5 a_54210_20288# VDDD.t97 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X103 a_119294_19028# a_111162_19260.t4 a_114210_19028.t0 VDDD.t120 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X104 a_122058_19028.t1 a_120418_19028.t5 VSSD.t279 VSSD.t278 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X105 a_94862_19260# a_90418_19028.t6 VSSD.t66 VSSD.t65 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X106 a_129210_20288# Set VDDD.t151 VDDD.t150 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X107 a_77058_19028.t4 a_75418_19028.t5 VSSD.t107 VSSD.t106 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X108 a_92058_19028.t0 Set a_92058_20288# VDDD.t149 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X109 VSSD.t255 a_113226_19028.t4 a_114210_19028.t3 VSSD.t254 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X110 a_36982_19260.t0 a_36162_19260.t4 VDDD.t63 VDDD.t62 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X111 VSSD.t187 Set a_152058_19028.t4 VSSD.t186 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X112 VSSD.t271 a_68226_19028.t4 a_69210_19028.t4 VSSD.t270 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X113 VSSD.t105 a_8226_19028.t4 a_9210_19028.t3 VSSD.t104 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X114 a_68226_19028.t0 a_66982_19260.t3 a_70838_19028.t0 VSSD.t82 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X115 a_130838_19028.t2 clks.t17 a_130838_20288# VDDD.t101 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X116 VSSD.t3 a_29294_19028# a_30418_19028.t0 VSSD.t2 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X117 a_n8838_19260.t0 Valid VDDD.t42 VDDD.t41 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X118 a_38226_19028.t1 a_36982_19260.t3 a_30418_19028.t2 VDDD.t163 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X119 a_40838_20288# a_39210_19028.t6 VDDD.t128 VDDD.t127 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X120 a_85838_19028.t0 clks.t18 a_85838_20288# VDDD.t102 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X121 a_100838_19028.t0 a_99210_19028.t5 VSSD.t5 VSSD.t4 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X122 a_21982_19260.t1 a_21162_19260.t5 VSSD.t209 VSSD.t208 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X123 a_29294_19028# a_21162_19260.t6 a_32058_19028.t3 VSSD.t210 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X124 VSSD.t139 clks.t19 a_145838_19028.t4 VSSD.t138 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X125 a_126162_19260.t1 Valid VSSD.t34 VSSD.t33 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X126 a_122058_20288# a_120418_19028.t6 VDDD.t236 VDDD.t235 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X127 a_55838_19028.t0 a_54210_19028.t5 VSSD.t227 VSSD.t226 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X128 a_77058_20288# a_75418_19028.t6 VDDD.t123 VDDD.t122 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X129 a_114210_19028.t4 a_113226_19028.t5 a_114210_20288# VDDD.t225 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X130 a_154862_19260# a_150418_19028.t4 VSSD.t207 VSSD.t206 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X131 a_69210_19028.t3 a_68226_19028.t5 a_69210_20288# VDDD.t226 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X132 a_68226_19028.t2 a_66162_19260.t4 a_70838_19028.t1 VDDD.t183 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X133 a_152058_19028.t3 Set a_152058_20288# VDDD.t148 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X134 a_137058_19028.t0 a_135418_19028.t5 VSSD.t239 VSSD.t238 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X135 a_9210_19028.t2 a_8226_19028.t5 a_9210_20288# VDDD.t79 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X136 a_15418_19028.t3 clks.t20 VSSD.t137 VSSD.t136 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X137 VSSD.t248 a_128226_19028.t4 a_129210_19028.t3 VSSD.t247 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X138 a_30418_19028.t1 a_29294_19028# a_30418_20288# VDDD.t4 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X139 a_128226_19028.t1 a_126982_19260.t4 a_130838_19028.t1 VSSD.t113 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X140 a_83226_19028.t3 a_81162_19260.t2 a_75418_19028.t0 VSSD.t56 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X141 a_83226_19028.t0 a_81982_19260.t2 a_85838_19028.t2 VSSD.t244 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X142 a_19862_19260# a_15418_19028.t7 VDDD.t213 VDDD.t212 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X143 a_100838_20288# a_99210_19028.t6 VDDD.t7 VDDD.t6 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X144 a_n4162_19028.t0 a_n5790_19028.t5 VSSD.t53 VSSD.t52 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X145 a_29294_19028# a_21982_19260.t4 a_32058_19028.t0 VDDD.t125 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X146 a_145838_19028.t3 clks.t21 a_145838_20288# VDDD.t175 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X147 VSSD.t7 a_44294_19028# a_45418_19028.t1 VSSD.t6 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X148 a_55838_20288# a_54210_19028.t6 VDDD.t182 VDDD.t181 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X149 a_21162_19260.t0 Valid VDDD.t40 VDDD.t39 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X150 a_14294_19028# a_6982_19260.t3 a_9210_19028.t0 VSSD.t243 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X151 a_115838_19028.t0 a_114210_19028.t5 VSSD.t232 VSSD.t231 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X152 a_81982_19260.t0 a_81162_19260.t3 VDDD.t67 VDDD.t66 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X153 a_137058_20288# a_135418_19028.t6 VDDD.t192 VDDD.t191 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X154 a_24210_19028.t4 Set VSSD.t185 VSSD.t184 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X155 a_36982_19260.t1 a_36162_19260.t5 VSSD.t51 VSSD.t50 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X156 a_44294_19028# a_36162_19260.t6 a_47058_19028.t4 VSSD.t249 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X157 a_15418_20288# clks.t22 VDDD.t177 VDDD.t176 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X158 a_129210_19028.t4 a_128226_19028.t5 a_129210_20288# VDDD.t201 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X159 a_83226_19028.t1 a_81982_19260.t3 a_75418_19028.t2 VDDD.t194 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X160 a_128226_19028.t3 a_126162_19260.t5 a_130838_19028.t4 VDDD.t14 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X161 a_n8838_19260.t1 Valid VSSD.t32 VSSD.t31 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X162 a_n4162_20288# a_n5790_19028.t6 VDDD.t19 VDDD.t18 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X163 a_83226_19028.t2 a_81162_19260.t4 a_85838_19028.t4 VDDD.t228 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X164 a_143226_19028.t2 a_141162_19260.t2 a_135418_19028.t3 VSSD.t16 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X165 a_45418_19028.t0 a_44294_19028# a_45418_20288# VDDD.t11 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X166 VSSD.t183 Set a_17058_19028.t3 VSSD.t182 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X167 a_143226_19028.t1 a_141982_19260.t2 a_145838_19028.t1 VSSD.t17 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X168 a_98226_19028.t1 a_96162_19260.t3 a_90418_19028.t3 VSSD.t90 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X169 VSSD.t48 a_104294_19028# a_105418_19028.t3 VSSD.t47 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X170 a_14294_19028# a_6162_19260.t4 a_9210_19028.t1 VDDD.t223 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X171 a_44294_19028# a_36982_19260.t4 a_47058_19028.t0 VDDD.t239 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X172 a_115838_20288# a_114210_19028.t6 VDDD.t190 VDDD.t189 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X173 a_24210_20288# Set VDDD.t147 VDDD.t146 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X174 a_141982_19260.t0 a_141162_19260.t3 VDDD.t21 VDDD.t20 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X175 a_104294_19028# a_96162_19260.t4 a_107058_19028.t2 VSSD.t87 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X176 a_60418_19028.t3 clks.t23 VSSD.t135 VSSD.t134 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X177 a_36162_19260.t0 Valid VDDD.t38 VDDD.t37 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X178 a_29294_19028# a_21982_19260.t5 a_24210_19028.t0 VSSD.t108 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X179 a_96982_19260.t0 a_96162_19260.t5 VDDD.t107 VDDD.t106 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X180 a_n706_19028# a_n8018_19260.t4 a_n5790_19028.t4 VSSD.t92 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X181 a_39210_19028.t4 Set VSSD.t181 VSSD.t180 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X182 a_n8018_19260.t0 a_n8838_19260.t3 VDDD.t90 VDDD.t89 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X183 a_64862_19260# a_60418_19028.t7 VDDD.t61 VDDD.t60 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X184 a_143226_19028.t0 a_141982_19260.t3 a_135418_19028.t0 VDDD.t1 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X185 VSSD.t219 a_n6774_19028.t4 a_n5790_19028.t3 VSSD.t218 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X186 a_19862_19260# a_15418_19028.t8 VSSD.t253 VSSD.t252 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X187 VSSD.t46 a_89294_19028# a_90418_19028.t2 VSSD.t45 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X188 a_4862_19260# a_418_19028.t7 VDDD.t65 VDDD.t64 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X189 a_143226_19028.t3 a_141162_19260.t4 a_145838_19028.t2 VDDD.t74 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X190 a_17058_19028.t2 Set a_17058_20288# VDDD.t145 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X191 a_98226_19028.t2 a_96982_19260.t3 a_90418_19028.t0 VDDD.t109 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X192 a_105418_19028.t2 a_104294_19028# a_105418_20288# VDDD.t56 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X193 a_21162_19260.t1 Valid VSSD.t30 VSSD.t29 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X194 VSSD.t133 clks.t24 a_40838_19028.t4 VSSD.t132 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X195 a_89294_19028# a_81162_19260.t5 a_92058_19028.t4 VSSD.t269 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X196 a_81982_19260.t1 a_81162_19260.t6 VSSD.t246 VSSD.t245 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X197 a_60418_20288# clks.t25 VDDD.t179 VDDD.t178 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X198 a_104294_19028# a_96982_19260.t4 a_107058_19028.t1 VDDD.t168 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X199 a_n706_19028# a_n8838_19260.t4 a_n5790_19028.t1 VDDD.t91 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X200 a_29294_19028# a_21162_19260.t7 a_24210_19028.t3 VDDD.t164 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X201 a_32058_19028.t4 a_30418_19028.t6 VSSD.t285 VSSD.t284 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X202 a_120418_19028.t3 clks.t26 VSSD.t131 VSSD.t130 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X203 a_39210_20288# Set VDDD.t144 VDDD.t143 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X204 a_418_19028.t1 clks.t27 VSSD.t129 VSSD.t128 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X205 VSSD.t103 a_23226_19028.t4 a_24210_19028.t2 VSSD.t102 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X206 a_n5790_19028.t2 a_n6774_19028.t5 a_n5790_20288# VDDD.t170 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X207 a_90418_19028.t1 a_89294_19028# a_90418_20288# VDDD.t55 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X208 a_75418_19028.t1 clks.t28 VSSD.t127 VSSD.t126 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X209 a_124862_19260# a_120418_19028.t7 VDDD.t186 VDDD.t185 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X210 VSSD.t179 Set a_62058_19028.t2 VSSD.t178 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X211 VSSD.t177 Set a_2058_19028.t1 VSSD.t176 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X212 VSSD.t9 a_149294_19028# a_150418_19028.t1 VSSD.t8 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X213 a_40838_19028.t3 clks.t29 a_40838_20288# VDDD.t5 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X214 a_79862_19260# a_75418_19028.t7 VDDD.t172 VDDD.t171 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X215 a_89294_19028# a_81982_19260.t4 a_92058_19028.t3 VDDD.t227 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X216 a_149294_19028# a_141162_19260.t5 a_152058_19028.t2 VSSD.t63 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X217 VSSD.t125 clks.t30 a_100838_19028.t3 VSSD.t124 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X218 a_81162_19260.t0 Valid VDDD.t36 VDDD.t35 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X219 a_10838_19028.t0 a_9210_19028.t5 VSSD.t86 VSSD.t85 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X220 a_141982_19260.t1 a_141162_19260.t6 VSSD.t1 VSSD.t0 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X221 a_32058_20288# a_30418_19028.t7 VDDD.t241 VDDD.t240 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X222 a_36162_19260.t1 Valid VSSD.t28 VSSD.t27 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X223 VSSD.t123 clks.t31 a_55838_19028.t4 VSSD.t122 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X224 a_96982_19260.t1 a_96162_19260.t6 VSSD.t89 VSSD.t88 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X225 a_84210_19028.t2 Set VSSD.t175 VSSD.t174 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X226 a_74294_19028# a_66982_19260.t4 a_69210_19028.t0 VSSD.t225 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X227 a_120418_20288# clks.t32 VDDD.t23 VDDD.t22 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X228 a_418_20288# clks.t33 VDDD.t25 VDDD.t24 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X229 a_24210_19028.t1 a_23226_19028.t5 a_24210_20288# VDDD.t121 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X230 a_75418_20288# clks.t34 VDDD.t27 VDDD.t26 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X231 a_n8018_19260.t1 a_n8838_19260.t5 VSSD.t76 VSSD.t75 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X232 a_64862_19260# a_60418_19028.t8 VSSD.t213 VSSD.t212 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X233 a_4862_19260# a_418_19028.t8 VSSD.t55 VSSD.t54 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X234 a_47058_19028.t1 a_45418_19028.t7 VSSD.t58 VSSD.t57 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X235 a_62058_19028.t1 Set a_62058_20288# VDDD.t142 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X236 a_150418_19028.t0 a_149294_19028# a_150418_20288# VDDD.t12 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X237 a_135418_19028.t4 clks.t35 VSSD.t121 VSSD.t120 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X238 a_2058_19028.t0 Set a_2058_20288# VDDD.t141 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X239 VSSD.t98 a_38226_19028.t4 a_39210_19028.t3 VSSD.t97 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X240 VSSD.t173 Set a_122058_19028.t3 VSSD.t172 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X241 a_n5790_19028.t0 Set VSSD.t171 VSSD.t170 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X242 a_38226_19028.t0 a_36982_19260.t5 a_40838_19028.t1 VSSD.t64 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X243 a_100838_19028.t2 clks.t36 a_100838_20288# VDDD.t75 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X244 a_139862_19260# a_135418_19028.t7 VDDD.t114 VDDD.t113 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X245 a_149294_19028# a_141982_19260.t4 a_152058_19028.t0 VDDD.t2 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X246 VSSD.t169 Set a_77058_19028.t2 VSSD.t168 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X247 a_10838_20288# a_9210_19028.t6 VDDD.t104 VDDD.t103 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X248 a_55838_19028.t3 clks.t37 a_55838_20288# VDDD.t76 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X249 a_74294_19028# a_66162_19260.t5 a_69210_19028.t1 VDDD.t184 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X250 a_84210_20288# Set VDDD.t140 VDDD.t139 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X251 a_141162_19260.t0 Valid VDDD.t34 VDDD.t33 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X252 a_134294_19028# a_126982_19260.t5 a_129210_19028.t0 VSSD.t112 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X253 VSSD.t119 clks.t38 a_115838_19028.t4 VSSD.t118 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X254 a_96162_19260.t0 Valid VDDD.t32 VDDD.t31 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X255 a_25838_19028.t4 a_24210_19028.t5 VSSD.t281 VSSD.t280 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X256 a_144210_19028.t3 Set VSSD.t167 VSSD.t166 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X257 a_89294_19028# a_81982_19260.t5 a_84210_19028.t4 VSSD.t268 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X258 a_47058_20288# a_45418_19028.t8 VDDD.t71 VDDD.t70 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X259 a_124862_19260# a_120418_19028.t8 VSSD.t230 VSSD.t229 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X260 a_99210_19028.t4 Set VSSD.t165 VSSD.t164 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X261 a_135418_20288# clks.t39 VDDD.t78 VDDD.t77 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X262 a_107058_19028.t0 a_105418_19028.t7 VSSD.t259 VSSD.t258 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X263 a_39210_19028.t2 a_38226_19028.t5 a_39210_20288# VDDD.t84 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X264 a_38226_19028.t2 a_36162_19260.t7 a_40838_19028.t2 VDDD.t202 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X265 a_122058_19028.t4 Set a_122058_20288# VDDD.t138 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X266 a_79862_19260# a_75418_19028.t8 VSSD.t221 VSSD.t220 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X267 a_n5790_20288# Set VDDD.t137 VDDD.t136 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X268 a_77058_19028.t1 Set a_77058_20288# VDDD.t135 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X269 a_53226_19028.t0 a_51162_19260.t3 a_45418_19028.t3 VSSD.t81 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X270 a_98226_19028.t3 a_96982_19260.t5 a_100838_19028.t1 VSSD.t222 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X271 a_81162_19260.t1 Valid VSSD.t26 VSSD.t25 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X272 a_53226_19028.t2 a_51982_19260.t4 a_55838_19028.t2 VSSD.t72 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X273 VSSD.t163 Set a_137058_19028.t4 VSSD.t162 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X274 a_25838_20288# a_24210_19028.t6 VDDD.t29 VDDD.t28 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X275 a_115838_19028.t3 clks.t40 a_115838_20288# VDDD.t8 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X276 a_134294_19028# a_126162_19260.t6 a_129210_19028.t1 VDDD.t126 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X277 a_144210_20288# Set VDDD.t134 VDDD.t133 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X278 VSSD.t44 a_14294_19028# a_15418_19028.t0 VSSD.t43 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X279 a_89294_19028# a_81162_19260.t7 a_84210_19028.t3 VDDD.t200 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X280 a_92058_19028.t2 a_90418_19028.t7 VSSD.t68 VSSD.t67 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X281 a_99210_20288# Set VDDD.t132 VDDD.t131 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X282 a_14294_19028# a_6162_19260.t5 a_17058_19028.t1 VSSD.t263 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X283 VSSD.t19 a_83226_19028.t4 a_84210_19028.t0 VSSD.t18 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X284 a_51982_19260.t0 a_51162_19260.t4 VDDD.t95 VDDD.t94 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X285 a_107058_20288# a_105418_19028.t8 VDDD.t217 VDDD.t216 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X286 a_149294_19028# a_141982_19260.t5 a_144210_19028.t1 VSSD.t20 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X287 a_98226_19028.t0 a_96162_19260.t7 a_100838_19028.t4 VDDD.t105 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X288 a_139862_19260# a_135418_19028.t8 VSSD.t95 VSSD.t94 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X289 a_53226_19028.t3 a_51982_19260.t5 a_45418_19028.t2 VDDD.t30 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X290 a_53226_19028.t1 a_51162_19260.t5 a_55838_19028.t1 VDDD.t96 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X291 a_137058_19028.t3 Set a_137058_20288# VDDD.t130 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X292 a_141162_19260.t1 Valid VSSD.t24 VSSD.t23 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X293 a_113226_19028.t0 a_111162_19260.t5 a_105418_19028.t0 VSSD.t101 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X294 a_15418_19028.t1 a_14294_19028# a_15418_20288# VDDD.t54 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X295 a_113226_19028.t3 a_111982_19260.t4 a_115838_19028.t2 VSSD.t60 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X296 a_70838_19028.t2 a_69210_19028.t5 VSSD.t80 VSSD.t79 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X297 a_96162_19260.t1 Valid VSSD.t22 VSSD.t21 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X298 a_68226_19028.t3 a_66162_19260.t6 a_60418_19028.t4 VSSD.t228 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X299 a_92058_20288# a_90418_19028.t8 VDDD.t233 VDDD.t232 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X300 a_8226_19028.t3 a_6162_19260.t6 a_418_19028.t4 VSSD.t260 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X301 a_14294_19028# a_6982_19260.t4 a_17058_19028.t0 VDDD.t193 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X302 a_84210_19028.t1 a_83226_19028.t5 a_84210_20288# VDDD.t68 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X303 a_149294_19028# a_141162_19260.t7 a_144210_19028.t0 VDDD.t0 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X304 a_152058_19028.t1 a_150418_19028.t5 VSSD.t265 VSSD.t264 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X305 a_111982_19260.t0 a_111162_19260.t6 VDDD.t118 VDDD.t117 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X306 a_30418_19028.t4 clks.t41 VSSD.t117 VSSD.t116 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X307 VSSD.t267 a_143226_19028.t4 a_144210_19028.t4 VSSD.t266 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X308 a_66982_19260.t0 a_66162_19260.t7 VDDD.t238 VDDD.t237 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X309 VSSD.t11 a_98226_19028.t5 a_99210_19028.t1 VSSD.t10 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X310 a_6982_19260.t0 a_6162_19260.t7 VDDD.t221 VDDD.t220 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X311 a_34862_19260# a_30418_19028.t8 VDDD.t188 VDDD.t187 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X312 a_113226_19028.t2 a_111982_19260.t5 a_105418_19028.t1 VDDD.t180 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X313 VSSD.t217 a_59294_19028# a_60418_19028.t1 VSSD.t216 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X314 a_70838_20288# a_69210_19028.t6 VDDD.t93 VDDD.t92 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X315 a_113226_19028.t1 a_111162_19260.t7 a_115838_19028.t1 VDDD.t119 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X316 a_68226_19028.t1 a_66982_19260.t5 a_60418_19028.t0 VDDD.t72 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X317 a_130838_19028.t0 a_129210_19028.t6 VSSD.t62 VSSD.t61 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X318 a_8226_19028.t1 a_6982_19260.t5 a_418_19028.t0 VDDD.t110 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X319 VSSD.t115 clks.t42 a_10838_19028.t2 VSSD.t114 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X320 a_128226_19028.t2 a_126162_19260.t7 a_120418_19028.t4 VSSD.t158 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X321 a_59294_19028# a_51162_19260.t6 a_62058_19028.t4 VSSD.t240 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X322 a_152058_20288# a_150418_19028.t6 VDDD.t205 VDDD.t204 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X323 a_n6774_19028.t0 a_n8018_19260.t5 a_n4162_19028.t1 VSSD.t91 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X324 a_n706_19028# a_n8838_19260.t6 a_2058_19028.t3 VSSD.t77 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X325 a_51982_19260.t1 a_51162_19260.t7 VSSD.t242 VSSD.t241 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X326 a_85838_19028.t3 a_84210_19028.t6 VSSD.t224 VSSD.t223 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X327 a_144210_19028.t2 a_143226_19028.t5 a_144210_20288# VDDD.t53 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X328 a_n6774_19028.t2 a_n8838_19260.t7 D.t0 VSSD.t78 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X329 a_30418_20288# clks.t43 VDDD.t10 VDDD.t9 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
R0 a_98226_19028.n1 a_98226_19028.t4 75.0252
R1 a_98226_19028.n1 a_98226_19028.t5 44.0697
R2 a_98226_19028.n2 a_98226_19028.t3 10.6055
R3 a_98226_19028.n0 a_98226_19028.t1 10.6055
R4 a_98226_19028.n2 a_98226_19028.n0 8.89791
R5 a_98226_19028.n0 a_98226_19028.n1 5.7951
R6 a_98226_19028.t0 a_98226_19028.n2 4.53117
R7 a_98226_19028.n0 a_98226_19028.t2 4.53024
R8 a_99210_19028.n0 a_99210_19028.t6 74.8588
R9 a_99210_19028.n0 a_99210_19028.t5 44.2362
R10 a_99210_19028.n0 a_99210_19028.n2 14.5242
R11 a_99210_19028.n2 a_99210_19028.t3 11.0089
R12 a_99210_19028.n3 a_99210_19028.n1 5.39574
R13 a_99210_19028.t0 a_99210_19028.n3 4.91248
R14 a_99210_19028.n2 a_99210_19028.t2 4.12478
R15 a_99210_19028.n1 a_99210_19028.t1 3.7821
R16 a_99210_19028.n1 a_99210_19028.t4 3.77824
R17 a_99210_19028.n3 a_99210_19028.n0 1.83141
R18 VDDD.t112 VDDD.t89 1051.92
R19 VDDD.t1 VDDD.t20 1051.92
R20 VDDD.t3 VDDD.t214 1051.92
R21 VDDD.t180 VDDD.t117 1051.92
R22 VDDD.t109 VDDD.t106 1051.92
R23 VDDD.t194 VDDD.t66 1051.92
R24 VDDD.t72 VDDD.t237 1051.92
R25 VDDD.t30 VDDD.t94 1051.92
R26 VDDD.t163 VDDD.t62 1051.92
R27 VDDD.t124 VDDD.t166 1051.92
R28 VDDD.t220 VDDD.t110 1051.92
R29 VDDD.t91 VDDD.t88 984
R30 VDDD.t0 VDDD.t74 984
R31 VDDD.t126 VDDD.t14 984
R32 VDDD.t120 VDDD.t119 984
R33 VDDD.t108 VDDD.t105 984
R34 VDDD.t200 VDDD.t228 984
R35 VDDD.t184 VDDD.t183 984
R36 VDDD.t129 VDDD.t96 984
R37 VDDD.t69 VDDD.t202 984
R38 VDDD.t164 VDDD.t165 984
R39 VDDD.t222 VDDD.t223 984
R40 VDDD.t88 VDDD.t197 909.333
R41 VDDD.t74 VDDD.t175 909.333
R42 VDDD.t14 VDDD.t101 909.333
R43 VDDD.t119 VDDD.t8 909.333
R44 VDDD.t105 VDDD.t75 909.333
R45 VDDD.t228 VDDD.t102 909.333
R46 VDDD.t183 VDDD.t98 909.333
R47 VDDD.t96 VDDD.t76 909.333
R48 VDDD.t202 VDDD.t5 909.333
R49 VDDD.t165 VDDD.t231 909.333
R50 VDDD.t57 VDDD.t222 909.333
R51 VDDD.t111 VDDD.t141 781.333
R52 VDDD.t2 VDDD.t148 781.333
R53 VDDD.t15 VDDD.t130 781.333
R54 VDDD.t73 VDDD.t138 781.333
R55 VDDD.t168 VDDD.t152 781.333
R56 VDDD.t227 VDDD.t149 781.333
R57 VDDD.t224 VDDD.t135 781.333
R58 VDDD.t85 VDDD.t142 781.333
R59 VDDD.t239 VDDD.t159 781.333
R60 VDDD.t125 VDDD.t162 781.333
R61 VDDD.t145 VDDD.t193 781.333
R62 VDDD.t24 VDDD.t91 749.333
R63 VDDD.t99 VDDD.t0 749.333
R64 VDDD.t77 VDDD.t126 749.333
R65 VDDD.t22 VDDD.t120 749.333
R66 VDDD.t195 VDDD.t108 749.333
R67 VDDD.t198 VDDD.t200 749.333
R68 VDDD.t26 VDDD.t184 749.333
R69 VDDD.t178 VDDD.t129 749.333
R70 VDDD.t58 VDDD.t69 749.333
R71 VDDD.t9 VDDD.t164 749.333
R72 VDDD.t223 VDDD.t176 749.333
R73 VDDD.t82 VDDD.t203 682.668
R74 VDDD.t204 VDDD.t12 682.668
R75 VDDD.t191 VDDD.t16 682.668
R76 VDDD.t235 VDDD.t17 682.668
R77 VDDD.t216 VDDD.t56 682.668
R78 VDDD.t232 VDDD.t55 682.668
R79 VDDD.t122 VDDD.t234 682.668
R80 VDDD.t206 VDDD.t169 682.668
R81 VDDD.t70 VDDD.t11 682.668
R82 VDDD.t240 VDDD.t4 682.668
R83 VDDD.t54 VDDD.t210 682.668
R84 VDDD.t18 VDDD.t170 674.668
R85 VDDD.t86 VDDD.t53 674.668
R86 VDDD.t115 VDDD.t201 674.668
R87 VDDD.t189 VDDD.t225 674.668
R88 VDDD.t6 VDDD.t13 674.668
R89 VDDD.t173 VDDD.t68 674.668
R90 VDDD.t92 VDDD.t226 674.668
R91 VDDD.t181 VDDD.t97 674.668
R92 VDDD.t127 VDDD.t84 674.668
R93 VDDD.t28 VDDD.t121 674.668
R94 VDDD.t79 VDDD.t103 674.668
R95 VDDD.t136 VDDD.t112 656
R96 VDDD.t133 VDDD.t1 656
R97 VDDD.t150 VDDD.t3 656
R98 VDDD.t157 VDDD.t180 656
R99 VDDD.t131 VDDD.t109 656
R100 VDDD.t139 VDDD.t194 656
R101 VDDD.t155 VDDD.t72 656
R102 VDDD.t160 VDDD.t30 656
R103 VDDD.t143 VDDD.t163 656
R104 VDDD.t146 VDDD.t124 656
R105 VDDD.t110 VDDD.t153 656
R106 VDDD.n116 VDDD.t111 611.111
R107 VDDD.n24 VDDD.t2 611.111
R108 VDDD.n32 VDDD.t15 611.111
R109 VDDD.n41 VDDD.t73 611.111
R110 VDDD.n50 VDDD.t168 611.111
R111 VDDD.n59 VDDD.t227 611.111
R112 VDDD.n68 VDDD.t224 611.111
R113 VDDD.n77 VDDD.t85 611.111
R114 VDDD.n86 VDDD.t239 611.111
R115 VDDD.n95 VDDD.t125 611.111
R116 VDDD.t193 VDDD.n105 611.111
R117 VDDD.n115 VDDD.t41 532.197
R118 VDDD.n23 VDDD.t33 532.197
R119 VDDD.n31 VDDD.t43 532.197
R120 VDDD.n40 VDDD.t49 532.197
R121 VDDD.n49 VDDD.t31 532.197
R122 VDDD.n58 VDDD.t35 532.197
R123 VDDD.n67 VDDD.t47 532.197
R124 VDDD.n76 VDDD.t51 532.197
R125 VDDD.n85 VDDD.t37 532.197
R126 VDDD.n94 VDDD.t39 532.197
R127 VDDD.t45 VDDD.n106 532.197
R128 VDDD.t141 VDDD.t82 410.668
R129 VDDD.t203 VDDD.t24 410.668
R130 VDDD.t197 VDDD.t18 410.668
R131 VDDD.t170 VDDD.t136 410.668
R132 VDDD.t148 VDDD.t204 410.668
R133 VDDD.t12 VDDD.t99 410.668
R134 VDDD.t175 VDDD.t86 410.668
R135 VDDD.t53 VDDD.t133 410.668
R136 VDDD.t130 VDDD.t191 410.668
R137 VDDD.t16 VDDD.t77 410.668
R138 VDDD.t101 VDDD.t115 410.668
R139 VDDD.t201 VDDD.t150 410.668
R140 VDDD.t138 VDDD.t235 410.668
R141 VDDD.t17 VDDD.t22 410.668
R142 VDDD.t8 VDDD.t189 410.668
R143 VDDD.t225 VDDD.t157 410.668
R144 VDDD.t152 VDDD.t216 410.668
R145 VDDD.t56 VDDD.t195 410.668
R146 VDDD.t75 VDDD.t6 410.668
R147 VDDD.t13 VDDD.t131 410.668
R148 VDDD.t149 VDDD.t232 410.668
R149 VDDD.t55 VDDD.t198 410.668
R150 VDDD.t102 VDDD.t173 410.668
R151 VDDD.t68 VDDD.t139 410.668
R152 VDDD.t135 VDDD.t122 410.668
R153 VDDD.t234 VDDD.t26 410.668
R154 VDDD.t98 VDDD.t92 410.668
R155 VDDD.t226 VDDD.t155 410.668
R156 VDDD.t142 VDDD.t206 410.668
R157 VDDD.t169 VDDD.t178 410.668
R158 VDDD.t76 VDDD.t181 410.668
R159 VDDD.t97 VDDD.t160 410.668
R160 VDDD.t159 VDDD.t70 410.668
R161 VDDD.t11 VDDD.t58 410.668
R162 VDDD.t5 VDDD.t127 410.668
R163 VDDD.t84 VDDD.t143 410.668
R164 VDDD.t162 VDDD.t240 410.668
R165 VDDD.t4 VDDD.t9 410.668
R166 VDDD.t231 VDDD.t28 410.668
R167 VDDD.t121 VDDD.t146 410.668
R168 VDDD.t210 VDDD.t145 410.668
R169 VDDD.t176 VDDD.t54 410.668
R170 VDDD.t103 VDDD.t57 410.668
R171 VDDD.t153 VDDD.t79 410.668
R172 VDDD.n116 VDDD.t64 260.606
R173 VDDD.n24 VDDD.t208 260.606
R174 VDDD.n32 VDDD.t113 260.606
R175 VDDD.n41 VDDD.t185 260.606
R176 VDDD.n50 VDDD.t218 260.606
R177 VDDD.n59 VDDD.t80 260.606
R178 VDDD.n68 VDDD.t171 260.606
R179 VDDD.n77 VDDD.t60 260.606
R180 VDDD.n86 VDDD.t229 260.606
R181 VDDD.n95 VDDD.t187 260.606
R182 VDDD.n105 VDDD.t212 260.606
R183 VDDD.n112 VDDD.t41 246.119
R184 VDDD.t33 VDDD.n22 246.119
R185 VDDD.t43 VDDD.n20 246.119
R186 VDDD.t49 VDDD.n18 246.119
R187 VDDD.t31 VDDD.n16 246.119
R188 VDDD.t35 VDDD.n14 246.119
R189 VDDD.t47 VDDD.n12 246.119
R190 VDDD.t51 VDDD.n10 246.119
R191 VDDD.t37 VDDD.n8 246.119
R192 VDDD.t39 VDDD.n6 246.119
R193 VDDD.n107 VDDD.t45 246.119
R194 VDDD.t89 VDDD.n115 244.319
R195 VDDD.t20 VDDD.n23 244.319
R196 VDDD.t214 VDDD.n31 244.319
R197 VDDD.t117 VDDD.n40 244.319
R198 VDDD.t106 VDDD.n49 244.319
R199 VDDD.t66 VDDD.n58 244.319
R200 VDDD.t237 VDDD.n67 244.319
R201 VDDD.t94 VDDD.n76 244.319
R202 VDDD.t62 VDDD.n85 244.319
R203 VDDD.t166 VDDD.n94 244.319
R204 VDDD.n106 VDDD.t220 244.319
R205 VDDD.n109 VDDD.t25 1.85009
R206 VDDD.n3 VDDD.t177 1.85009
R207 VDDD.n99 VDDD.t10 1.85009
R208 VDDD.n90 VDDD.t59 1.85009
R209 VDDD.n81 VDDD.t179 1.85009
R210 VDDD.n72 VDDD.t27 1.85009
R211 VDDD.n63 VDDD.t199 1.85009
R212 VDDD.n54 VDDD.t196 1.85009
R213 VDDD.n45 VDDD.t23 1.85009
R214 VDDD.n36 VDDD.t78 1.85009
R215 VDDD.n27 VDDD.t100 1.85009
R216 VDDD.n108 VDDD.t83 1.85009
R217 VDDD.n111 VDDD.t137 1.85009
R218 VDDD.n110 VDDD.t19 1.85009
R219 VDDD.n0 VDDD.t154 1.85009
R220 VDDD.n2 VDDD.t104 1.85009
R221 VDDD.n4 VDDD.t211 1.85009
R222 VDDD.n101 VDDD.t147 1.85009
R223 VDDD.n100 VDDD.t29 1.85009
R224 VDDD.n98 VDDD.t241 1.85009
R225 VDDD.n92 VDDD.t144 1.85009
R226 VDDD.n91 VDDD.t128 1.85009
R227 VDDD.n89 VDDD.t71 1.85009
R228 VDDD.n83 VDDD.t161 1.85009
R229 VDDD.n82 VDDD.t182 1.85009
R230 VDDD.n80 VDDD.t207 1.85009
R231 VDDD.n74 VDDD.t156 1.85009
R232 VDDD.n73 VDDD.t93 1.85009
R233 VDDD.n71 VDDD.t123 1.85009
R234 VDDD.n65 VDDD.t140 1.85009
R235 VDDD.n64 VDDD.t174 1.85009
R236 VDDD.n62 VDDD.t233 1.85009
R237 VDDD.n56 VDDD.t132 1.85009
R238 VDDD.n55 VDDD.t7 1.85009
R239 VDDD.n53 VDDD.t217 1.85009
R240 VDDD.n47 VDDD.t158 1.85009
R241 VDDD.n46 VDDD.t190 1.85009
R242 VDDD.n44 VDDD.t236 1.85009
R243 VDDD.n38 VDDD.t151 1.85009
R244 VDDD.n37 VDDD.t116 1.85009
R245 VDDD.n35 VDDD.t192 1.85009
R246 VDDD.n29 VDDD.t134 1.85009
R247 VDDD.n28 VDDD.t87 1.85009
R248 VDDD.n26 VDDD.t205 1.85009
R249 VDDD.n115 VDDD.n114 1.8005
R250 VDDD.n117 VDDD.n116 1.8005
R251 VDDD.n25 VDDD.n24 1.8005
R252 VDDD.n23 VDDD.n21 1.8005
R253 VDDD.n33 VDDD.n32 1.8005
R254 VDDD.n31 VDDD.n19 1.8005
R255 VDDD.n42 VDDD.n41 1.8005
R256 VDDD.n40 VDDD.n17 1.8005
R257 VDDD.n51 VDDD.n50 1.8005
R258 VDDD.n49 VDDD.n15 1.8005
R259 VDDD.n60 VDDD.n59 1.8005
R260 VDDD.n58 VDDD.n13 1.8005
R261 VDDD.n69 VDDD.n68 1.8005
R262 VDDD.n67 VDDD.n11 1.8005
R263 VDDD.n78 VDDD.n77 1.8005
R264 VDDD.n76 VDDD.n9 1.8005
R265 VDDD.n87 VDDD.n86 1.8005
R266 VDDD.n85 VDDD.n7 1.8005
R267 VDDD.n96 VDDD.n95 1.8005
R268 VDDD.n94 VDDD.n5 1.8005
R269 VDDD.n105 VDDD.n104 1.8005
R270 VDDD.n106 VDDD.n1 1.8005
R271 VDDD.n114 VDDD.t90 1.4972
R272 VDDD.n112 VDDD.t42 1.4972
R273 VDDD.n117 VDDD.t65 1.4972
R274 VDDD.n107 VDDD.t46 1.4972
R275 VDDD.n104 VDDD.t213 1.4972
R276 VDDD.n6 VDDD.t40 1.4972
R277 VDDD.n96 VDDD.t188 1.4972
R278 VDDD.n8 VDDD.t38 1.4972
R279 VDDD.n87 VDDD.t230 1.4972
R280 VDDD.n10 VDDD.t52 1.4972
R281 VDDD.n78 VDDD.t61 1.4972
R282 VDDD.n12 VDDD.t48 1.4972
R283 VDDD.n69 VDDD.t172 1.4972
R284 VDDD.n14 VDDD.t36 1.4972
R285 VDDD.n60 VDDD.t81 1.4972
R286 VDDD.n16 VDDD.t32 1.4972
R287 VDDD.n51 VDDD.t219 1.4972
R288 VDDD.n18 VDDD.t50 1.4972
R289 VDDD.n42 VDDD.t186 1.4972
R290 VDDD.n20 VDDD.t44 1.4972
R291 VDDD.n33 VDDD.t114 1.4972
R292 VDDD.n22 VDDD.t34 1.4972
R293 VDDD.n25 VDDD.t209 1.4972
R294 VDDD.n21 VDDD.t21 1.4972
R295 VDDD.n19 VDDD.t215 1.4972
R296 VDDD.n17 VDDD.t118 1.4972
R297 VDDD.n15 VDDD.t107 1.4972
R298 VDDD.n13 VDDD.t67 1.4972
R299 VDDD.n11 VDDD.t238 1.4972
R300 VDDD.n9 VDDD.t95 1.4972
R301 VDDD.n7 VDDD.t63 1.4972
R302 VDDD.n5 VDDD.t167 1.4972
R303 VDDD.n1 VDDD.t221 1.4972
R304 VDDD.n26 VDDD.n25 0.678275
R305 VDDD.n118 VDDD.n117 0.57852
R306 VDDD.n34 VDDD.n33 0.57852
R307 VDDD.n43 VDDD.n42 0.57852
R308 VDDD.n52 VDDD.n51 0.57852
R309 VDDD.n61 VDDD.n60 0.57852
R310 VDDD.n70 VDDD.n69 0.57852
R311 VDDD.n79 VDDD.n78 0.57852
R312 VDDD.n88 VDDD.n87 0.57852
R313 VDDD.n97 VDDD.n96 0.57852
R314 VDDD.n104 VDDD.n103 0.57852
R315 VDDD.n119 VDDD.n107 0.524086
R316 VDDD.n102 VDDD.n6 0.524086
R317 VDDD.n93 VDDD.n8 0.524086
R318 VDDD.n84 VDDD.n10 0.524086
R319 VDDD.n75 VDDD.n12 0.524086
R320 VDDD.n66 VDDD.n14 0.524086
R321 VDDD.n57 VDDD.n16 0.524086
R322 VDDD.n48 VDDD.n18 0.524086
R323 VDDD.n39 VDDD.n20 0.524086
R324 VDDD.n30 VDDD.n22 0.524086
R325 VDDD.n113 VDDD.n112 0.524086
R326 VDDD.n114 VDDD.n113 0.463526
R327 VDDD.n30 VDDD.n21 0.463526
R328 VDDD.n39 VDDD.n19 0.463526
R329 VDDD.n48 VDDD.n17 0.463526
R330 VDDD.n57 VDDD.n15 0.463526
R331 VDDD.n66 VDDD.n13 0.463526
R332 VDDD.n75 VDDD.n11 0.463526
R333 VDDD.n84 VDDD.n9 0.463526
R334 VDDD.n93 VDDD.n7 0.463526
R335 VDDD.n102 VDDD.n5 0.463526
R336 VDDD.n119 VDDD.n1 0.463526
R337 VDDD.n110 VDDD.n109 0.188641
R338 VDDD.n3 VDDD.n2 0.188641
R339 VDDD.n100 VDDD.n99 0.188641
R340 VDDD.n91 VDDD.n90 0.188641
R341 VDDD.n82 VDDD.n81 0.188641
R342 VDDD.n73 VDDD.n72 0.188641
R343 VDDD.n64 VDDD.n63 0.188641
R344 VDDD.n55 VDDD.n54 0.188641
R345 VDDD.n46 VDDD.n45 0.188641
R346 VDDD.n37 VDDD.n36 0.188641
R347 VDDD.n28 VDDD.n27 0.188641
R348 VDDD.n102 VDDD.n101 0.109612
R349 VDDD.n93 VDDD.n92 0.109612
R350 VDDD.n84 VDDD.n83 0.109612
R351 VDDD.n75 VDDD.n74 0.109612
R352 VDDD.n66 VDDD.n65 0.109612
R353 VDDD.n57 VDDD.n56 0.109612
R354 VDDD.n48 VDDD.n47 0.109612
R355 VDDD.n39 VDDD.n38 0.109612
R356 VDDD.n30 VDDD.n29 0.109612
R357 VDDD.n113 VDDD.n111 0.109612
R358 VDDD.n118 VDDD.n108 0.100255
R359 VDDD.n103 VDDD.n4 0.100255
R360 VDDD.n98 VDDD.n97 0.100255
R361 VDDD.n89 VDDD.n88 0.100255
R362 VDDD.n80 VDDD.n79 0.100255
R363 VDDD.n71 VDDD.n70 0.100255
R364 VDDD.n62 VDDD.n61 0.100255
R365 VDDD.n53 VDDD.n52 0.100255
R366 VDDD.n44 VDDD.n43 0.100255
R367 VDDD.n35 VDDD.n34 0.100255
R368 VDDD VDDD.n0 0.0698756
R369 VDDD.n109 VDDD.n108 0.0684057
R370 VDDD.n4 VDDD.n3 0.0684057
R371 VDDD.n99 VDDD.n98 0.0684057
R372 VDDD.n90 VDDD.n89 0.0684057
R373 VDDD.n81 VDDD.n80 0.0684057
R374 VDDD.n72 VDDD.n71 0.0684057
R375 VDDD.n63 VDDD.n62 0.0684057
R376 VDDD.n54 VDDD.n53 0.0684057
R377 VDDD.n45 VDDD.n44 0.0684057
R378 VDDD.n36 VDDD.n35 0.0684057
R379 VDDD.n27 VDDD.n26 0.0684057
R380 VDDD.n111 VDDD.n110 0.0679124
R381 VDDD.n2 VDDD.n0 0.0679124
R382 VDDD.n101 VDDD.n100 0.0679124
R383 VDDD.n92 VDDD.n91 0.0679124
R384 VDDD.n83 VDDD.n82 0.0679124
R385 VDDD.n74 VDDD.n73 0.0679124
R386 VDDD.n65 VDDD.n64 0.0679124
R387 VDDD.n56 VDDD.n55 0.0679124
R388 VDDD.n47 VDDD.n46 0.0679124
R389 VDDD.n38 VDDD.n37 0.0679124
R390 VDDD.n29 VDDD.n28 0.0679124
R391 VDDD.n119 VDDD.n118 0.0641908
R392 VDDD.n34 VDDD.n30 0.0641908
R393 VDDD.n43 VDDD.n39 0.0641908
R394 VDDD.n52 VDDD.n48 0.0641908
R395 VDDD.n61 VDDD.n57 0.0641908
R396 VDDD.n70 VDDD.n66 0.0641908
R397 VDDD.n79 VDDD.n75 0.0641908
R398 VDDD.n88 VDDD.n84 0.0641908
R399 VDDD.n97 VDDD.n93 0.0641908
R400 VDDD.n103 VDDD.n102 0.0641908
R401 VDDD VDDD.n119 0.0402368
R402 a_60418_19028.n2 a_60418_19028.t6 74.8588
R403 a_60418_19028.n3 a_60418_19028.t7 70.3153
R404 a_60418_19028.n2 a_60418_19028.t5 44.2362
R405 a_60418_19028.n3 a_60418_19028.t8 39.854
R406 a_60418_19028.n4 a_60418_19028.n0 11.62
R407 a_60418_19028.n5 a_60418_19028.t4 11.0089
R408 a_60418_19028.n5 a_60418_19028.n4 8.15804
R409 a_60418_19028.n0 a_60418_19028.n1 5.39574
R410 a_60418_19028.n0 a_60418_19028.t2 4.91248
R411 a_60418_19028.t0 a_60418_19028.n5 4.12612
R412 a_60418_19028.n1 a_60418_19028.t1 3.7821
R413 a_60418_19028.n1 a_60418_19028.t3 3.77824
R414 a_60418_19028.n0 a_60418_19028.n2 3.04286
R415 a_60418_19028.n4 a_60418_19028.n3 2.84345
R416 a_126162_19260.n2 a_126162_19260.t6 82.7757
R417 a_126162_19260.n3 a_126162_19260.t5 82.6424
R418 a_126162_19260.n1 a_126162_19260.t2 70.3153
R419 a_126162_19260.n2 a_126162_19260.t3 55.8264
R420 a_126162_19260.n4 a_126162_19260.t7 51.5658
R421 a_126162_19260.n1 a_126162_19260.t4 39.854
R422 a_126162_19260.n0 a_126162_19260.t1 6.02308
R423 a_126162_19260.n4 a_126162_19260.n3 3.9695
R424 a_126162_19260.n0 a_126162_19260.n4 3.3953
R425 a_126162_19260.n0 a_126162_19260.n1 2.70724
R426 a_126162_19260.t0 a_126162_19260.n0 2.47208
R427 a_126162_19260.n3 a_126162_19260.n2 1.3073
R428 a_126982_19260.n0 a_126982_19260.t3 86.4194
R429 a_126982_19260.n2 a_126982_19260.t2 82.416
R430 a_126982_19260.n1 a_126982_19260.t4 51.8544
R431 a_126982_19260.n0 a_126982_19260.t5 51.8072
R432 a_126982_19260.n3 a_126982_19260.t1 6.28457
R433 a_126982_19260.n2 a_126982_19260.n1 4.1171
R434 a_126982_19260.n3 a_126982_19260.n2 2.66253
R435 a_126982_19260.t0 a_126982_19260.n3 2.21122
R436 a_126982_19260.n1 a_126982_19260.n0 1.3775
R437 clks.n40 clks.t9 75.0252
R438 clks.n36 clks.t1 75.0252
R439 clks.n32 clks.t6 75.0252
R440 clks.n28 clks.t29 75.0252
R441 clks.n24 clks.t37 75.0252
R442 clks.n20 clks.t13 75.0252
R443 clks.n16 clks.t18 75.0252
R444 clks.n12 clks.t36 75.0252
R445 clks.n8 clks.t40 75.0252
R446 clks.n4 clks.t17 75.0252
R447 clks.n1 clks.t21 75.0252
R448 clks.n39 clks.t33 74.8588
R449 clks.n35 clks.t22 74.8588
R450 clks.n31 clks.t43 74.8588
R451 clks.n27 clks.t3 74.8588
R452 clks.n23 clks.t25 74.8588
R453 clks.n19 clks.t34 74.8588
R454 clks.n15 clks.t11 74.8588
R455 clks.n11 clks.t8 74.8588
R456 clks.n7 clks.t32 74.8588
R457 clks.n3 clks.t39 74.8588
R458 clks.n0 clks.t16 74.8588
R459 clks.n39 clks.t27 44.2362
R460 clks.n35 clks.t20 44.2362
R461 clks.n31 clks.t41 44.2362
R462 clks.n27 clks.t0 44.2362
R463 clks.n23 clks.t23 44.2362
R464 clks.n19 clks.t28 44.2362
R465 clks.n15 clks.t7 44.2362
R466 clks.n11 clks.t4 44.2362
R467 clks.n7 clks.t26 44.2362
R468 clks.n3 clks.t35 44.2362
R469 clks.n0 clks.t12 44.2362
R470 clks.n40 clks.t5 44.0697
R471 clks.n36 clks.t42 44.0697
R472 clks.n32 clks.t2 44.0697
R473 clks.n28 clks.t24 44.0697
R474 clks.n24 clks.t31 44.0697
R475 clks.n20 clks.t10 44.0697
R476 clks.n16 clks.t15 44.0697
R477 clks.n12 clks.t30 44.0697
R478 clks.n8 clks.t38 44.0697
R479 clks.n4 clks.t14 44.0697
R480 clks.n1 clks.t19 44.0697
R481 clks.n6 clks.n2 15.3118
R482 clks.n41 clks.n39 12.2256
R483 clks.n37 clks.n35 12.2256
R484 clks.n33 clks.n31 12.2256
R485 clks.n29 clks.n27 12.2256
R486 clks.n25 clks.n23 12.2256
R487 clks.n21 clks.n19 12.2256
R488 clks.n17 clks.n15 12.2256
R489 clks.n13 clks.n11 12.2256
R490 clks.n9 clks.n7 12.2256
R491 clks.n5 clks.n3 12.2256
R492 clks.n2 clks.n0 12.2256
R493 clks.n42 clks.n41 9.1787
R494 clks.n38 clks.n37 9.1787
R495 clks.n34 clks.n33 9.1787
R496 clks.n30 clks.n29 9.1787
R497 clks.n26 clks.n25 9.1787
R498 clks.n22 clks.n21 9.1787
R499 clks.n18 clks.n17 9.1787
R500 clks.n14 clks.n13 9.1787
R501 clks.n10 clks.n9 9.1787
R502 clks.n6 clks.n5 9.1787
R503 clks.n41 clks.n40 9.00265
R504 clks.n37 clks.n36 9.00265
R505 clks.n33 clks.n32 9.00265
R506 clks.n29 clks.n28 9.00265
R507 clks.n25 clks.n24 9.00265
R508 clks.n21 clks.n20 9.00265
R509 clks.n17 clks.n16 9.00265
R510 clks.n13 clks.n12 9.00265
R511 clks.n9 clks.n8 9.00265
R512 clks.n5 clks.n4 9.00265
R513 clks.n2 clks.n1 9.00265
R514 clks.n10 clks.n6 6.14014
R515 clks.n30 clks.n26 6.14014
R516 clks.n42 clks.n38 6.1385
R517 clks.n26 clks.n22 6.13768
R518 clks.n38 clks.n34 6.13768
R519 clks.n18 clks.n14 6.13686
R520 clks.n22 clks.n18 6.13686
R521 clks.n34 clks.n30 6.13441
R522 clks.n14 clks.n10 6.13277
R523 clks clks.n42 0.0426364
R524 VSSD.n262 VSSD.n261 40751.9
R525 VSSD.n71 VSSD.t206 34761.5
R526 VSSD.n41 VSSD.n5 20642.4
R527 VSSD.n55 VSSD.n37 20642.4
R528 VSSD.n56 VSSD.n36 20642.4
R529 VSSD.n70 VSSD.n32 20642.4
R530 VSSD.n71 VSSD.n70 20642.4
R531 VSSD.n36 VSSD.n32 20642.4
R532 VSSD.n56 VSSD.n55 20642.4
R533 VSSD.n41 VSSD.n37 20642.4
R534 VSSD.n261 VSSD.n5 20642.4
R535 VSSD.n72 VSSD.n71 6106.76
R536 VSSD.n70 VSSD.n69 6106.76
R537 VSSD.n65 VSSD.n32 6106.76
R538 VSSD.n61 VSSD.n36 6106.76
R539 VSSD.n57 VSSD.n56 6106.76
R540 VSSD.n55 VSSD.n54 6106.76
R541 VSSD.n50 VSSD.n37 6106.76
R542 VSSD.n46 VSSD.n41 6106.76
R543 VSSD.n42 VSSD.n5 6106.76
R544 VSSD.n261 VSSD.n260 6106.76
R545 VSSD.t92 VSSD.t91 1576.92
R546 VSSD.t272 VSSD.t243 1576.92
R547 VSSD.t109 VSSD.t64 1576.92
R548 VSSD.t82 VSSD.t225 1576.92
R549 VSSD.t93 VSSD.t222 1576.92
R550 VSSD.t113 VSSD.t112 1576.92
R551 VSSD.t20 VSSD.t17 1576.92
R552 VSSD.t59 VSSD.t60 1576.92
R553 VSSD.t268 VSSD.t244 1576.92
R554 VSSD.t71 VSSD.t72 1576.92
R555 VSSD.t108 VSSD.t96 1576.92
R556 VSSD.t91 VSSD.t150 1457.26
R557 VSSD.t114 VSSD.t272 1457.26
R558 VSSD.t64 VSSD.t132 1457.26
R559 VSSD.t146 VSSD.t82 1457.26
R560 VSSD.t222 VSSD.t124 1457.26
R561 VSSD.t142 VSSD.t113 1457.26
R562 VSSD.t17 VSSD.t138 1457.26
R563 VSSD.t60 VSSD.t118 1457.26
R564 VSSD.t244 VSSD.t140 1457.26
R565 VSSD.t72 VSSD.t122 1457.26
R566 VSSD.t96 VSSD.t154 1457.26
R567 VSSD.t78 VSSD.t75 1342.71
R568 VSSD.t236 VSSD.t260 1342.71
R569 VSSD.t49 VSSD.t50 1342.71
R570 VSSD.t234 VSSD.t228 1342.71
R571 VSSD.t90 VSSD.t88 1342.71
R572 VSSD.t159 VSSD.t158 1342.71
R573 VSSD.t16 VSSD.t0 1342.71
R574 VSSD.t101 VSSD.t99 1342.71
R575 VSSD.t56 VSSD.t245 1342.71
R576 VSSD.t81 VSSD.t241 1342.71
R577 VSSD.t211 VSSD.t208 1342.71
R578 VSSD.t77 VSSD.t176 1252.14
R579 VSSD.t182 VSSD.t263 1252.14
R580 VSSD.t249 VSSD.t200 1252.14
R581 VSSD.t168 VSSD.t233 1252.14
R582 VSSD.t87 VSSD.t192 1252.14
R583 VSSD.t162 VSSD.t161 1252.14
R584 VSSD.t63 VSSD.t186 1252.14
R585 VSSD.t277 VSSD.t172 1252.14
R586 VSSD.t269 VSSD.t188 1252.14
R587 VSSD.t240 VSSD.t178 1252.14
R588 VSSD.t210 VSSD.t204 1252.14
R589 VSSD.t128 VSSD.t92 1200.85
R590 VSSD.t243 VSSD.t136 1200.85
R591 VSSD.t156 VSSD.t109 1200.85
R592 VSSD.t225 VSSD.t126 1200.85
R593 VSSD.t152 VSSD.t93 1200.85
R594 VSSD.t112 VSSD.t120 1200.85
R595 VSSD.t144 VSSD.t20 1200.85
R596 VSSD.t130 VSSD.t59 1200.85
R597 VSSD.t148 VSSD.t268 1200.85
R598 VSSD.t134 VSSD.t71 1200.85
R599 VSSD.t116 VSSD.t108 1200.85
R600 VSSD.t69 VSSD.t250 1094.02
R601 VSSD.t43 VSSD.t261 1094.02
R602 VSSD.t57 VSSD.t6 1094.02
R603 VSSD.t275 VSSD.t106 1094.02
R604 VSSD.t258 VSSD.t47 1094.02
R605 VSSD.t12 VSSD.t238 1094.02
R606 VSSD.t264 VSSD.t8 1094.02
R607 VSSD.t278 VSSD.t14 1094.02
R608 VSSD.t67 VSSD.t45 1094.02
R609 VSSD.t214 VSSD.t216 1094.02
R610 VSSD.t284 VSSD.t2 1094.02
R611 VSSD.t52 VSSD.t218 1081.2
R612 VSSD.t104 VSSD.t85 1081.2
R613 VSSD.t110 VSSD.t97 1081.2
R614 VSSD.t270 VSSD.t79 1081.2
R615 VSSD.t4 VSSD.t10 1081.2
R616 VSSD.t247 VSSD.t61 1081.2
R617 VSSD.t73 VSSD.t266 1081.2
R618 VSSD.t231 VSSD.t254 1081.2
R619 VSSD.t223 VSSD.t18 1081.2
R620 VSSD.t226 VSSD.t83 1081.2
R621 VSSD.t280 VSSD.t102 1081.2
R622 VSSD.t170 VSSD.t78 1051.28
R623 VSSD.t260 VSSD.t194 1051.28
R624 VSSD.t180 VSSD.t49 1051.28
R625 VSSD.t228 VSSD.t196 1051.28
R626 VSSD.t164 VSSD.t90 1051.28
R627 VSSD.t158 VSSD.t190 1051.28
R628 VSSD.t166 VSSD.t16 1051.28
R629 VSSD.t198 VSSD.t101 1051.28
R630 VSSD.t174 VSSD.t56 1051.28
R631 VSSD.t202 VSSD.t81 1051.28
R632 VSSD.t184 VSSD.t211 1051.28
R633 VSSD.n259 VSSD.t77 822.926
R634 VSSD.t263 VSSD.n255 822.926
R635 VSSD.n49 VSSD.t249 822.926
R636 VSSD.t233 VSSD.n38 822.926
R637 VSSD.n64 VSSD.t87 822.926
R638 VSSD.t161 VSSD.n33 822.926
R639 VSSD.n75 VSSD.t63 822.926
R640 VSSD.n68 VSSD.t277 822.926
R641 VSSD.n60 VSSD.t269 822.926
R642 VSSD.n53 VSSD.t240 822.926
R643 VSSD.n45 VSSD.t210 822.926
R644 VSSD.t176 VSSD.t69 658.12
R645 VSSD.t250 VSSD.t128 658.12
R646 VSSD.t150 VSSD.t52 658.12
R647 VSSD.t218 VSSD.t170 658.12
R648 VSSD.t261 VSSD.t182 658.12
R649 VSSD.t136 VSSD.t43 658.12
R650 VSSD.t85 VSSD.t114 658.12
R651 VSSD.t194 VSSD.t104 658.12
R652 VSSD.t200 VSSD.t57 658.12
R653 VSSD.t6 VSSD.t156 658.12
R654 VSSD.t132 VSSD.t110 658.12
R655 VSSD.t97 VSSD.t180 658.12
R656 VSSD.t106 VSSD.t168 658.12
R657 VSSD.t126 VSSD.t275 658.12
R658 VSSD.t79 VSSD.t146 658.12
R659 VSSD.t196 VSSD.t270 658.12
R660 VSSD.t192 VSSD.t258 658.12
R661 VSSD.t47 VSSD.t152 658.12
R662 VSSD.t124 VSSD.t4 658.12
R663 VSSD.t10 VSSD.t164 658.12
R664 VSSD.t238 VSSD.t162 658.12
R665 VSSD.t120 VSSD.t12 658.12
R666 VSSD.t61 VSSD.t142 658.12
R667 VSSD.t190 VSSD.t247 658.12
R668 VSSD.t186 VSSD.t264 658.12
R669 VSSD.t8 VSSD.t144 658.12
R670 VSSD.t138 VSSD.t73 658.12
R671 VSSD.t266 VSSD.t166 658.12
R672 VSSD.t172 VSSD.t278 658.12
R673 VSSD.t14 VSSD.t130 658.12
R674 VSSD.t118 VSSD.t231 658.12
R675 VSSD.t254 VSSD.t198 658.12
R676 VSSD.t188 VSSD.t67 658.12
R677 VSSD.t45 VSSD.t148 658.12
R678 VSSD.t140 VSSD.t223 658.12
R679 VSSD.t18 VSSD.t174 658.12
R680 VSSD.t178 VSSD.t214 658.12
R681 VSSD.t216 VSSD.t134 658.12
R682 VSSD.t122 VSSD.t226 658.12
R683 VSSD.t83 VSSD.t202 658.12
R684 VSSD.t204 VSSD.t284 658.12
R685 VSSD.t2 VSSD.t116 658.12
R686 VSSD.t154 VSSD.t280 658.12
R687 VSSD.t102 VSSD.t184 658.12
R688 VSSD.n72 VSSD.t94 630.125
R689 VSSD.n69 VSSD.t229 630.125
R690 VSSD.n65 VSSD.t256 630.125
R691 VSSD.n61 VSSD.t65 630.125
R692 VSSD.n57 VSSD.t220 630.125
R693 VSSD.n54 VSSD.t212 630.125
R694 VSSD.n50 VSSD.t273 630.125
R695 VSSD.n46 VSSD.t282 630.125
R696 VSSD.n42 VSSD.t252 630.125
R697 VSSD.n260 VSSD.t54 630.125
R698 VSSD.n258 VSSD.t31 622.481
R699 VSSD.n74 VSSD.t23 622.481
R700 VSSD.t33 VSSD.n34 622.481
R701 VSSD.n67 VSSD.t39 622.481
R702 VSSD.n63 VSSD.t21 622.481
R703 VSSD.n59 VSSD.t25 622.481
R704 VSSD.t37 VSSD.n39 622.481
R705 VSSD.n52 VSSD.t41 622.481
R706 VSSD.n48 VSSD.t27 622.481
R707 VSSD.n44 VSSD.t29 622.481
R708 VSSD.t35 VSSD.n256 622.481
R709 VSSD.n73 VSSD.n72 516.549
R710 VSSD.n69 VSSD.n35 516.549
R711 VSSD.n66 VSSD.n65 516.549
R712 VSSD.n62 VSSD.n61 516.549
R713 VSSD.n58 VSSD.n57 516.549
R714 VSSD.n54 VSSD.n40 516.549
R715 VSSD.n51 VSSD.n50 516.549
R716 VSSD.n47 VSSD.n46 516.549
R717 VSSD.n43 VSSD.n42 516.549
R718 VSSD.n260 VSSD.n257 516.549
R719 VSSD.t75 VSSD.n258 273.017
R720 VSSD.n262 VSSD.t31 273.017
R721 VSSD.n75 VSSD.t206 273.017
R722 VSSD.t0 VSSD.n74 273.017
R723 VSSD.t23 VSSD.n73 273.017
R724 VSSD.n33 VSSD.t94 273.017
R725 VSSD.n34 VSSD.t159 273.017
R726 VSSD.n35 VSSD.t33 273.017
R727 VSSD.t229 VSSD.n68 273.017
R728 VSSD.t99 VSSD.n67 273.017
R729 VSSD.t39 VSSD.n66 273.017
R730 VSSD.t256 VSSD.n64 273.017
R731 VSSD.t88 VSSD.n63 273.017
R732 VSSD.t21 VSSD.n62 273.017
R733 VSSD.t65 VSSD.n60 273.017
R734 VSSD.t245 VSSD.n59 273.017
R735 VSSD.t25 VSSD.n58 273.017
R736 VSSD.n38 VSSD.t220 273.017
R737 VSSD.n39 VSSD.t234 273.017
R738 VSSD.n40 VSSD.t37 273.017
R739 VSSD.t212 VSSD.n53 273.017
R740 VSSD.t241 VSSD.n52 273.017
R741 VSSD.t41 VSSD.n51 273.017
R742 VSSD.t273 VSSD.n49 273.017
R743 VSSD.t50 VSSD.n48 273.017
R744 VSSD.t27 VSSD.n47 273.017
R745 VSSD.t282 VSSD.n45 273.017
R746 VSSD.t208 VSSD.n44 273.017
R747 VSSD.t29 VSSD.n43 273.017
R748 VSSD.n255 VSSD.t252 273.017
R749 VSSD.n256 VSSD.t236 273.017
R750 VSSD.n257 VSSD.t35 273.017
R751 VSSD.t54 VSSD.n259 273.017
R752 VSSD.n278 VSSD.t70 3.96068
R753 VSSD.n274 VSSD.t129 3.96068
R754 VSSD.n270 VSSD.t53 3.96068
R755 VSSD.n266 VSSD.t171 3.96068
R756 VSSD.n250 VSSD.t262 3.96068
R757 VSSD.n246 VSSD.t137 3.96068
R758 VSSD.n242 VSSD.t86 3.96068
R759 VSSD.n238 VSSD.t195 3.96068
R760 VSSD.n223 VSSD.t285 3.96068
R761 VSSD.n227 VSSD.t117 3.96068
R762 VSSD.n231 VSSD.t281 3.96068
R763 VSSD.n235 VSSD.t185 3.96068
R764 VSSD.n205 VSSD.t58 3.96068
R765 VSSD.n209 VSSD.t157 3.96068
R766 VSSD.n213 VSSD.t111 3.96068
R767 VSSD.n217 VSSD.t181 3.96068
R768 VSSD.n187 VSSD.t215 3.96068
R769 VSSD.n191 VSSD.t135 3.96068
R770 VSSD.n195 VSSD.t227 3.96068
R771 VSSD.n199 VSSD.t203 3.96068
R772 VSSD.n169 VSSD.t107 3.96068
R773 VSSD.n173 VSSD.t127 3.96068
R774 VSSD.n177 VSSD.t80 3.96068
R775 VSSD.n181 VSSD.t197 3.96068
R776 VSSD.n151 VSSD.t68 3.96068
R777 VSSD.n155 VSSD.t149 3.96068
R778 VSSD.n159 VSSD.t224 3.96068
R779 VSSD.n163 VSSD.t175 3.96068
R780 VSSD.n133 VSSD.t259 3.96068
R781 VSSD.n137 VSSD.t153 3.96068
R782 VSSD.n141 VSSD.t5 3.96068
R783 VSSD.n145 VSSD.t165 3.96068
R784 VSSD.n115 VSSD.t279 3.96068
R785 VSSD.n119 VSSD.t131 3.96068
R786 VSSD.n123 VSSD.t232 3.96068
R787 VSSD.n127 VSSD.t199 3.96068
R788 VSSD.n97 VSSD.t239 3.96068
R789 VSSD.n101 VSSD.t121 3.96068
R790 VSSD.n105 VSSD.t62 3.96068
R791 VSSD.n109 VSSD.t191 3.96068
R792 VSSD.n79 VSSD.t265 3.96068
R793 VSSD.n83 VSSD.t145 3.96068
R794 VSSD.n87 VSSD.t74 3.96068
R795 VSSD.n91 VSSD.t167 3.96068
R796 VSSD.n279 VSSD.t177 3.92733
R797 VSSD.n275 VSSD.t251 3.92733
R798 VSSD.n271 VSSD.t151 3.92733
R799 VSSD.n267 VSSD.t219 3.92733
R800 VSSD.n251 VSSD.t183 3.92733
R801 VSSD.n247 VSSD.t44 3.92733
R802 VSSD.n243 VSSD.t115 3.92733
R803 VSSD.n239 VSSD.t105 3.92733
R804 VSSD.n222 VSSD.t205 3.92733
R805 VSSD.n226 VSSD.t3 3.92733
R806 VSSD.n230 VSSD.t155 3.92733
R807 VSSD.n234 VSSD.t103 3.92733
R808 VSSD.n204 VSSD.t201 3.92733
R809 VSSD.n208 VSSD.t7 3.92733
R810 VSSD.n212 VSSD.t133 3.92733
R811 VSSD.n216 VSSD.t98 3.92733
R812 VSSD.n186 VSSD.t179 3.92733
R813 VSSD.n190 VSSD.t217 3.92733
R814 VSSD.n194 VSSD.t123 3.92733
R815 VSSD.n198 VSSD.t84 3.92733
R816 VSSD.n168 VSSD.t169 3.92733
R817 VSSD.n172 VSSD.t276 3.92733
R818 VSSD.n176 VSSD.t147 3.92733
R819 VSSD.n180 VSSD.t271 3.92733
R820 VSSD.n150 VSSD.t189 3.92733
R821 VSSD.n154 VSSD.t46 3.92733
R822 VSSD.n158 VSSD.t141 3.92733
R823 VSSD.n162 VSSD.t19 3.92733
R824 VSSD.n132 VSSD.t193 3.92733
R825 VSSD.n136 VSSD.t48 3.92733
R826 VSSD.n140 VSSD.t125 3.92733
R827 VSSD.n144 VSSD.t11 3.92733
R828 VSSD.n114 VSSD.t173 3.92733
R829 VSSD.n118 VSSD.t15 3.92733
R830 VSSD.n122 VSSD.t119 3.92733
R831 VSSD.n126 VSSD.t255 3.92733
R832 VSSD.n96 VSSD.t163 3.92733
R833 VSSD.n100 VSSD.t13 3.92733
R834 VSSD.n104 VSSD.t143 3.92733
R835 VSSD.n108 VSSD.t248 3.92733
R836 VSSD.n78 VSSD.t187 3.92733
R837 VSSD.n82 VSSD.t9 3.92733
R838 VSSD.n86 VSSD.t139 3.92733
R839 VSSD.n90 VSSD.t267 3.92733
R840 VSSD.n1 VSSD.t237 3.76153
R841 VSSD.n2 VSSD.t36 3.76153
R842 VSSD.n4 VSSD.t76 3.76153
R843 VSSD.n263 VSSD.t32 3.76153
R844 VSSD.n76 VSSD.t207 3.76153
R845 VSSD.n6 VSSD.t209 3.76153
R846 VSSD.n7 VSSD.t30 3.76153
R847 VSSD.n254 VSSD.t253 3.76153
R848 VSSD.n9 VSSD.t51 3.76153
R849 VSSD.n10 VSSD.t28 3.76153
R850 VSSD.n8 VSSD.t283 3.76153
R851 VSSD.n12 VSSD.t242 3.76153
R852 VSSD.n13 VSSD.t42 3.76153
R853 VSSD.n11 VSSD.t274 3.76153
R854 VSSD.n15 VSSD.t235 3.76153
R855 VSSD.n16 VSSD.t38 3.76153
R856 VSSD.n14 VSSD.t213 3.76153
R857 VSSD.n18 VSSD.t246 3.76153
R858 VSSD.n19 VSSD.t26 3.76153
R859 VSSD.n17 VSSD.t221 3.76153
R860 VSSD.n21 VSSD.t89 3.76153
R861 VSSD.n22 VSSD.t22 3.76153
R862 VSSD.n20 VSSD.t66 3.76153
R863 VSSD.n24 VSSD.t100 3.76153
R864 VSSD.n25 VSSD.t40 3.76153
R865 VSSD.n23 VSSD.t257 3.76153
R866 VSSD.n27 VSSD.t160 3.76153
R867 VSSD.n28 VSSD.t34 3.76153
R868 VSSD.n26 VSSD.t230 3.76153
R869 VSSD.n30 VSSD.t1 3.76153
R870 VSSD.n31 VSSD.t24 3.76153
R871 VSSD.n29 VSSD.t95 3.76153
R872 VSSD.n3 VSSD.t55 3.76153
R873 VSSD.n258 VSSD.n4 3.46717
R874 VSSD.n263 VSSD.n262 3.46717
R875 VSSD.n76 VSSD.n75 3.46717
R876 VSSD.n74 VSSD.n30 3.46717
R877 VSSD.n73 VSSD.n31 3.46717
R878 VSSD.n33 VSSD.n29 3.46717
R879 VSSD.n34 VSSD.n27 3.46717
R880 VSSD.n35 VSSD.n28 3.46717
R881 VSSD.n68 VSSD.n26 3.46717
R882 VSSD.n67 VSSD.n24 3.46717
R883 VSSD.n66 VSSD.n25 3.46717
R884 VSSD.n64 VSSD.n23 3.46717
R885 VSSD.n63 VSSD.n21 3.46717
R886 VSSD.n62 VSSD.n22 3.46717
R887 VSSD.n60 VSSD.n20 3.46717
R888 VSSD.n59 VSSD.n18 3.46717
R889 VSSD.n58 VSSD.n19 3.46717
R890 VSSD.n38 VSSD.n17 3.46717
R891 VSSD.n39 VSSD.n15 3.46717
R892 VSSD.n40 VSSD.n16 3.46717
R893 VSSD.n53 VSSD.n14 3.46717
R894 VSSD.n52 VSSD.n12 3.46717
R895 VSSD.n51 VSSD.n13 3.46717
R896 VSSD.n49 VSSD.n11 3.46717
R897 VSSD.n48 VSSD.n9 3.46717
R898 VSSD.n47 VSSD.n10 3.46717
R899 VSSD.n45 VSSD.n8 3.46717
R900 VSSD.n44 VSSD.n6 3.46717
R901 VSSD.n43 VSSD.n7 3.46717
R902 VSSD.n255 VSSD.n254 3.46717
R903 VSSD.n256 VSSD.n1 3.46717
R904 VSSD.n257 VSSD.n2 3.46717
R905 VSSD.n259 VSSD.n3 3.46717
R906 VSSD.n280 VSSD.n277 2.8535
R907 VSSD.n276 VSSD.n273 2.8535
R908 VSSD.n272 VSSD.n269 2.8535
R909 VSSD.n268 VSSD.n265 2.8535
R910 VSSD.n252 VSSD.n249 2.8535
R911 VSSD.n248 VSSD.n245 2.8535
R912 VSSD.n244 VSSD.n241 2.8535
R913 VSSD.n240 VSSD.n0 2.8535
R914 VSSD.n224 VSSD.n221 2.8535
R915 VSSD.n228 VSSD.n225 2.8535
R916 VSSD.n232 VSSD.n229 2.8535
R917 VSSD.n236 VSSD.n233 2.8535
R918 VSSD.n206 VSSD.n203 2.8535
R919 VSSD.n210 VSSD.n207 2.8535
R920 VSSD.n214 VSSD.n211 2.8535
R921 VSSD.n218 VSSD.n215 2.8535
R922 VSSD.n188 VSSD.n185 2.8535
R923 VSSD.n192 VSSD.n189 2.8535
R924 VSSD.n196 VSSD.n193 2.8535
R925 VSSD.n200 VSSD.n197 2.8535
R926 VSSD.n170 VSSD.n167 2.8535
R927 VSSD.n174 VSSD.n171 2.8535
R928 VSSD.n178 VSSD.n175 2.8535
R929 VSSD.n182 VSSD.n179 2.8535
R930 VSSD.n152 VSSD.n149 2.8535
R931 VSSD.n156 VSSD.n153 2.8535
R932 VSSD.n160 VSSD.n157 2.8535
R933 VSSD.n164 VSSD.n161 2.8535
R934 VSSD.n134 VSSD.n131 2.8535
R935 VSSD.n138 VSSD.n135 2.8535
R936 VSSD.n142 VSSD.n139 2.8535
R937 VSSD.n146 VSSD.n143 2.8535
R938 VSSD.n116 VSSD.n113 2.8535
R939 VSSD.n120 VSSD.n117 2.8535
R940 VSSD.n124 VSSD.n121 2.8535
R941 VSSD.n128 VSSD.n125 2.8535
R942 VSSD.n98 VSSD.n95 2.8535
R943 VSSD.n102 VSSD.n99 2.8535
R944 VSSD.n106 VSSD.n103 2.8535
R945 VSSD.n110 VSSD.n107 2.8535
R946 VSSD.n80 VSSD.n77 2.8535
R947 VSSD.n84 VSSD.n81 2.8535
R948 VSSD.n88 VSSD.n85 2.8535
R949 VSSD.n92 VSSD.n89 2.8535
R950 VSSD.n77 VSSD.n76 0.308486
R951 VSSD.n282 VSSD.n2 0.248526
R952 VSSD.n264 VSSD.n263 0.248526
R953 VSSD.n237 VSSD.n7 0.248526
R954 VSSD.n219 VSSD.n10 0.248526
R955 VSSD.n201 VSSD.n13 0.248526
R956 VSSD.n183 VSSD.n16 0.248526
R957 VSSD.n165 VSSD.n19 0.248526
R958 VSSD.n147 VSSD.n22 0.248526
R959 VSSD.n129 VSSD.n25 0.248526
R960 VSSD.n111 VSSD.n28 0.248526
R961 VSSD.n93 VSSD.n31 0.248526
R962 VSSD.n282 VSSD.n1 0.17684
R963 VSSD.n264 VSSD.n4 0.17684
R964 VSSD.n237 VSSD.n6 0.17684
R965 VSSD.n219 VSSD.n9 0.17684
R966 VSSD.n201 VSSD.n12 0.17684
R967 VSSD.n183 VSSD.n15 0.17684
R968 VSSD.n165 VSSD.n18 0.17684
R969 VSSD.n147 VSSD.n21 0.17684
R970 VSSD.n129 VSSD.n24 0.17684
R971 VSSD.n111 VSSD.n27 0.17684
R972 VSSD.n93 VSSD.n30 0.17684
R973 VSSD.n254 VSSD.n253 0.150945
R974 VSSD.n220 VSSD.n8 0.150945
R975 VSSD.n202 VSSD.n11 0.150945
R976 VSSD.n184 VSSD.n14 0.150945
R977 VSSD.n166 VSSD.n17 0.150945
R978 VSSD.n148 VSSD.n20 0.150945
R979 VSSD.n130 VSSD.n23 0.150945
R980 VSSD.n112 VSSD.n26 0.150945
R981 VSSD.n94 VSSD.n29 0.150945
R982 VSSD.n281 VSSD.n3 0.150945
R983 VSSD.n273 VSSD.n272 0.144228
R984 VSSD.n245 VSSD.n244 0.144228
R985 VSSD.n229 VSSD.n228 0.144228
R986 VSSD.n211 VSSD.n210 0.144228
R987 VSSD.n193 VSSD.n192 0.144228
R988 VSSD.n175 VSSD.n174 0.144228
R989 VSSD.n157 VSSD.n156 0.144228
R990 VSSD.n139 VSSD.n138 0.144228
R991 VSSD.n121 VSSD.n120 0.144228
R992 VSSD.n103 VSSD.n102 0.144228
R993 VSSD.n85 VSSD.n84 0.144228
R994 VSSD.n265 VSSD.n264 0.107903
R995 VSSD.n237 VSSD.n236 0.107903
R996 VSSD.n219 VSSD.n218 0.107903
R997 VSSD.n201 VSSD.n200 0.107903
R998 VSSD.n183 VSSD.n182 0.107903
R999 VSSD.n165 VSSD.n164 0.107903
R1000 VSSD.n147 VSSD.n146 0.107903
R1001 VSSD.n129 VSSD.n128 0.107903
R1002 VSSD.n111 VSSD.n110 0.107903
R1003 VSSD.n93 VSSD.n92 0.107903
R1004 VSSD.n253 VSSD.n237 0.07745
R1005 VSSD.n220 VSSD.n219 0.07745
R1006 VSSD.n202 VSSD.n201 0.07745
R1007 VSSD.n184 VSSD.n183 0.07745
R1008 VSSD.n166 VSSD.n165 0.07745
R1009 VSSD.n148 VSSD.n147 0.07745
R1010 VSSD.n130 VSSD.n129 0.07745
R1011 VSSD.n112 VSSD.n111 0.07745
R1012 VSSD.n94 VSSD.n93 0.07745
R1013 VSSD.n282 VSSD.n281 0.07745
R1014 VSSD.n281 VSSD.n280 0.0771224
R1015 VSSD.n253 VSSD.n252 0.0771224
R1016 VSSD.n221 VSSD.n220 0.0771224
R1017 VSSD.n203 VSSD.n202 0.0771224
R1018 VSSD.n185 VSSD.n184 0.0771224
R1019 VSSD.n167 VSSD.n166 0.0771224
R1020 VSSD.n149 VSSD.n148 0.0771224
R1021 VSSD.n131 VSSD.n130 0.0771224
R1022 VSSD.n113 VSSD.n112 0.0771224
R1023 VSSD.n95 VSSD.n94 0.0771224
R1024 VSSD VSSD.n0 0.0630826
R1025 VSSD VSSD.n282 0.04532
R1026 VSSD.n279 VSSD.n278 0.0393577
R1027 VSSD.n275 VSSD.n274 0.0393577
R1028 VSSD.n271 VSSD.n270 0.0393577
R1029 VSSD.n267 VSSD.n266 0.0393577
R1030 VSSD.n251 VSSD.n250 0.0393577
R1031 VSSD.n247 VSSD.n246 0.0393577
R1032 VSSD.n243 VSSD.n242 0.0393577
R1033 VSSD.n239 VSSD.n238 0.0393577
R1034 VSSD.n223 VSSD.n222 0.0393577
R1035 VSSD.n227 VSSD.n226 0.0393577
R1036 VSSD.n231 VSSD.n230 0.0393577
R1037 VSSD.n235 VSSD.n234 0.0393577
R1038 VSSD.n205 VSSD.n204 0.0393577
R1039 VSSD.n209 VSSD.n208 0.0393577
R1040 VSSD.n213 VSSD.n212 0.0393577
R1041 VSSD.n217 VSSD.n216 0.0393577
R1042 VSSD.n187 VSSD.n186 0.0393577
R1043 VSSD.n191 VSSD.n190 0.0393577
R1044 VSSD.n195 VSSD.n194 0.0393577
R1045 VSSD.n199 VSSD.n198 0.0393577
R1046 VSSD.n169 VSSD.n168 0.0393577
R1047 VSSD.n173 VSSD.n172 0.0393577
R1048 VSSD.n177 VSSD.n176 0.0393577
R1049 VSSD.n181 VSSD.n180 0.0393577
R1050 VSSD.n151 VSSD.n150 0.0393577
R1051 VSSD.n155 VSSD.n154 0.0393577
R1052 VSSD.n159 VSSD.n158 0.0393577
R1053 VSSD.n163 VSSD.n162 0.0393577
R1054 VSSD.n133 VSSD.n132 0.0393577
R1055 VSSD.n137 VSSD.n136 0.0393577
R1056 VSSD.n141 VSSD.n140 0.0393577
R1057 VSSD.n145 VSSD.n144 0.0393577
R1058 VSSD.n115 VSSD.n114 0.0393577
R1059 VSSD.n119 VSSD.n118 0.0393577
R1060 VSSD.n123 VSSD.n122 0.0393577
R1061 VSSD.n127 VSSD.n126 0.0393577
R1062 VSSD.n97 VSSD.n96 0.0393577
R1063 VSSD.n101 VSSD.n100 0.0393577
R1064 VSSD.n105 VSSD.n104 0.0393577
R1065 VSSD.n109 VSSD.n108 0.0393577
R1066 VSSD.n79 VSSD.n78 0.0393577
R1067 VSSD.n83 VSSD.n82 0.0393577
R1068 VSSD.n87 VSSD.n86 0.0393577
R1069 VSSD.n91 VSSD.n90 0.0393577
R1070 VSSD.n277 VSSD.n276 0.0168795
R1071 VSSD.n249 VSSD.n248 0.0168795
R1072 VSSD.n225 VSSD.n224 0.0168795
R1073 VSSD.n207 VSSD.n206 0.0168795
R1074 VSSD.n189 VSSD.n188 0.0168795
R1075 VSSD.n171 VSSD.n170 0.0168795
R1076 VSSD.n153 VSSD.n152 0.0168795
R1077 VSSD.n135 VSSD.n134 0.0168795
R1078 VSSD.n117 VSSD.n116 0.0168795
R1079 VSSD.n99 VSSD.n98 0.0168795
R1080 VSSD.n81 VSSD.n80 0.0168795
R1081 VSSD.n269 VSSD.n268 0.0163567
R1082 VSSD.n241 VSSD.n240 0.0163567
R1083 VSSD.n233 VSSD.n232 0.0163567
R1084 VSSD.n215 VSSD.n214 0.0163567
R1085 VSSD.n197 VSSD.n196 0.0163567
R1086 VSSD.n179 VSSD.n178 0.0163567
R1087 VSSD.n161 VSSD.n160 0.0163567
R1088 VSSD.n143 VSSD.n142 0.0163567
R1089 VSSD.n125 VSSD.n124 0.0163567
R1090 VSSD.n107 VSSD.n106 0.0163567
R1091 VSSD.n89 VSSD.n88 0.0163567
R1092 VSSD.n278 VSSD.n277 0.00938674
R1093 VSSD.n274 VSSD.n273 0.00938674
R1094 VSSD.n270 VSSD.n269 0.00938674
R1095 VSSD.n266 VSSD.n265 0.00938674
R1096 VSSD.n250 VSSD.n249 0.00938674
R1097 VSSD.n246 VSSD.n245 0.00938674
R1098 VSSD.n242 VSSD.n241 0.00938674
R1099 VSSD.n238 VSSD.n0 0.00938674
R1100 VSSD.n224 VSSD.n223 0.00938674
R1101 VSSD.n228 VSSD.n227 0.00938674
R1102 VSSD.n232 VSSD.n231 0.00938674
R1103 VSSD.n236 VSSD.n235 0.00938674
R1104 VSSD.n206 VSSD.n205 0.00938674
R1105 VSSD.n210 VSSD.n209 0.00938674
R1106 VSSD.n214 VSSD.n213 0.00938674
R1107 VSSD.n218 VSSD.n217 0.00938674
R1108 VSSD.n188 VSSD.n187 0.00938674
R1109 VSSD.n192 VSSD.n191 0.00938674
R1110 VSSD.n196 VSSD.n195 0.00938674
R1111 VSSD.n200 VSSD.n199 0.00938674
R1112 VSSD.n170 VSSD.n169 0.00938674
R1113 VSSD.n174 VSSD.n173 0.00938674
R1114 VSSD.n178 VSSD.n177 0.00938674
R1115 VSSD.n182 VSSD.n181 0.00938674
R1116 VSSD.n152 VSSD.n151 0.00938674
R1117 VSSD.n156 VSSD.n155 0.00938674
R1118 VSSD.n160 VSSD.n159 0.00938674
R1119 VSSD.n164 VSSD.n163 0.00938674
R1120 VSSD.n134 VSSD.n133 0.00938674
R1121 VSSD.n138 VSSD.n137 0.00938674
R1122 VSSD.n142 VSSD.n141 0.00938674
R1123 VSSD.n146 VSSD.n145 0.00938674
R1124 VSSD.n116 VSSD.n115 0.00938674
R1125 VSSD.n120 VSSD.n119 0.00938674
R1126 VSSD.n124 VSSD.n123 0.00938674
R1127 VSSD.n128 VSSD.n127 0.00938674
R1128 VSSD.n98 VSSD.n97 0.00938674
R1129 VSSD.n102 VSSD.n101 0.00938674
R1130 VSSD.n106 VSSD.n105 0.00938674
R1131 VSSD.n110 VSSD.n109 0.00938674
R1132 VSSD.n80 VSSD.n79 0.00938674
R1133 VSSD.n84 VSSD.n83 0.00938674
R1134 VSSD.n88 VSSD.n87 0.00938674
R1135 VSSD.n92 VSSD.n91 0.00938674
R1136 VSSD.n280 VSSD.n279 0.00781849
R1137 VSSD.n276 VSSD.n275 0.00781849
R1138 VSSD.n272 VSSD.n271 0.00781849
R1139 VSSD.n268 VSSD.n267 0.00781849
R1140 VSSD.n252 VSSD.n251 0.00781849
R1141 VSSD.n248 VSSD.n247 0.00781849
R1142 VSSD.n244 VSSD.n243 0.00781849
R1143 VSSD.n240 VSSD.n239 0.00781849
R1144 VSSD.n222 VSSD.n221 0.00781849
R1145 VSSD.n226 VSSD.n225 0.00781849
R1146 VSSD.n230 VSSD.n229 0.00781849
R1147 VSSD.n234 VSSD.n233 0.00781849
R1148 VSSD.n204 VSSD.n203 0.00781849
R1149 VSSD.n208 VSSD.n207 0.00781849
R1150 VSSD.n212 VSSD.n211 0.00781849
R1151 VSSD.n216 VSSD.n215 0.00781849
R1152 VSSD.n186 VSSD.n185 0.00781849
R1153 VSSD.n190 VSSD.n189 0.00781849
R1154 VSSD.n194 VSSD.n193 0.00781849
R1155 VSSD.n198 VSSD.n197 0.00781849
R1156 VSSD.n168 VSSD.n167 0.00781849
R1157 VSSD.n172 VSSD.n171 0.00781849
R1158 VSSD.n176 VSSD.n175 0.00781849
R1159 VSSD.n180 VSSD.n179 0.00781849
R1160 VSSD.n150 VSSD.n149 0.00781849
R1161 VSSD.n154 VSSD.n153 0.00781849
R1162 VSSD.n158 VSSD.n157 0.00781849
R1163 VSSD.n162 VSSD.n161 0.00781849
R1164 VSSD.n132 VSSD.n131 0.00781849
R1165 VSSD.n136 VSSD.n135 0.00781849
R1166 VSSD.n140 VSSD.n139 0.00781849
R1167 VSSD.n144 VSSD.n143 0.00781849
R1168 VSSD.n114 VSSD.n113 0.00781849
R1169 VSSD.n118 VSSD.n117 0.00781849
R1170 VSSD.n122 VSSD.n121 0.00781849
R1171 VSSD.n126 VSSD.n125 0.00781849
R1172 VSSD.n96 VSSD.n95 0.00781849
R1173 VSSD.n100 VSSD.n99 0.00781849
R1174 VSSD.n104 VSSD.n103 0.00781849
R1175 VSSD.n108 VSSD.n107 0.00781849
R1176 VSSD.n78 VSSD.n77 0.00781849
R1177 VSSD.n82 VSSD.n81 0.00781849
R1178 VSSD.n86 VSSD.n85 0.00781849
R1179 VSSD.n90 VSSD.n89 0.00781849
R1180 a_45418_19028.n5 a_45418_19028.t8 74.8588
R1181 a_45418_19028.n2 a_45418_19028.t5 70.3153
R1182 a_45418_19028.n5 a_45418_19028.t7 44.2362
R1183 a_45418_19028.n2 a_45418_19028.t6 39.854
R1184 a_45418_19028.n0 a_45418_19028.n4 11.62
R1185 a_45418_19028.n3 a_45418_19028.t3 11.0089
R1186 a_45418_19028.n4 a_45418_19028.n3 8.15804
R1187 a_45418_19028.n0 a_45418_19028.n1 5.39574
R1188 a_45418_19028.t0 a_45418_19028.n0 4.91248
R1189 a_45418_19028.n3 a_45418_19028.t2 4.12478
R1190 a_45418_19028.n1 a_45418_19028.t1 3.7821
R1191 a_45418_19028.n1 a_45418_19028.t4 3.77824
R1192 a_45418_19028.n0 a_45418_19028.n5 3.04286
R1193 a_45418_19028.n4 a_45418_19028.n2 2.84345
R1194 a_32058_19028.n2 a_32058_19028.t3 11.0089
R1195 a_32058_19028.n2 a_32058_19028.n1 7.28488
R1196 a_32058_19028.n1 a_32058_19028.n0 5.39574
R1197 a_32058_19028.n1 a_32058_19028.t2 4.91248
R1198 a_32058_19028.t0 a_32058_19028.n2 4.12612
R1199 a_32058_19028.n0 a_32058_19028.t1 3.7821
R1200 a_32058_19028.n0 a_32058_19028.t4 3.77824
R1201 a_120418_19028.n5 a_120418_19028.t6 74.8588
R1202 a_120418_19028.n2 a_120418_19028.t7 70.3153
R1203 a_120418_19028.n5 a_120418_19028.t5 44.2362
R1204 a_120418_19028.n2 a_120418_19028.t8 39.854
R1205 a_120418_19028.n0 a_120418_19028.n4 11.62
R1206 a_120418_19028.n3 a_120418_19028.t4 11.0089
R1207 a_120418_19028.n4 a_120418_19028.n3 8.15804
R1208 a_120418_19028.n0 a_120418_19028.n1 5.39574
R1209 a_120418_19028.t0 a_120418_19028.n0 4.91248
R1210 a_120418_19028.n3 a_120418_19028.t2 4.12478
R1211 a_120418_19028.n1 a_120418_19028.t1 3.7821
R1212 a_120418_19028.n1 a_120418_19028.t3 3.77824
R1213 a_120418_19028.n0 a_120418_19028.n5 3.04286
R1214 a_120418_19028.n4 a_120418_19028.n2 2.84345
R1215 a_10838_19028.n1 a_10838_19028.t4 11.0089
R1216 a_10838_19028.n2 a_10838_19028.n1 7.51324
R1217 a_10838_19028.n2 a_10838_19028.n0 5.39574
R1218 a_10838_19028.t1 a_10838_19028.n2 4.91248
R1219 a_10838_19028.n1 a_10838_19028.t3 4.12478
R1220 a_10838_19028.n0 a_10838_19028.t2 3.7821
R1221 a_10838_19028.n0 a_10838_19028.t0 3.77824
R1222 a_129210_19028.n0 a_129210_19028.t5 74.8588
R1223 a_129210_19028.n0 a_129210_19028.t6 44.2362
R1224 a_129210_19028.n3 a_129210_19028.n0 14.5242
R1225 a_129210_19028.n3 a_129210_19028.t0 11.0089
R1226 a_129210_19028.n2 a_129210_19028.n1 5.39574
R1227 a_129210_19028.n2 a_129210_19028.t4 4.91248
R1228 a_129210_19028.t1 a_129210_19028.n3 4.12612
R1229 a_129210_19028.n1 a_129210_19028.t3 3.7821
R1230 a_129210_19028.n1 a_129210_19028.t2 3.77824
R1231 a_129210_19028.n0 a_129210_19028.n2 1.83141
R1232 a_418_19028.n2 a_418_19028.t6 74.8588
R1233 a_418_19028.n3 a_418_19028.t7 70.3153
R1234 a_418_19028.n2 a_418_19028.t5 44.2362
R1235 a_418_19028.n3 a_418_19028.t8 39.854
R1236 a_418_19028.n4 a_418_19028.n0 11.62
R1237 a_418_19028.n5 a_418_19028.t4 11.0089
R1238 a_418_19028.n5 a_418_19028.n4 8.15804
R1239 a_418_19028.n0 a_418_19028.n1 5.39574
R1240 a_418_19028.n0 a_418_19028.t2 4.91248
R1241 a_418_19028.t0 a_418_19028.n5 4.12612
R1242 a_418_19028.n1 a_418_19028.t3 3.7821
R1243 a_418_19028.n1 a_418_19028.t1 3.77824
R1244 a_418_19028.n0 a_418_19028.n2 3.04286
R1245 a_418_19028.n4 a_418_19028.n3 2.84345
R1246 a_51982_19260.n0 a_51982_19260.t2 86.4194
R1247 a_51982_19260.n2 a_51982_19260.t5 82.416
R1248 a_51982_19260.n1 a_51982_19260.t4 51.8544
R1249 a_51982_19260.n0 a_51982_19260.t3 51.8072
R1250 a_51982_19260.n3 a_51982_19260.t1 6.28457
R1251 a_51982_19260.n2 a_51982_19260.n1 4.1171
R1252 a_51982_19260.n3 a_51982_19260.n2 2.66253
R1253 a_51982_19260.t0 a_51982_19260.n3 2.21122
R1254 a_51982_19260.n1 a_51982_19260.n0 1.3775
R1255 a_62058_19028.n2 a_62058_19028.t4 11.0089
R1256 a_62058_19028.n2 a_62058_19028.n1 7.28488
R1257 a_62058_19028.n1 a_62058_19028.n0 5.39574
R1258 a_62058_19028.n1 a_62058_19028.t1 4.91248
R1259 a_62058_19028.t0 a_62058_19028.n2 4.12612
R1260 a_62058_19028.n0 a_62058_19028.t2 3.7821
R1261 a_62058_19028.n0 a_62058_19028.t3 3.77824
R1262 a_128226_19028.n1 a_128226_19028.t5 75.0252
R1263 a_128226_19028.n1 a_128226_19028.t4 44.0697
R1264 a_128226_19028.n2 a_128226_19028.t1 10.6055
R1265 a_128226_19028.n0 a_128226_19028.t2 10.6055
R1266 a_128226_19028.n0 a_128226_19028.n2 8.89791
R1267 a_128226_19028.n0 a_128226_19028.n1 5.7951
R1268 a_128226_19028.t0 a_128226_19028.n0 4.53117
R1269 a_128226_19028.n2 a_128226_19028.t3 4.53024
R1270 a_75418_19028.n2 a_75418_19028.t6 74.8588
R1271 a_75418_19028.n3 a_75418_19028.t7 70.3153
R1272 a_75418_19028.n2 a_75418_19028.t5 44.2362
R1273 a_75418_19028.n3 a_75418_19028.t8 39.854
R1274 a_75418_19028.n4 a_75418_19028.n0 11.62
R1275 a_75418_19028.n5 a_75418_19028.t0 11.0089
R1276 a_75418_19028.n5 a_75418_19028.n4 8.15804
R1277 a_75418_19028.n0 a_75418_19028.n1 5.39574
R1278 a_75418_19028.n0 a_75418_19028.t3 4.91248
R1279 a_75418_19028.t2 a_75418_19028.n5 4.12612
R1280 a_75418_19028.n1 a_75418_19028.t4 3.7821
R1281 a_75418_19028.n1 a_75418_19028.t1 3.77824
R1282 a_75418_19028.n0 a_75418_19028.n2 3.04286
R1283 a_75418_19028.n4 a_75418_19028.n3 2.84345
R1284 a_n8838_19260.n2 a_n8838_19260.t4 82.7757
R1285 a_n8838_19260.n3 a_n8838_19260.t2 82.6424
R1286 a_n8838_19260.n1 a_n8838_19260.t3 70.3153
R1287 a_n8838_19260.n2 a_n8838_19260.t6 55.8264
R1288 a_n8838_19260.n4 a_n8838_19260.t7 51.5658
R1289 a_n8838_19260.n1 a_n8838_19260.t5 39.854
R1290 a_n8838_19260.n0 a_n8838_19260.t1 6.02308
R1291 a_n8838_19260.n4 a_n8838_19260.n3 3.9695
R1292 a_n8838_19260.n0 a_n8838_19260.n4 3.3953
R1293 a_n8838_19260.n0 a_n8838_19260.n1 2.70724
R1294 a_n8838_19260.t0 a_n8838_19260.n0 2.47208
R1295 a_n8838_19260.n3 a_n8838_19260.n2 1.3073
R1296 a_n4162_19028.n1 a_n4162_19028.t1 11.0089
R1297 a_n4162_19028.n2 a_n4162_19028.n1 7.51324
R1298 a_n4162_19028.n2 a_n4162_19028.n0 5.39574
R1299 a_n4162_19028.t3 a_n4162_19028.n2 4.91248
R1300 a_n4162_19028.n1 a_n4162_19028.t4 4.12478
R1301 a_n4162_19028.n0 a_n4162_19028.t2 3.7821
R1302 a_n4162_19028.n0 a_n4162_19028.t0 3.77824
R1303 a_n6774_19028.n1 a_n6774_19028.t5 75.0252
R1304 a_n6774_19028.n1 a_n6774_19028.t4 44.0697
R1305 a_n6774_19028.n2 a_n6774_19028.t0 10.6055
R1306 a_n6774_19028.n0 a_n6774_19028.t2 10.6055
R1307 a_n6774_19028.n0 a_n6774_19028.n2 8.89791
R1308 a_n6774_19028.n0 a_n6774_19028.n1 5.7951
R1309 a_n6774_19028.t1 a_n6774_19028.n0 4.53117
R1310 a_n6774_19028.n2 a_n6774_19028.t3 4.53024
R1311 a_n8018_19260.n0 a_n8018_19260.t2 86.4194
R1312 a_n8018_19260.n2 a_n8018_19260.t3 82.416
R1313 a_n8018_19260.n1 a_n8018_19260.t5 51.8544
R1314 a_n8018_19260.n0 a_n8018_19260.t4 51.8072
R1315 a_n8018_19260.n3 a_n8018_19260.t1 6.28457
R1316 a_n8018_19260.n2 a_n8018_19260.n1 4.1171
R1317 a_n8018_19260.n3 a_n8018_19260.n2 2.66253
R1318 a_n8018_19260.t0 a_n8018_19260.n3 2.21122
R1319 a_n8018_19260.n1 a_n8018_19260.n0 1.3775
R1320 a_2058_19028.n1 a_2058_19028.t3 11.0089
R1321 a_2058_19028.n2 a_2058_19028.n1 7.28488
R1322 a_2058_19028.n2 a_2058_19028.n0 5.39574
R1323 a_2058_19028.t0 a_2058_19028.n2 4.91248
R1324 a_2058_19028.n1 a_2058_19028.t4 4.12478
R1325 a_2058_19028.n0 a_2058_19028.t1 3.7821
R1326 a_2058_19028.n0 a_2058_19028.t2 3.77824
R1327 a_84210_19028.n0 a_84210_19028.t5 74.8588
R1328 a_84210_19028.n0 a_84210_19028.t6 44.2362
R1329 a_84210_19028.n0 a_84210_19028.n2 14.5242
R1330 a_84210_19028.n2 a_84210_19028.t4 11.0089
R1331 a_84210_19028.n3 a_84210_19028.n1 5.39574
R1332 a_84210_19028.t1 a_84210_19028.n3 4.91248
R1333 a_84210_19028.n2 a_84210_19028.t3 4.12478
R1334 a_84210_19028.n1 a_84210_19028.t0 3.7821
R1335 a_84210_19028.n1 a_84210_19028.t2 3.77824
R1336 a_84210_19028.n3 a_84210_19028.n0 1.83141
R1337 a_111162_19260.n2 a_111162_19260.t4 82.7757
R1338 a_111162_19260.n3 a_111162_19260.t7 82.6424
R1339 a_111162_19260.n1 a_111162_19260.t6 70.3153
R1340 a_111162_19260.n2 a_111162_19260.t2 55.8264
R1341 a_111162_19260.n4 a_111162_19260.t5 51.5658
R1342 a_111162_19260.n1 a_111162_19260.t3 39.854
R1343 a_111162_19260.n0 a_111162_19260.t1 6.02308
R1344 a_111162_19260.n4 a_111162_19260.n3 3.9695
R1345 a_111162_19260.n0 a_111162_19260.n4 3.3953
R1346 a_111162_19260.n0 a_111162_19260.n1 2.70724
R1347 a_111162_19260.t0 a_111162_19260.n0 2.47208
R1348 a_111162_19260.n3 a_111162_19260.n2 1.3073
R1349 a_122058_19028.n2 a_122058_19028.t0 11.0089
R1350 a_122058_19028.n2 a_122058_19028.n1 7.28488
R1351 a_122058_19028.n1 a_122058_19028.n0 5.39574
R1352 a_122058_19028.n1 a_122058_19028.t4 4.91248
R1353 a_122058_19028.t2 a_122058_19028.n2 4.12612
R1354 a_122058_19028.n0 a_122058_19028.t3 3.7821
R1355 a_122058_19028.n0 a_122058_19028.t1 3.77824
R1356 D.n0 D.t0 11.0089
R1357 D D.n0 9.51039
R1358 D.n0 D.t1 4.12478
R1359 a_51162_19260.n2 a_51162_19260.t2 82.7757
R1360 a_51162_19260.n3 a_51162_19260.t5 82.6424
R1361 a_51162_19260.n1 a_51162_19260.t4 70.3153
R1362 a_51162_19260.n2 a_51162_19260.t6 55.8264
R1363 a_51162_19260.n4 a_51162_19260.t3 51.5658
R1364 a_51162_19260.n1 a_51162_19260.t7 39.854
R1365 a_51162_19260.n0 a_51162_19260.t1 6.02308
R1366 a_51162_19260.n4 a_51162_19260.n3 3.9695
R1367 a_51162_19260.n0 a_51162_19260.n4 3.3953
R1368 a_51162_19260.n0 a_51162_19260.n1 2.70724
R1369 a_51162_19260.t0 a_51162_19260.n0 2.47208
R1370 a_51162_19260.n3 a_51162_19260.n2 1.3073
R1371 a_25838_19028.n1 a_25838_19028.t0 11.0089
R1372 a_25838_19028.n2 a_25838_19028.n1 7.51324
R1373 a_25838_19028.n2 a_25838_19028.n0 5.39574
R1374 a_25838_19028.t2 a_25838_19028.n2 4.91248
R1375 a_25838_19028.n1 a_25838_19028.t3 4.12478
R1376 a_25838_19028.n0 a_25838_19028.t1 3.7821
R1377 a_25838_19028.n0 a_25838_19028.t4 3.77824
R1378 a_144210_19028.n0 a_144210_19028.t6 74.8588
R1379 a_144210_19028.n0 a_144210_19028.t5 44.2362
R1380 a_144210_19028.n3 a_144210_19028.n0 14.5242
R1381 a_144210_19028.n3 a_144210_19028.t1 11.0089
R1382 a_144210_19028.n2 a_144210_19028.n1 5.39574
R1383 a_144210_19028.n2 a_144210_19028.t2 4.91248
R1384 a_144210_19028.t0 a_144210_19028.n3 4.12612
R1385 a_144210_19028.n1 a_144210_19028.t4 3.7821
R1386 a_144210_19028.n1 a_144210_19028.t3 3.77824
R1387 a_144210_19028.n0 a_144210_19028.n2 1.83141
R1388 a_145838_19028.n2 a_145838_19028.t1 11.0089
R1389 a_145838_19028.n2 a_145838_19028.n1 7.51324
R1390 a_145838_19028.n1 a_145838_19028.n0 5.39574
R1391 a_145838_19028.n1 a_145838_19028.t3 4.91248
R1392 a_145838_19028.t2 a_145838_19028.n2 4.12612
R1393 a_145838_19028.n0 a_145838_19028.t4 3.7821
R1394 a_145838_19028.n0 a_145838_19028.t0 3.77824
R1395 a_111982_19260.n0 a_111982_19260.t2 86.4194
R1396 a_111982_19260.n2 a_111982_19260.t5 82.416
R1397 a_111982_19260.n1 a_111982_19260.t4 51.8544
R1398 a_111982_19260.n0 a_111982_19260.t3 51.8072
R1399 a_111982_19260.n3 a_111982_19260.t1 6.28457
R1400 a_111982_19260.n2 a_111982_19260.n1 4.1171
R1401 a_111982_19260.n3 a_111982_19260.n2 2.66253
R1402 a_111982_19260.t0 a_111982_19260.n3 2.21122
R1403 a_111982_19260.n1 a_111982_19260.n0 1.3775
R1404 a_36982_19260.n0 a_36982_19260.t4 86.4194
R1405 a_36982_19260.n2 a_36982_19260.t3 82.416
R1406 a_36982_19260.n1 a_36982_19260.t5 51.8544
R1407 a_36982_19260.n0 a_36982_19260.t2 51.8072
R1408 a_36982_19260.n3 a_36982_19260.t1 6.28457
R1409 a_36982_19260.n2 a_36982_19260.n1 4.1171
R1410 a_36982_19260.n3 a_36982_19260.n2 2.66253
R1411 a_36982_19260.t0 a_36982_19260.n3 2.21122
R1412 a_36982_19260.n1 a_36982_19260.n0 1.3775
R1413 a_39210_19028.n0 a_39210_19028.t6 74.8588
R1414 a_39210_19028.n0 a_39210_19028.t5 44.2362
R1415 a_39210_19028.n3 a_39210_19028.n0 14.5242
R1416 a_39210_19028.n3 a_39210_19028.t0 11.0089
R1417 a_39210_19028.n2 a_39210_19028.n1 5.39574
R1418 a_39210_19028.n2 a_39210_19028.t2 4.91248
R1419 a_39210_19028.t1 a_39210_19028.n3 4.12612
R1420 a_39210_19028.n1 a_39210_19028.t3 3.7821
R1421 a_39210_19028.n1 a_39210_19028.t4 3.77824
R1422 a_39210_19028.n0 a_39210_19028.n2 1.83141
R1423 a_54210_19028.n0 a_54210_19028.t6 74.8588
R1424 a_54210_19028.n0 a_54210_19028.t5 44.2362
R1425 a_54210_19028.n3 a_54210_19028.n0 14.5242
R1426 a_54210_19028.n3 a_54210_19028.t1 11.0089
R1427 a_54210_19028.n2 a_54210_19028.n1 5.39574
R1428 a_54210_19028.n2 a_54210_19028.t3 4.91248
R1429 a_54210_19028.t0 a_54210_19028.n3 4.12612
R1430 a_54210_19028.n1 a_54210_19028.t2 3.7821
R1431 a_54210_19028.n1 a_54210_19028.t4 3.77824
R1432 a_54210_19028.n0 a_54210_19028.n2 1.83141
R1433 a_66162_19260.n2 a_66162_19260.t5 82.7757
R1434 a_66162_19260.n3 a_66162_19260.t4 82.6424
R1435 a_66162_19260.n1 a_66162_19260.t7 70.3153
R1436 a_66162_19260.n2 a_66162_19260.t2 55.8264
R1437 a_66162_19260.n4 a_66162_19260.t6 51.5658
R1438 a_66162_19260.n1 a_66162_19260.t3 39.854
R1439 a_66162_19260.n0 a_66162_19260.t1 6.02308
R1440 a_66162_19260.n4 a_66162_19260.n3 3.9695
R1441 a_66162_19260.n0 a_66162_19260.n4 3.3953
R1442 a_66162_19260.n0 a_66162_19260.n1 2.70724
R1443 a_66162_19260.t0 a_66162_19260.n0 2.47208
R1444 a_66162_19260.n3 a_66162_19260.n2 1.3073
R1445 a_77058_19028.n1 a_77058_19028.t0 11.0089
R1446 a_77058_19028.n2 a_77058_19028.n1 7.28488
R1447 a_77058_19028.n2 a_77058_19028.n0 5.39574
R1448 a_77058_19028.t1 a_77058_19028.n2 4.91248
R1449 a_77058_19028.n1 a_77058_19028.t3 4.12478
R1450 a_77058_19028.n0 a_77058_19028.t2 3.7821
R1451 a_77058_19028.n0 a_77058_19028.t4 3.77824
R1452 a_66982_19260.n0 a_66982_19260.t2 86.4194
R1453 a_66982_19260.n2 a_66982_19260.t5 82.416
R1454 a_66982_19260.n1 a_66982_19260.t3 51.8544
R1455 a_66982_19260.n0 a_66982_19260.t4 51.8072
R1456 a_66982_19260.n3 a_66982_19260.t1 6.28457
R1457 a_66982_19260.n2 a_66982_19260.n1 4.1171
R1458 a_66982_19260.n3 a_66982_19260.n2 2.66253
R1459 a_66982_19260.t0 a_66982_19260.n3 2.21122
R1460 a_66982_19260.n1 a_66982_19260.n0 1.3775
R1461 a_6162_19260.n2 a_6162_19260.t4 82.7757
R1462 a_6162_19260.n3 a_6162_19260.t3 82.6424
R1463 a_6162_19260.n1 a_6162_19260.t7 70.3153
R1464 a_6162_19260.n2 a_6162_19260.t5 55.8264
R1465 a_6162_19260.n4 a_6162_19260.t6 51.5658
R1466 a_6162_19260.n1 a_6162_19260.t2 39.854
R1467 a_6162_19260.n0 a_6162_19260.t1 6.02308
R1468 a_6162_19260.n4 a_6162_19260.n3 3.9695
R1469 a_6162_19260.n0 a_6162_19260.n4 3.3953
R1470 a_6162_19260.n0 a_6162_19260.n1 2.70724
R1471 a_6162_19260.t0 a_6162_19260.n0 2.47208
R1472 a_6162_19260.n3 a_6162_19260.n2 1.3073
R1473 a_6982_19260.n0 a_6982_19260.t4 86.4194
R1474 a_6982_19260.n2 a_6982_19260.t5 82.416
R1475 a_6982_19260.n1 a_6982_19260.t2 51.8544
R1476 a_6982_19260.n0 a_6982_19260.t3 51.8072
R1477 a_6982_19260.n3 a_6982_19260.t1 6.28457
R1478 a_6982_19260.n2 a_6982_19260.n1 4.1171
R1479 a_6982_19260.n3 a_6982_19260.n2 2.66253
R1480 a_6982_19260.t0 a_6982_19260.n3 2.21122
R1481 a_6982_19260.n1 a_6982_19260.n0 1.3775
R1482 a_30418_19028.n5 a_30418_19028.t7 74.8588
R1483 a_30418_19028.n2 a_30418_19028.t8 70.3153
R1484 a_30418_19028.n5 a_30418_19028.t6 44.2362
R1485 a_30418_19028.n2 a_30418_19028.t5 39.854
R1486 a_30418_19028.n0 a_30418_19028.n4 11.62
R1487 a_30418_19028.n3 a_30418_19028.t3 11.0089
R1488 a_30418_19028.n4 a_30418_19028.n3 8.15804
R1489 a_30418_19028.n0 a_30418_19028.n1 5.39574
R1490 a_30418_19028.t1 a_30418_19028.n0 4.91248
R1491 a_30418_19028.n3 a_30418_19028.t2 4.12478
R1492 a_30418_19028.n1 a_30418_19028.t0 3.7821
R1493 a_30418_19028.n1 a_30418_19028.t4 3.77824
R1494 a_30418_19028.n0 a_30418_19028.n5 3.04286
R1495 a_30418_19028.n4 a_30418_19028.n2 2.84345
R1496 a_15418_19028.n5 a_15418_19028.t6 74.8588
R1497 a_15418_19028.n2 a_15418_19028.t7 70.3153
R1498 a_15418_19028.n5 a_15418_19028.t5 44.2362
R1499 a_15418_19028.n2 a_15418_19028.t8 39.854
R1500 a_15418_19028.n0 a_15418_19028.n4 11.62
R1501 a_15418_19028.n3 a_15418_19028.t4 11.0089
R1502 a_15418_19028.n4 a_15418_19028.n3 8.15804
R1503 a_15418_19028.n0 a_15418_19028.n1 5.39574
R1504 a_15418_19028.t1 a_15418_19028.n0 4.91248
R1505 a_15418_19028.n3 a_15418_19028.t2 4.12478
R1506 a_15418_19028.n1 a_15418_19028.t0 3.7821
R1507 a_15418_19028.n1 a_15418_19028.t3 3.77824
R1508 a_15418_19028.n0 a_15418_19028.n5 3.04286
R1509 a_15418_19028.n4 a_15418_19028.n2 2.84345
R1510 a_17058_19028.n2 a_17058_19028.t1 11.0089
R1511 a_17058_19028.n2 a_17058_19028.n1 7.28488
R1512 a_17058_19028.n1 a_17058_19028.n0 5.39574
R1513 a_17058_19028.n1 a_17058_19028.t2 4.91248
R1514 a_17058_19028.t0 a_17058_19028.n2 4.12612
R1515 a_17058_19028.n0 a_17058_19028.t3 3.7821
R1516 a_17058_19028.n0 a_17058_19028.t4 3.77824
R1517 a_105418_19028.n2 a_105418_19028.t8 74.8588
R1518 a_105418_19028.n3 a_105418_19028.t5 70.3153
R1519 a_105418_19028.n2 a_105418_19028.t7 44.2362
R1520 a_105418_19028.n3 a_105418_19028.t6 39.854
R1521 a_105418_19028.n4 a_105418_19028.n0 11.62
R1522 a_105418_19028.n5 a_105418_19028.t0 11.0089
R1523 a_105418_19028.n5 a_105418_19028.n4 8.15804
R1524 a_105418_19028.n0 a_105418_19028.n1 5.39574
R1525 a_105418_19028.n0 a_105418_19028.t2 4.91248
R1526 a_105418_19028.t1 a_105418_19028.n5 4.12612
R1527 a_105418_19028.n1 a_105418_19028.t3 3.7821
R1528 a_105418_19028.n1 a_105418_19028.t4 3.77824
R1529 a_105418_19028.n0 a_105418_19028.n2 3.04286
R1530 a_105418_19028.n4 a_105418_19028.n3 2.84345
R1531 a_8226_19028.n1 a_8226_19028.t5 75.0252
R1532 a_8226_19028.n1 a_8226_19028.t4 44.0697
R1533 a_8226_19028.n2 a_8226_19028.t0 10.6055
R1534 a_8226_19028.n0 a_8226_19028.t3 10.6055
R1535 a_8226_19028.n0 a_8226_19028.n2 8.89791
R1536 a_8226_19028.n0 a_8226_19028.n1 5.7951
R1537 a_8226_19028.t1 a_8226_19028.n0 4.53117
R1538 a_8226_19028.n2 a_8226_19028.t2 4.53024
R1539 a_47058_19028.n2 a_47058_19028.t4 11.0089
R1540 a_47058_19028.n2 a_47058_19028.n1 7.28488
R1541 a_47058_19028.n1 a_47058_19028.n0 5.39574
R1542 a_47058_19028.n1 a_47058_19028.t3 4.91248
R1543 a_47058_19028.t0 a_47058_19028.n2 4.12612
R1544 a_47058_19028.n0 a_47058_19028.t2 3.7821
R1545 a_47058_19028.n0 a_47058_19028.t1 3.77824
R1546 a_135418_19028.n2 a_135418_19028.t6 74.8588
R1547 a_135418_19028.n3 a_135418_19028.t7 70.3153
R1548 a_135418_19028.n2 a_135418_19028.t5 44.2362
R1549 a_135418_19028.n3 a_135418_19028.t8 39.854
R1550 a_135418_19028.n4 a_135418_19028.n0 11.62
R1551 a_135418_19028.n5 a_135418_19028.t3 11.0089
R1552 a_135418_19028.n5 a_135418_19028.n4 8.15804
R1553 a_135418_19028.n0 a_135418_19028.n1 5.39574
R1554 a_135418_19028.n0 a_135418_19028.t2 4.91248
R1555 a_135418_19028.t0 a_135418_19028.n5 4.12612
R1556 a_135418_19028.n1 a_135418_19028.t1 3.7821
R1557 a_135418_19028.n1 a_135418_19028.t4 3.77824
R1558 a_135418_19028.n0 a_135418_19028.n2 3.04286
R1559 a_135418_19028.n4 a_135418_19028.n3 2.84345
R1560 a_36162_19260.n2 a_36162_19260.t2 82.7757
R1561 a_36162_19260.n3 a_36162_19260.t7 82.6424
R1562 a_36162_19260.n1 a_36162_19260.t4 70.3153
R1563 a_36162_19260.n2 a_36162_19260.t6 55.8264
R1564 a_36162_19260.n4 a_36162_19260.t3 51.5658
R1565 a_36162_19260.n1 a_36162_19260.t5 39.854
R1566 a_36162_19260.n0 a_36162_19260.t1 6.02308
R1567 a_36162_19260.n4 a_36162_19260.n3 3.9695
R1568 a_36162_19260.n0 a_36162_19260.n4 3.3953
R1569 a_36162_19260.n0 a_36162_19260.n1 2.70724
R1570 a_36162_19260.t0 a_36162_19260.n0 2.47208
R1571 a_36162_19260.n3 a_36162_19260.n2 1.3073
R1572 a_137058_19028.n2 a_137058_19028.t2 11.0089
R1573 a_137058_19028.n2 a_137058_19028.n1 7.28488
R1574 a_137058_19028.n1 a_137058_19028.n0 5.39574
R1575 a_137058_19028.n1 a_137058_19028.t3 4.91248
R1576 a_137058_19028.t1 a_137058_19028.n2 4.12612
R1577 a_137058_19028.n0 a_137058_19028.t4 3.7821
R1578 a_137058_19028.n0 a_137058_19028.t0 3.77824
R1579 a_114210_19028.n0 a_114210_19028.t6 74.8588
R1580 a_114210_19028.n0 a_114210_19028.t5 44.2362
R1581 a_114210_19028.n3 a_114210_19028.n0 14.5242
R1582 a_114210_19028.n3 a_114210_19028.t1 11.0089
R1583 a_114210_19028.n2 a_114210_19028.n1 5.39574
R1584 a_114210_19028.n2 a_114210_19028.t4 4.91248
R1585 a_114210_19028.t0 a_114210_19028.n3 4.12612
R1586 a_114210_19028.n1 a_114210_19028.t3 3.7821
R1587 a_114210_19028.n1 a_114210_19028.t2 3.77824
R1588 a_114210_19028.n0 a_114210_19028.n2 1.83141
R1589 a_96982_19260.n0 a_96982_19260.t4 86.4194
R1590 a_96982_19260.n2 a_96982_19260.t3 82.416
R1591 a_96982_19260.n1 a_96982_19260.t5 51.8544
R1592 a_96982_19260.n0 a_96982_19260.t2 51.8072
R1593 a_96982_19260.n3 a_96982_19260.t1 6.28457
R1594 a_96982_19260.n2 a_96982_19260.n1 4.1171
R1595 a_96982_19260.n3 a_96982_19260.n2 2.66253
R1596 a_96982_19260.t0 a_96982_19260.n3 2.21122
R1597 a_96982_19260.n1 a_96982_19260.n0 1.3775
R1598 a_90418_19028.n2 a_90418_19028.t8 74.8588
R1599 a_90418_19028.n3 a_90418_19028.t5 70.3153
R1600 a_90418_19028.n2 a_90418_19028.t7 44.2362
R1601 a_90418_19028.n3 a_90418_19028.t6 39.854
R1602 a_90418_19028.n4 a_90418_19028.n0 11.62
R1603 a_90418_19028.n5 a_90418_19028.t3 11.0089
R1604 a_90418_19028.n5 a_90418_19028.n4 8.15804
R1605 a_90418_19028.n0 a_90418_19028.n1 5.39574
R1606 a_90418_19028.n0 a_90418_19028.t1 4.91248
R1607 a_90418_19028.t0 a_90418_19028.n5 4.12612
R1608 a_90418_19028.n1 a_90418_19028.t2 3.7821
R1609 a_90418_19028.n1 a_90418_19028.t4 3.77824
R1610 a_90418_19028.n0 a_90418_19028.n2 3.04286
R1611 a_90418_19028.n4 a_90418_19028.n3 2.84345
R1612 a_69210_19028.n0 a_69210_19028.t6 74.8588
R1613 a_69210_19028.n0 a_69210_19028.t5 44.2362
R1614 a_69210_19028.n3 a_69210_19028.n0 14.5242
R1615 a_69210_19028.n3 a_69210_19028.t0 11.0089
R1616 a_69210_19028.n2 a_69210_19028.n1 5.39574
R1617 a_69210_19028.n2 a_69210_19028.t3 4.91248
R1618 a_69210_19028.t1 a_69210_19028.n3 4.12612
R1619 a_69210_19028.n1 a_69210_19028.t4 3.7821
R1620 a_69210_19028.n1 a_69210_19028.t2 3.77824
R1621 a_69210_19028.n0 a_69210_19028.n2 1.83141
R1622 a_9210_19028.n0 a_9210_19028.t6 74.8588
R1623 a_9210_19028.n0 a_9210_19028.t5 44.2362
R1624 a_9210_19028.n3 a_9210_19028.n0 14.5242
R1625 a_9210_19028.n3 a_9210_19028.t0 11.0089
R1626 a_9210_19028.n2 a_9210_19028.n1 5.39574
R1627 a_9210_19028.n2 a_9210_19028.t2 4.91248
R1628 a_9210_19028.t1 a_9210_19028.n3 4.12612
R1629 a_9210_19028.n1 a_9210_19028.t3 3.7821
R1630 a_9210_19028.n1 a_9210_19028.t4 3.77824
R1631 a_9210_19028.n0 a_9210_19028.n2 1.83141
R1632 a_21162_19260.n2 a_21162_19260.t7 82.7757
R1633 a_21162_19260.n3 a_21162_19260.t4 82.6424
R1634 a_21162_19260.n1 a_21162_19260.t3 70.3153
R1635 a_21162_19260.n2 a_21162_19260.t6 55.8264
R1636 a_21162_19260.n4 a_21162_19260.t2 51.5658
R1637 a_21162_19260.n1 a_21162_19260.t5 39.854
R1638 a_21162_19260.n0 a_21162_19260.t1 6.02308
R1639 a_21162_19260.n4 a_21162_19260.n3 3.9695
R1640 a_21162_19260.n0 a_21162_19260.n4 3.3953
R1641 a_21162_19260.n0 a_21162_19260.n1 2.70724
R1642 a_21162_19260.t0 a_21162_19260.n0 2.47208
R1643 a_21162_19260.n3 a_21162_19260.n2 1.3073
R1644 a_23226_19028.n1 a_23226_19028.t5 75.0252
R1645 a_23226_19028.n1 a_23226_19028.t4 44.0697
R1646 a_23226_19028.n2 a_23226_19028.t2 10.6055
R1647 a_23226_19028.n0 a_23226_19028.t1 10.6055
R1648 a_23226_19028.n2 a_23226_19028.n0 8.89791
R1649 a_23226_19028.n0 a_23226_19028.n1 5.7951
R1650 a_23226_19028.t0 a_23226_19028.n2 4.53117
R1651 a_23226_19028.n0 a_23226_19028.t3 4.53024
R1652 a_70838_19028.n2 a_70838_19028.t0 11.0089
R1653 a_70838_19028.n2 a_70838_19028.n1 7.51324
R1654 a_70838_19028.n1 a_70838_19028.n0 5.39574
R1655 a_70838_19028.n1 a_70838_19028.t4 4.91248
R1656 a_70838_19028.t1 a_70838_19028.n2 4.12612
R1657 a_70838_19028.n0 a_70838_19028.t3 3.7821
R1658 a_70838_19028.n0 a_70838_19028.t2 3.77824
R1659 a_21982_19260.n0 a_21982_19260.t4 86.4194
R1660 a_21982_19260.n2 a_21982_19260.t3 82.416
R1661 a_21982_19260.n1 a_21982_19260.t2 51.8544
R1662 a_21982_19260.n0 a_21982_19260.t5 51.8072
R1663 a_21982_19260.n3 a_21982_19260.t1 6.28457
R1664 a_21982_19260.n2 a_21982_19260.n1 4.1171
R1665 a_21982_19260.n3 a_21982_19260.n2 2.66253
R1666 a_21982_19260.t0 a_21982_19260.n3 2.21122
R1667 a_21982_19260.n1 a_21982_19260.n0 1.3775
R1668 a_107058_19028.n2 a_107058_19028.t2 11.0089
R1669 a_107058_19028.n2 a_107058_19028.n1 7.28488
R1670 a_107058_19028.n1 a_107058_19028.n0 5.39574
R1671 a_107058_19028.n1 a_107058_19028.t3 4.91248
R1672 a_107058_19028.t1 a_107058_19028.n2 4.12612
R1673 a_107058_19028.n0 a_107058_19028.t4 3.7821
R1674 a_107058_19028.n0 a_107058_19028.t0 3.77824
R1675 a_96162_19260.n2 a_96162_19260.t2 82.7757
R1676 a_96162_19260.n3 a_96162_19260.t7 82.6424
R1677 a_96162_19260.n1 a_96162_19260.t5 70.3153
R1678 a_96162_19260.n2 a_96162_19260.t4 55.8264
R1679 a_96162_19260.n4 a_96162_19260.t3 51.5658
R1680 a_96162_19260.n1 a_96162_19260.t6 39.854
R1681 a_96162_19260.n0 a_96162_19260.t1 6.02308
R1682 a_96162_19260.n4 a_96162_19260.n3 3.9695
R1683 a_96162_19260.n0 a_96162_19260.n4 3.3953
R1684 a_96162_19260.n0 a_96162_19260.n1 2.70724
R1685 a_96162_19260.t0 a_96162_19260.n0 2.47208
R1686 a_96162_19260.n3 a_96162_19260.n2 1.3073
R1687 a_150418_19028.n3 a_150418_19028.t6 74.8588
R1688 a_150418_19028.n2 a_150418_19028.t3 70.3153
R1689 a_150418_19028.n3 a_150418_19028.t5 44.2362
R1690 a_150418_19028.n2 a_150418_19028.t4 39.854
R1691 a_150418_19028.n0 a_150418_19028.n2 14.463
R1692 a_150418_19028.n0 a_150418_19028.n1 5.39574
R1693 a_150418_19028.t0 a_150418_19028.n0 4.91248
R1694 a_150418_19028.n1 a_150418_19028.t1 3.7821
R1695 a_150418_19028.n1 a_150418_19028.t2 3.77824
R1696 a_150418_19028.n0 a_150418_19028.n3 3.04286
R1697 a_53226_19028.n1 a_53226_19028.t5 75.0252
R1698 a_53226_19028.n1 a_53226_19028.t4 44.0697
R1699 a_53226_19028.n2 a_53226_19028.t2 10.6055
R1700 a_53226_19028.n0 a_53226_19028.t0 10.6055
R1701 a_53226_19028.n2 a_53226_19028.n0 8.89791
R1702 a_53226_19028.n0 a_53226_19028.n1 5.7951
R1703 a_53226_19028.t1 a_53226_19028.n2 4.53117
R1704 a_53226_19028.n0 a_53226_19028.t3 4.53024
R1705 a_92058_19028.n1 a_92058_19028.t4 11.0089
R1706 a_92058_19028.n2 a_92058_19028.n1 7.28488
R1707 a_92058_19028.n2 a_92058_19028.n0 5.39574
R1708 a_92058_19028.t0 a_92058_19028.n2 4.91248
R1709 a_92058_19028.n1 a_92058_19028.t3 4.12478
R1710 a_92058_19028.n0 a_92058_19028.t1 3.7821
R1711 a_92058_19028.n0 a_92058_19028.t2 3.77824
R1712 a_130838_19028.n1 a_130838_19028.t1 11.0089
R1713 a_130838_19028.n2 a_130838_19028.n1 7.51324
R1714 a_130838_19028.n2 a_130838_19028.n0 5.39574
R1715 a_130838_19028.t2 a_130838_19028.n2 4.91248
R1716 a_130838_19028.n1 a_130838_19028.t4 4.12478
R1717 a_130838_19028.n0 a_130838_19028.t3 3.7821
R1718 a_130838_19028.n0 a_130838_19028.t0 3.77824
R1719 a_40838_19028.n2 a_40838_19028.t1 11.0089
R1720 a_40838_19028.n2 a_40838_19028.n1 7.51324
R1721 a_40838_19028.n1 a_40838_19028.n0 5.39574
R1722 a_40838_19028.n1 a_40838_19028.t3 4.91248
R1723 a_40838_19028.t2 a_40838_19028.n2 4.12612
R1724 a_40838_19028.n0 a_40838_19028.t4 3.7821
R1725 a_40838_19028.n0 a_40838_19028.t0 3.77824
R1726 a_38226_19028.n1 a_38226_19028.t5 75.0252
R1727 a_38226_19028.n1 a_38226_19028.t4 44.0697
R1728 a_38226_19028.n2 a_38226_19028.t0 10.6055
R1729 a_38226_19028.n0 a_38226_19028.t3 10.6055
R1730 a_38226_19028.n0 a_38226_19028.n2 8.89791
R1731 a_38226_19028.n0 a_38226_19028.n1 5.7951
R1732 a_38226_19028.t1 a_38226_19028.n0 4.53117
R1733 a_38226_19028.n2 a_38226_19028.t2 4.53024
R1734 a_85838_19028.n1 a_85838_19028.t2 11.0089
R1735 a_85838_19028.n2 a_85838_19028.n1 7.51324
R1736 a_85838_19028.n2 a_85838_19028.n0 5.39574
R1737 a_85838_19028.t0 a_85838_19028.n2 4.91248
R1738 a_85838_19028.n1 a_85838_19028.t4 4.12478
R1739 a_85838_19028.n0 a_85838_19028.t1 3.7821
R1740 a_85838_19028.n0 a_85838_19028.t3 3.77824
R1741 a_113226_19028.n1 a_113226_19028.t5 75.0252
R1742 a_113226_19028.n1 a_113226_19028.t4 44.0697
R1743 a_113226_19028.n2 a_113226_19028.t3 10.6055
R1744 a_113226_19028.n0 a_113226_19028.t0 10.6055
R1745 a_113226_19028.n2 a_113226_19028.n0 8.89791
R1746 a_113226_19028.n0 a_113226_19028.n1 5.7951
R1747 a_113226_19028.t1 a_113226_19028.n2 4.53117
R1748 a_113226_19028.n0 a_113226_19028.t2 4.53024
R1749 a_152058_19028.n2 a_152058_19028.t2 11.0089
R1750 a_152058_19028.n2 a_152058_19028.n1 7.28488
R1751 a_152058_19028.n1 a_152058_19028.n0 5.39574
R1752 a_152058_19028.n1 a_152058_19028.t3 4.91248
R1753 a_152058_19028.t0 a_152058_19028.n2 4.12612
R1754 a_152058_19028.n0 a_152058_19028.t4 3.7821
R1755 a_152058_19028.n0 a_152058_19028.t1 3.77824
R1756 a_68226_19028.n1 a_68226_19028.t5 75.0252
R1757 a_68226_19028.n1 a_68226_19028.t4 44.0697
R1758 a_68226_19028.n2 a_68226_19028.t0 10.6055
R1759 a_68226_19028.n0 a_68226_19028.t3 10.6055
R1760 a_68226_19028.n0 a_68226_19028.n2 8.89791
R1761 a_68226_19028.n0 a_68226_19028.n1 5.7951
R1762 a_68226_19028.t1 a_68226_19028.n0 4.53117
R1763 a_68226_19028.n2 a_68226_19028.t2 4.53024
R1764 a_100838_19028.n1 a_100838_19028.t1 11.0089
R1765 a_100838_19028.n2 a_100838_19028.n1 7.51324
R1766 a_100838_19028.n2 a_100838_19028.n0 5.39574
R1767 a_100838_19028.t2 a_100838_19028.n2 4.91248
R1768 a_100838_19028.n1 a_100838_19028.t4 4.12478
R1769 a_100838_19028.n0 a_100838_19028.t3 3.7821
R1770 a_100838_19028.n0 a_100838_19028.t0 3.77824
R1771 a_55838_19028.n2 a_55838_19028.t2 11.0089
R1772 a_55838_19028.n2 a_55838_19028.n1 7.51324
R1773 a_55838_19028.n1 a_55838_19028.n0 5.39574
R1774 a_55838_19028.n1 a_55838_19028.t3 4.91248
R1775 a_55838_19028.t1 a_55838_19028.n2 4.12612
R1776 a_55838_19028.n0 a_55838_19028.t4 3.7821
R1777 a_55838_19028.n0 a_55838_19028.t0 3.77824
R1778 a_81162_19260.n2 a_81162_19260.t7 82.7757
R1779 a_81162_19260.n3 a_81162_19260.t4 82.6424
R1780 a_81162_19260.n1 a_81162_19260.t3 70.3153
R1781 a_81162_19260.n2 a_81162_19260.t5 55.8264
R1782 a_81162_19260.n4 a_81162_19260.t2 51.5658
R1783 a_81162_19260.n1 a_81162_19260.t6 39.854
R1784 a_81162_19260.n0 a_81162_19260.t1 6.02308
R1785 a_81162_19260.n4 a_81162_19260.n3 3.9695
R1786 a_81162_19260.n0 a_81162_19260.n4 3.3953
R1787 a_81162_19260.n0 a_81162_19260.n1 2.70724
R1788 a_81162_19260.t0 a_81162_19260.n0 2.47208
R1789 a_81162_19260.n3 a_81162_19260.n2 1.3073
R1790 a_83226_19028.n1 a_83226_19028.t5 75.0252
R1791 a_83226_19028.n1 a_83226_19028.t4 44.0697
R1792 a_83226_19028.n2 a_83226_19028.t0 10.6055
R1793 a_83226_19028.n0 a_83226_19028.t3 10.6055
R1794 a_83226_19028.n0 a_83226_19028.n2 8.89791
R1795 a_83226_19028.n0 a_83226_19028.n1 5.7951
R1796 a_83226_19028.t1 a_83226_19028.n0 4.53117
R1797 a_83226_19028.n2 a_83226_19028.t2 4.53024
R1798 a_81982_19260.n0 a_81982_19260.t4 86.4194
R1799 a_81982_19260.n2 a_81982_19260.t3 82.416
R1800 a_81982_19260.n1 a_81982_19260.t2 51.8544
R1801 a_81982_19260.n0 a_81982_19260.t5 51.8072
R1802 a_81982_19260.n3 a_81982_19260.t1 6.28457
R1803 a_81982_19260.n2 a_81982_19260.n1 4.1171
R1804 a_81982_19260.n3 a_81982_19260.n2 2.66253
R1805 a_81982_19260.t0 a_81982_19260.n3 2.21122
R1806 a_81982_19260.n1 a_81982_19260.n0 1.3775
R1807 a_n5790_19028.n0 a_n5790_19028.t6 74.8588
R1808 a_n5790_19028.n0 a_n5790_19028.t5 44.2362
R1809 a_n5790_19028.n3 a_n5790_19028.n0 14.5242
R1810 a_n5790_19028.n3 a_n5790_19028.t4 11.0089
R1811 a_n5790_19028.n2 a_n5790_19028.n1 5.39574
R1812 a_n5790_19028.n2 a_n5790_19028.t2 4.91248
R1813 a_n5790_19028.t1 a_n5790_19028.n3 4.12612
R1814 a_n5790_19028.n1 a_n5790_19028.t3 3.7821
R1815 a_n5790_19028.n1 a_n5790_19028.t0 3.77824
R1816 a_n5790_19028.n0 a_n5790_19028.n2 1.83141
R1817 a_115838_19028.n2 a_115838_19028.t2 11.0089
R1818 a_115838_19028.n2 a_115838_19028.n1 7.51324
R1819 a_115838_19028.n1 a_115838_19028.n0 5.39574
R1820 a_115838_19028.n1 a_115838_19028.t3 4.91248
R1821 a_115838_19028.t1 a_115838_19028.n2 4.12612
R1822 a_115838_19028.n0 a_115838_19028.t4 3.7821
R1823 a_115838_19028.n0 a_115838_19028.t0 3.77824
R1824 a_24210_19028.n0 a_24210_19028.t6 74.8588
R1825 a_24210_19028.n0 a_24210_19028.t5 44.2362
R1826 a_24210_19028.n0 a_24210_19028.n2 14.5242
R1827 a_24210_19028.n2 a_24210_19028.t0 11.0089
R1828 a_24210_19028.n3 a_24210_19028.n1 5.39574
R1829 a_24210_19028.t1 a_24210_19028.n3 4.91248
R1830 a_24210_19028.n2 a_24210_19028.t3 4.12478
R1831 a_24210_19028.n1 a_24210_19028.t2 3.7821
R1832 a_24210_19028.n1 a_24210_19028.t4 3.77824
R1833 a_24210_19028.n3 a_24210_19028.n0 1.83141
R1834 a_141162_19260.n2 a_141162_19260.t7 82.7757
R1835 a_141162_19260.n3 a_141162_19260.t4 82.6424
R1836 a_141162_19260.n1 a_141162_19260.t3 70.3153
R1837 a_141162_19260.n2 a_141162_19260.t5 55.8264
R1838 a_141162_19260.n4 a_141162_19260.t2 51.5658
R1839 a_141162_19260.n1 a_141162_19260.t6 39.854
R1840 a_141162_19260.n0 a_141162_19260.t1 6.02308
R1841 a_141162_19260.n4 a_141162_19260.n3 3.9695
R1842 a_141162_19260.n0 a_141162_19260.n4 3.3953
R1843 a_141162_19260.n0 a_141162_19260.n1 2.70724
R1844 a_141162_19260.t0 a_141162_19260.n0 2.47208
R1845 a_141162_19260.n3 a_141162_19260.n2 1.3073
R1846 a_143226_19028.n1 a_143226_19028.t5 75.0252
R1847 a_143226_19028.n1 a_143226_19028.t4 44.0697
R1848 a_143226_19028.n2 a_143226_19028.t1 10.6055
R1849 a_143226_19028.n0 a_143226_19028.t2 10.6055
R1850 a_143226_19028.n0 a_143226_19028.n2 8.89791
R1851 a_143226_19028.n0 a_143226_19028.n1 5.7951
R1852 a_143226_19028.t0 a_143226_19028.n0 4.53117
R1853 a_143226_19028.n2 a_143226_19028.t3 4.53024
R1854 a_141982_19260.n0 a_141982_19260.t4 86.4194
R1855 a_141982_19260.n2 a_141982_19260.t3 82.416
R1856 a_141982_19260.n1 a_141982_19260.t2 51.8544
R1857 a_141982_19260.n0 a_141982_19260.t5 51.8072
R1858 a_141982_19260.n3 a_141982_19260.t1 6.28457
R1859 a_141982_19260.n2 a_141982_19260.n1 4.1171
R1860 a_141982_19260.n3 a_141982_19260.n2 2.66253
R1861 a_141982_19260.t0 a_141982_19260.n3 2.21122
R1862 a_141982_19260.n1 a_141982_19260.n0 1.3775
C0 a_74294_19028# a_79862_19260# 0.039104f
C1 CK5 a_89294_19028# 0.00233f
C2 VDDD a_19862_19260# 0.531388f
C3 a_109862_19260# Set 0.027287f
C4 a_n706_19028# a_4862_19260# 0.039104f
C5 VDDD a_n706_19028# 1.96254f
C6 VDDD CK8 1.34464f
C7 a_84210_20288# Set 0.031756f
C8 a_124862_19260# Set 0.027287f
C9 CK3 Valid 4.09e-19
C10 VDDD a_n4162_20288# 0.638355f
C11 clks a_94862_19260# 0.005595f
C12 clks a_418_20288# 0.079048f
C13 VDDD a_17058_20288# 0.638355f
C14 a_107058_20288# Set 0.03149f
C15 clks a_19862_19260# 0.005595f
C16 clks a_n706_19028# 0.989857f
C17 VDDD CK6 1.34464f
C18 clks CK8 0.369497f
C19 a_152058_20288# Set 0.03149f
C20 VDDD a_92058_20288# 0.638355f
C21 D Set 0.136434f
C22 VDDD a_n5790_20288# 0.638355f
C23 a_122058_20288# Set 0.03149f
C24 Valid a_34862_19260# 0.055162f
C25 Set a_69210_20288# 0.031756f
C26 a_74294_19028# a_75418_20288# 0.051153f
C27 a_79862_19260# Set 0.027287f
C28 VDDD a_15418_20288# 0.638355f
C29 a_134294_19028# a_135418_20288# 0.051153f
C30 a_59294_19028# a_64862_19260# 0.039104f
C31 clks a_n4162_20288# 0.03149f
C32 VDDD a_14294_19028# 1.96254f
C33 VDDD a_90418_20288# 0.638355f
C34 Valid a_4862_19260# 0.055162f
C35 VDDD Valid 3.23732f
C36 CK10 a_19862_19260# 0.330594f
C37 VDDD CK4 1.34464f
C38 clks CK6 0.369497f
C39 VDDD a_89294_19028# 1.96254f
C40 VDDD a_114210_20288# 0.638355f
C41 CK8 a_49862_19260# 0.330594f
C42 CK7 a_64862_19260# 0.330594f
C43 a_119294_19028# Set 1.08218f
C44 CK3 a_124862_19260# 0.330594f
C45 clks a_n5790_20288# 0.035956f
C46 Set a_64862_19260# 0.027287f
C47 a_77058_20288# Set 0.03149f
C48 a_137058_20288# Set 0.03149f
C49 clks a_15418_20288# 0.079048f
C50 VDDD a_85838_20288# 0.638355f
C51 a_104294_19028# Valid 0.709946f
C52 clks a_14294_19028# 0.989857f
C53 clks a_90418_20288# 0.079048f
C54 a_29294_19028# Valid 0.709946f
C55 clks Valid 0.09486f
C56 CK4 a_104294_19028# 0.00233f
C57 VDDD a_109862_19260# 0.531388f
C58 clks CK4 0.369497f
C59 VDDD CK2 1.27376f
C60 clks a_89294_19028# 0.989857f
C61 a_59294_19028# a_60418_20288# 0.051153f
C62 clks a_114210_20288# 0.035956f
C63 a_n706_19028# a_418_20288# 0.051153f
C64 Set a_62058_20288# 0.03149f
C65 a_74294_19028# Set 1.08218f
C66 a_134294_19028# Set 1.08218f
C67 VDDD a_84210_20288# 0.638355f
C68 VDDD a_124862_19260# 0.531388f
C69 a_154862_19260# CK1 0.330594f
C70 a_154862_19260# VDDD 0.486609f
C71 a_154862_19260# a_149294_19028# 0.039104f
C72 clks a_85838_20288# 0.03149f
C73 CK10 a_14294_19028# 0.00233f
C74 CK10 Valid 4.09e-19
C75 a_49862_19260# Valid 0.055162f
C76 VDDD a_107058_20288# 0.638355f
C77 a_109862_19260# a_104294_19028# 0.039104f
C78 CK7 a_59294_19028# 0.00233f
C79 a_139862_19260# Valid 0.055162f
C80 CK3 a_119294_19028# 0.00233f
C81 clks a_109862_19260# 0.005595f
C82 clks CK2 0.54869f
C83 Set a_59294_19028# 1.08218f
C84 a_152058_20288# VDDD 0.638355f
C85 VDDD D 1.11963f
C86 VDDD a_122058_20288# 0.638355f
C87 clks a_84210_20288# 0.035956f
C88 clks a_124862_19260# 0.005595f
C89 VDDD a_69210_20288# 0.638355f
C90 VDDD a_79862_19260# 0.531388f
C91 a_129210_20288# Set 0.031756f
C92 VDDD a_105418_20288# 0.638355f
C93 a_94862_19260# Valid 0.055162f
C94 VDDD a_120418_20288# 0.638355f
C95 a_14294_19028# a_19862_19260# 0.039104f
C96 Valid a_19862_19260# 0.055162f
C97 a_89294_19028# a_94862_19260# 0.039104f
C98 VDDD a_119294_19028# 1.96254f
C99 a_n706_19028# Valid 0.709946f
C100 CK2 a_139862_19260# 0.330594f
C101 CK8 Valid 4.09e-19
C102 CK11 a_4862_19260# 0.330594f
C103 VDDD CK11 1.34464f
C104 D clks 0.196553f
C105 Set a_44294_19028# 1.08218f
C106 VDDD a_64862_19260# 0.531388f
C107 VDDD a_77058_20288# 0.638355f
C108 VDDD a_137058_20288# 0.638355f
C109 clks a_69210_20288# 0.035956f
C110 a_105418_20288# a_104294_19028# 0.051153f
C111 a_44294_19028# a_45418_20288# 0.051153f
C112 clks a_79862_19260# 0.005595f
C113 clks a_105418_20288# 0.079048f
C114 VDDD a_115838_20288# 0.638355f
C115 clks a_120418_20288# 0.079048f
C116 VDDD a_75418_20288# 0.638355f
C117 VDDD a_135418_20288# 0.638355f
C118 clks a_119294_19028# 0.989857f
C119 VDDD a_62058_20288# 0.638355f
C120 CK6 Valid 4.09e-19
C121 CK9 a_34862_19260# 0.330594f
C122 clks CK11 0.369497f
C123 VDDD a_74294_19028# 1.96254f
C124 VDDD a_134294_19028# 1.96254f
C125 clks a_64862_19260# 0.005595f
C126 Set a_39210_20288# 0.031756f
C127 a_14294_19028# a_15418_20288# 0.051153f
C128 VDDD CK9 1.34464f
C129 clks a_115838_20288# 0.03149f
C130 VDDD a_60418_20288# 0.638355f
C131 VDDD a_70838_20288# 0.638355f
C132 VDDD a_130838_20288# 0.638355f
C133 Set a_9210_20288# 0.031756f
C134 Valid a_14294_19028# 0.709946f
C135 clks a_75418_20288# 0.079048f
C136 clks a_135418_20288# 0.079048f
C137 VDDD a_59294_19028# 1.96254f
C138 a_89294_19028# a_90418_20288# 0.051153f
C139 CK4 Valid 4.09e-19
C140 a_89294_19028# Valid 0.709946f
C141 clks a_74294_19028# 0.989857f
C142 clks a_134294_19028# 0.989857f
C143 Set a_34862_19260# 0.027287f
C144 VDDD a_129210_20288# 0.638355f
C145 CK9 a_29294_19028# 0.00233f
C146 VDDD CK7 1.34464f
C147 clks CK9 0.369497f
C148 clks a_60418_20288# 0.079048f
C149 Set a_4862_19260# 0.027287f
C150 VDDD Set 14.3834f
C151 a_149294_19028# Set 1.05616f
C152 clks a_70838_20288# 0.03149f
C153 clks a_130838_20288# 0.03149f
C154 a_32058_20288# Set 0.03149f
C155 VDDD a_45418_20288# 0.638355f
C156 clks a_59294_19028# 0.989857f
C157 a_109862_19260# Valid 0.055162f
C158 CK2 Valid 4.09e-19
C159 VDDD a_44294_19028# 1.96254f
C160 CK4 a_109862_19260# 0.330594f
C161 a_139862_19260# a_134294_19028# 0.039104f
C162 clks a_129210_20288# 0.035956f
C163 a_124862_19260# Valid 0.055162f
C164 CK11 a_n706_19028# 0.00233f
C165 clks CK7 0.369497f
C166 VDDD CK5 1.34464f
C167 Set a_2058_20288# 0.03149f
C168 a_104294_19028# Set 1.08218f
C169 a_29294_19028# Set 1.08218f
C170 clks Set 0.10454f
C171 CK6 a_79862_19260# 0.330594f
C172 VDDD a_40838_20288# 0.638355f
C173 a_54210_20288# Set 0.031756f
C174 clks a_45418_20288# 0.079048f
C175 a_144210_20288# Set 0.031756f
C176 clks a_44294_19028# 0.989857f
C177 VDDD a_10838_20288# 0.638355f
C178 D Valid 0.244411f
C179 VDDD a_39210_20288# 0.638355f
C180 a_79862_19260# Valid 0.055162f
C181 VDDD CK3 1.34464f
C182 clks CK5 0.369497f
C183 a_49862_19260# Set 0.027287f
C184 clks a_40838_20288# 0.03149f
C185 VDDD a_9210_20288# 0.638355f
C186 a_99210_20288# Set 0.031756f
C187 a_139862_19260# Set 0.027287f
C188 a_24210_20288# Set 0.031756f
C189 clks a_10838_20288# 0.03149f
C190 a_119294_19028# Valid 0.709946f
C191 a_49862_19260# a_44294_19028# 0.039104f
C192 VDDD a_34862_19260# 0.531388f
C193 CK11 Valid 4.09e-19
C194 Valid a_64862_19260# 0.055162f
C195 clks a_39210_20288# 0.035956f
C196 VDDD a_150418_20288# 0.638355f
C197 a_149294_19028# a_150418_20288# 0.051153f
C198 clks CK3 0.369497f
C199 VDDD CK1 0.375365f
C200 CK6 a_74294_19028# 0.00233f
C201 CK1 a_149294_19028# 0.00233f
C202 a_47058_20288# Set 0.03149f
C203 VDDD a_4862_19260# 0.531388f
C204 a_94862_19260# Set 0.027287f
C205 VDDD a_149294_19028# 1.96135f
C206 VDDD a_32058_20288# 0.638355f
C207 clks a_9210_20288# 0.035956f
C208 Set a_19862_19260# 0.027287f
C209 Set a_n706_19028# 1.08218f
C210 a_29294_19028# a_34862_19260# 0.039104f
C211 VDDD a_55838_20288# 0.638355f
C212 clks a_34862_19260# 0.005595f
C213 a_74294_19028# Valid 0.709946f
C214 a_134294_19028# Valid 0.709946f
C215 VDDD a_145838_20288# 0.638355f
C216 VDDD a_30418_20288# 0.638355f
C217 clks a_150418_20288# 0.061452f
C218 CK5 a_94862_19260# 0.330594f
C219 CK8 a_44294_19028# 0.00233f
C220 VDDD a_2058_20288# 0.638355f
C221 VDDD a_104294_19028# 1.96254f
C222 VDDD a_29294_19028# 1.96254f
C223 clks a_4862_19260# 0.005595f
C224 CK9 Valid 4.09e-19
C225 VDDD clks 0.106038p
C226 a_119294_19028# a_124862_19260# 0.039104f
C227 clks a_149294_19028# 0.983726f
C228 VDDD a_54210_20288# 0.638355f
C229 Set a_17058_20288# 0.03149f
C230 VDDD a_144210_20288# 0.638355f
C231 Valid a_59294_19028# 0.709946f
C232 a_92058_20288# Set 0.03149f
C233 VDDD a_100838_20288# 0.638355f
C234 clks a_55838_20288# 0.03149f
C235 Set a_n5790_20288# 0.031756f
C236 VDDD a_25838_20288# 0.638355f
C237 clks a_145838_20288# 0.03149f
C238 a_29294_19028# a_30418_20288# 0.051153f
C239 clks a_30418_20288# 0.079048f
C240 CK2 a_134294_19028# 0.00233f
C241 clks a_104294_19028# 0.989857f
C242 clks a_29294_19028# 0.989857f
C243 CK7 Valid 4.09e-19
C244 VDDD CK10 1.34464f
C245 VDDD a_49862_19260# 0.531388f
C246 Set a_14294_19028# 1.08218f
C247 Set Valid 29.0961f
C248 clks a_54210_20288# 0.035956f
C249 VDDD a_139862_19260# 0.531388f
C250 VDDD a_99210_20288# 0.638355f
C251 VDDD a_24210_20288# 0.638355f
C252 clks a_144210_20288# 0.035956f
C253 a_89294_19028# Set 1.08218f
C254 a_114210_20288# Set 0.031756f
C255 clks a_100838_20288# 0.03149f
C256 a_119294_19028# a_120418_20288# 0.051153f
C257 clks a_25838_20288# 0.03149f
C258 Valid a_44294_19028# 0.709946f
C259 VDDD a_47058_20288# 0.638355f
C260 CK5 Valid 4.09e-19
C261 clks CK10 0.369497f
C262 VDDD a_94862_19260# 0.531388f
C263 clks a_49862_19260# 0.005595f
C264 VDDD a_418_20288# 0.638355f
C265 clks a_99210_20288# 0.035956f
C266 clks a_139862_19260# 0.005595f
C267 clks a_24210_20288# 0.035956f
C268 CK1 VSSD 1.15486f
C269 CK2 VSSD 0.490759f
C270 CK3 VSSD 0.568892f
C271 CK4 VSSD 0.568892f
C272 CK5 VSSD 0.568892f
C273 CK6 VSSD 0.568892f
C274 CK7 VSSD 0.568892f
C275 CK8 VSSD 0.568892f
C276 CK9 VSSD 0.568892f
C277 CK10 VSSD 0.568892f
C278 CK11 VSSD 0.568892f
C279 clks VSSD 37.08308f
C280 D VSSD 0.918219f
C281 VDDD VSSD 0.959375p
C282 a_154862_19260# VSSD 0.734132f
C283 a_152058_20288# VSSD 4.87e-25
C284 a_150418_20288# VSSD 4.87e-25
C285 a_149294_19028# VSSD 5.37273f
C286 a_145838_20288# VSSD 4.87e-25
C287 a_144210_20288# VSSD 4.87e-25
C288 a_139862_19260# VSSD 0.607665f
C289 a_137058_20288# VSSD 4.87e-25
C290 a_135418_20288# VSSD 4.87e-25
C291 a_134294_19028# VSSD 4.74222f
C292 a_130838_20288# VSSD 4.87e-25
C293 a_129210_20288# VSSD 4.87e-25
C294 a_124862_19260# VSSD 0.607665f
C295 a_122058_20288# VSSD 4.87e-25
C296 a_120418_20288# VSSD 4.87e-25
C297 a_119294_19028# VSSD 4.74222f
C298 a_115838_20288# VSSD 4.87e-25
C299 a_114210_20288# VSSD 4.87e-25
C300 a_109862_19260# VSSD 0.607665f
C301 a_107058_20288# VSSD 4.87e-25
C302 a_105418_20288# VSSD 4.87e-25
C303 a_104294_19028# VSSD 4.74222f
C304 a_100838_20288# VSSD 4.87e-25
C305 a_99210_20288# VSSD 4.87e-25
C306 a_94862_19260# VSSD 0.607665f
C307 a_92058_20288# VSSD 4.87e-25
C308 a_90418_20288# VSSD 4.87e-25
C309 a_89294_19028# VSSD 4.74222f
C310 a_85838_20288# VSSD 4.87e-25
C311 a_84210_20288# VSSD 4.87e-25
C312 a_79862_19260# VSSD 0.607665f
C313 a_77058_20288# VSSD 4.87e-25
C314 a_75418_20288# VSSD 4.87e-25
C315 a_74294_19028# VSSD 4.74222f
C316 a_70838_20288# VSSD 4.87e-25
C317 a_69210_20288# VSSD 4.87e-25
C318 a_64862_19260# VSSD 0.607665f
C319 a_62058_20288# VSSD 4.87e-25
C320 a_60418_20288# VSSD 4.87e-25
C321 a_59294_19028# VSSD 4.74222f
C322 a_55838_20288# VSSD 4.87e-25
C323 a_54210_20288# VSSD 4.87e-25
C324 a_49862_19260# VSSD 0.607665f
C325 a_47058_20288# VSSD 4.87e-25
C326 a_45418_20288# VSSD 4.87e-25
C327 a_44294_19028# VSSD 4.74222f
C328 a_40838_20288# VSSD 4.87e-25
C329 a_39210_20288# VSSD 4.87e-25
C330 a_34862_19260# VSSD 0.607665f
C331 a_32058_20288# VSSD 4.87e-25
C332 a_30418_20288# VSSD 4.87e-25
C333 a_29294_19028# VSSD 4.74222f
C334 a_25838_20288# VSSD 4.87e-25
C335 a_24210_20288# VSSD 4.87e-25
C336 a_19862_19260# VSSD 0.607665f
C337 a_17058_20288# VSSD 4.87e-25
C338 a_15418_20288# VSSD 4.87e-25
C339 a_14294_19028# VSSD 4.74222f
C340 a_10838_20288# VSSD 4.87e-25
C341 a_9210_20288# VSSD 4.87e-25
C342 a_4862_19260# VSSD 0.607665f
C343 a_2058_20288# VSSD 4.87e-25
C344 a_418_20288# VSSD 4.87e-25
C345 a_n706_19028# VSSD 4.74222f
C346 a_n4162_20288# VSSD 4.87e-25
C347 a_n5790_20288# VSSD 4.87e-25
C348 Set VSSD 0.134061p
C349 Valid VSSD 60.165f
C350 a_141982_19260.t1 VSSD 0.198092f
C351 a_141982_19260.t3 VSSD 0.1503f
C352 a_141982_19260.t5 VSSD 0.111361f
C353 a_141982_19260.t4 VSSD 0.210813f
C354 a_141982_19260.n0 VSSD 2.80378f
C355 a_141982_19260.t2 VSSD 0.113403f
C356 a_141982_19260.n1 VSSD 1.56811f
C357 a_141982_19260.n2 VSSD 1.46985f
C358 a_141982_19260.n3 VSSD 1.46632f
C359 a_141982_19260.t0 VSSD 0.407979f
C360 a_143226_19028.n0 VSSD 1.62012f
C361 a_143226_19028.t5 VSSD 0.058764f
C362 a_143226_19028.t4 VSSD 0.026943f
C363 a_143226_19028.n1 VSSD 0.285443f
C364 a_143226_19028.t3 VSSD 0.473406f
C365 a_143226_19028.t1 VSSD 0.14055f
C366 a_143226_19028.n2 VSSD 1.44263f
C367 a_143226_19028.t2 VSSD 0.14055f
C368 a_143226_19028.t0 VSSD 0.411594f
C369 a_141162_19260.n0 VSSD 1.29327f
C370 a_141162_19260.t6 VSSD 0.038174f
C371 a_141162_19260.t3 VSSD 0.090059f
C372 a_141162_19260.n1 VSSD 0.298372f
C373 a_141162_19260.t1 VSSD 0.147143f
C374 a_141162_19260.t5 VSSD 0.1636f
C375 a_141162_19260.t7 VSSD 0.130517f
C376 a_141162_19260.n2 VSSD 2.29806f
C377 a_141162_19260.t4 VSSD 0.128166f
C378 a_141162_19260.n3 VSSD 1.28395f
C379 a_141162_19260.t2 VSSD 0.088697f
C380 a_141162_19260.n4 VSSD 1.24258f
C381 a_141162_19260.t0 VSSD 0.397411f
C382 a_24210_19028.n0 VSSD 1.4589f
C383 a_24210_19028.t2 VSSD 0.075381f
C384 a_24210_19028.t4 VSSD 0.075169f
C385 a_24210_19028.n1 VSSD 0.480219f
C386 a_24210_19028.t6 VSSD 0.095963f
C387 a_24210_19028.t5 VSSD 0.044581f
C388 a_24210_19028.t3 VSSD 0.658502f
C389 a_24210_19028.t0 VSSD 0.246654f
C390 a_24210_19028.n2 VSSD 2.44953f
C391 a_24210_19028.n3 VSSD 0.872922f
C392 a_24210_19028.t1 VSSD 0.84218f
C393 a_115838_19028.t2 VSSD 0.143652f
C394 a_115838_19028.t4 VSSD 0.043902f
C395 a_115838_19028.t0 VSSD 0.043779f
C396 a_115838_19028.n0 VSSD 0.279682f
C397 a_115838_19028.t3 VSSD 0.49049f
C398 a_115838_19028.n1 VSSD 0.54216f
C399 a_115838_19028.n2 VSSD 1.07527f
C400 a_115838_19028.t1 VSSD 0.381063f
C401 a_n5790_19028.n0 VSSD 1.4589f
C402 a_n5790_19028.t4 VSSD 0.246654f
C403 a_n5790_19028.t6 VSSD 0.095963f
C404 a_n5790_19028.t5 VSSD 0.044581f
C405 a_n5790_19028.t3 VSSD 0.075381f
C406 a_n5790_19028.t0 VSSD 0.075169f
C407 a_n5790_19028.n1 VSSD 0.480219f
C408 a_n5790_19028.t2 VSSD 0.84218f
C409 a_n5790_19028.n2 VSSD 0.872922f
C410 a_n5790_19028.n3 VSSD 2.44962f
C411 a_n5790_19028.t1 VSSD 0.658416f
C412 a_81982_19260.t1 VSSD 0.198092f
C413 a_81982_19260.t3 VSSD 0.1503f
C414 a_81982_19260.t5 VSSD 0.111361f
C415 a_81982_19260.t4 VSSD 0.210813f
C416 a_81982_19260.n0 VSSD 2.80378f
C417 a_81982_19260.t2 VSSD 0.113403f
C418 a_81982_19260.n1 VSSD 1.56811f
C419 a_81982_19260.n2 VSSD 1.46985f
C420 a_81982_19260.n3 VSSD 1.46632f
C421 a_81982_19260.t0 VSSD 0.407979f
C422 a_83226_19028.n0 VSSD 1.62012f
C423 a_83226_19028.t5 VSSD 0.058764f
C424 a_83226_19028.t4 VSSD 0.026943f
C425 a_83226_19028.n1 VSSD 0.285443f
C426 a_83226_19028.t2 VSSD 0.473406f
C427 a_83226_19028.t0 VSSD 0.14055f
C428 a_83226_19028.n2 VSSD 1.44263f
C429 a_83226_19028.t3 VSSD 0.14055f
C430 a_83226_19028.t1 VSSD 0.411594f
C431 a_81162_19260.n0 VSSD 1.29327f
C432 a_81162_19260.t6 VSSD 0.038174f
C433 a_81162_19260.t3 VSSD 0.090059f
C434 a_81162_19260.n1 VSSD 0.298372f
C435 a_81162_19260.t1 VSSD 0.147143f
C436 a_81162_19260.t5 VSSD 0.1636f
C437 a_81162_19260.t7 VSSD 0.130517f
C438 a_81162_19260.n2 VSSD 2.29806f
C439 a_81162_19260.t4 VSSD 0.128166f
C440 a_81162_19260.n3 VSSD 1.28395f
C441 a_81162_19260.t2 VSSD 0.088697f
C442 a_81162_19260.n4 VSSD 1.24258f
C443 a_81162_19260.t0 VSSD 0.397411f
C444 a_55838_19028.t2 VSSD 0.143652f
C445 a_55838_19028.t4 VSSD 0.043902f
C446 a_55838_19028.t0 VSSD 0.043779f
C447 a_55838_19028.n0 VSSD 0.279682f
C448 a_55838_19028.t3 VSSD 0.49049f
C449 a_55838_19028.n1 VSSD 0.54216f
C450 a_55838_19028.n2 VSSD 1.07527f
C451 a_55838_19028.t1 VSSD 0.381063f
C452 a_100838_19028.t3 VSSD 0.043902f
C453 a_100838_19028.t0 VSSD 0.043779f
C454 a_100838_19028.n0 VSSD 0.279682f
C455 a_100838_19028.t4 VSSD 0.381113f
C456 a_100838_19028.t1 VSSD 0.143652f
C457 a_100838_19028.n1 VSSD 1.07522f
C458 a_100838_19028.n2 VSSD 0.54216f
C459 a_100838_19028.t2 VSSD 0.49049f
C460 a_68226_19028.n0 VSSD 1.62012f
C461 a_68226_19028.t5 VSSD 0.058764f
C462 a_68226_19028.t4 VSSD 0.026943f
C463 a_68226_19028.n1 VSSD 0.285443f
C464 a_68226_19028.t2 VSSD 0.473406f
C465 a_68226_19028.t0 VSSD 0.14055f
C466 a_68226_19028.n2 VSSD 1.44263f
C467 a_68226_19028.t3 VSSD 0.14055f
C468 a_68226_19028.t1 VSSD 0.411594f
C469 a_152058_19028.t2 VSSD 0.143873f
C470 a_152058_19028.t4 VSSD 0.04397f
C471 a_152058_19028.t1 VSSD 0.043846f
C472 a_152058_19028.n0 VSSD 0.280111f
C473 a_152058_19028.t3 VSSD 0.491242f
C474 a_152058_19028.n1 VSSD 0.534715f
C475 a_152058_19028.n2 VSSD 1.07819f
C476 a_152058_19028.t0 VSSD 0.384053f
C477 a_113226_19028.n0 VSSD 1.62008f
C478 a_113226_19028.t5 VSSD 0.058764f
C479 a_113226_19028.t4 VSSD 0.026943f
C480 a_113226_19028.n1 VSSD 0.285443f
C481 a_113226_19028.t2 VSSD 0.411632f
C482 a_113226_19028.t0 VSSD 0.14055f
C483 a_113226_19028.t3 VSSD 0.14055f
C484 a_113226_19028.n2 VSSD 1.44268f
C485 a_113226_19028.t1 VSSD 0.473359f
C486 a_85838_19028.t1 VSSD 0.043902f
C487 a_85838_19028.t3 VSSD 0.043779f
C488 a_85838_19028.n0 VSSD 0.279682f
C489 a_85838_19028.t4 VSSD 0.381113f
C490 a_85838_19028.t2 VSSD 0.143652f
C491 a_85838_19028.n1 VSSD 1.07522f
C492 a_85838_19028.n2 VSSD 0.54216f
C493 a_85838_19028.t0 VSSD 0.49049f
C494 a_38226_19028.n0 VSSD 1.62012f
C495 a_38226_19028.t5 VSSD 0.058764f
C496 a_38226_19028.t4 VSSD 0.026943f
C497 a_38226_19028.n1 VSSD 0.285443f
C498 a_38226_19028.t2 VSSD 0.473406f
C499 a_38226_19028.t0 VSSD 0.14055f
C500 a_38226_19028.n2 VSSD 1.44263f
C501 a_38226_19028.t3 VSSD 0.14055f
C502 a_38226_19028.t1 VSSD 0.411594f
C503 a_40838_19028.t1 VSSD 0.143652f
C504 a_40838_19028.t4 VSSD 0.043902f
C505 a_40838_19028.t0 VSSD 0.043779f
C506 a_40838_19028.n0 VSSD 0.279682f
C507 a_40838_19028.t3 VSSD 0.49049f
C508 a_40838_19028.n1 VSSD 0.54216f
C509 a_40838_19028.n2 VSSD 1.07527f
C510 a_40838_19028.t2 VSSD 0.381063f
C511 a_130838_19028.t3 VSSD 0.043902f
C512 a_130838_19028.t0 VSSD 0.043779f
C513 a_130838_19028.n0 VSSD 0.279682f
C514 a_130838_19028.t4 VSSD 0.381113f
C515 a_130838_19028.t1 VSSD 0.143652f
C516 a_130838_19028.n1 VSSD 1.07522f
C517 a_130838_19028.n2 VSSD 0.54216f
C518 a_130838_19028.t2 VSSD 0.49049f
C519 a_92058_19028.t1 VSSD 0.04397f
C520 a_92058_19028.t2 VSSD 0.043846f
C521 a_92058_19028.n0 VSSD 0.280111f
C522 a_92058_19028.t3 VSSD 0.384103f
C523 a_92058_19028.t4 VSSD 0.143873f
C524 a_92058_19028.n1 VSSD 1.07814f
C525 a_92058_19028.n2 VSSD 0.534715f
C526 a_92058_19028.t0 VSSD 0.491242f
C527 a_53226_19028.n0 VSSD 1.62008f
C528 a_53226_19028.t5 VSSD 0.058764f
C529 a_53226_19028.t4 VSSD 0.026943f
C530 a_53226_19028.n1 VSSD 0.285443f
C531 a_53226_19028.t3 VSSD 0.411632f
C532 a_53226_19028.t0 VSSD 0.14055f
C533 a_53226_19028.t2 VSSD 0.14055f
C534 a_53226_19028.n2 VSSD 1.44268f
C535 a_53226_19028.t1 VSSD 0.473359f
C536 a_150418_19028.n0 VSSD 1.8454f
C537 a_150418_19028.t1 VSSD 0.075286f
C538 a_150418_19028.t2 VSSD 0.075074f
C539 a_150418_19028.n1 VSSD 0.479615f
C540 a_150418_19028.t4 VSSD 0.038878f
C541 a_150418_19028.t3 VSSD 0.091721f
C542 a_150418_19028.n2 VSSD 1.39252f
C543 a_150418_19028.t6 VSSD 0.095842f
C544 a_150418_19028.t5 VSSD 0.044524f
C545 a_150418_19028.n3 VSSD 0.320012f
C546 a_150418_19028.t0 VSSD 0.841119f
C547 a_96162_19260.n0 VSSD 1.29327f
C548 a_96162_19260.t6 VSSD 0.038174f
C549 a_96162_19260.t5 VSSD 0.090059f
C550 a_96162_19260.n1 VSSD 0.298372f
C551 a_96162_19260.t1 VSSD 0.147143f
C552 a_96162_19260.t4 VSSD 0.1636f
C553 a_96162_19260.t2 VSSD 0.130517f
C554 a_96162_19260.n2 VSSD 2.29806f
C555 a_96162_19260.t7 VSSD 0.128166f
C556 a_96162_19260.n3 VSSD 1.28395f
C557 a_96162_19260.t3 VSSD 0.088697f
C558 a_96162_19260.n4 VSSD 1.24258f
C559 a_96162_19260.t0 VSSD 0.397411f
C560 a_107058_19028.t2 VSSD 0.143873f
C561 a_107058_19028.t4 VSSD 0.04397f
C562 a_107058_19028.t0 VSSD 0.043846f
C563 a_107058_19028.n0 VSSD 0.280111f
C564 a_107058_19028.t3 VSSD 0.491242f
C565 a_107058_19028.n1 VSSD 0.534715f
C566 a_107058_19028.n2 VSSD 1.07819f
C567 a_107058_19028.t1 VSSD 0.384053f
C568 a_21982_19260.t1 VSSD 0.198092f
C569 a_21982_19260.t3 VSSD 0.1503f
C570 a_21982_19260.t5 VSSD 0.111361f
C571 a_21982_19260.t4 VSSD 0.210813f
C572 a_21982_19260.n0 VSSD 2.80378f
C573 a_21982_19260.t2 VSSD 0.113403f
C574 a_21982_19260.n1 VSSD 1.56811f
C575 a_21982_19260.n2 VSSD 1.46985f
C576 a_21982_19260.n3 VSSD 1.46632f
C577 a_21982_19260.t0 VSSD 0.407979f
C578 a_70838_19028.t0 VSSD 0.143652f
C579 a_70838_19028.t3 VSSD 0.043902f
C580 a_70838_19028.t2 VSSD 0.043779f
C581 a_70838_19028.n0 VSSD 0.279682f
C582 a_70838_19028.t4 VSSD 0.49049f
C583 a_70838_19028.n1 VSSD 0.54216f
C584 a_70838_19028.n2 VSSD 1.07527f
C585 a_70838_19028.t1 VSSD 0.381063f
C586 a_23226_19028.n0 VSSD 1.62008f
C587 a_23226_19028.t5 VSSD 0.058764f
C588 a_23226_19028.t4 VSSD 0.026943f
C589 a_23226_19028.n1 VSSD 0.285443f
C590 a_23226_19028.t3 VSSD 0.411632f
C591 a_23226_19028.t1 VSSD 0.14055f
C592 a_23226_19028.t2 VSSD 0.14055f
C593 a_23226_19028.n2 VSSD 1.44268f
C594 a_23226_19028.t0 VSSD 0.473359f
C595 a_21162_19260.n0 VSSD 1.29327f
C596 a_21162_19260.t5 VSSD 0.038174f
C597 a_21162_19260.t3 VSSD 0.090059f
C598 a_21162_19260.n1 VSSD 0.298372f
C599 a_21162_19260.t1 VSSD 0.147143f
C600 a_21162_19260.t6 VSSD 0.1636f
C601 a_21162_19260.t7 VSSD 0.130517f
C602 a_21162_19260.n2 VSSD 2.29806f
C603 a_21162_19260.t4 VSSD 0.128166f
C604 a_21162_19260.n3 VSSD 1.28395f
C605 a_21162_19260.t2 VSSD 0.088697f
C606 a_21162_19260.n4 VSSD 1.24258f
C607 a_21162_19260.t0 VSSD 0.397411f
C608 a_9210_19028.n0 VSSD 1.4589f
C609 a_9210_19028.t0 VSSD 0.246654f
C610 a_9210_19028.t6 VSSD 0.095963f
C611 a_9210_19028.t5 VSSD 0.044581f
C612 a_9210_19028.t3 VSSD 0.075381f
C613 a_9210_19028.t4 VSSD 0.075169f
C614 a_9210_19028.n1 VSSD 0.480219f
C615 a_9210_19028.t2 VSSD 0.84218f
C616 a_9210_19028.n2 VSSD 0.872922f
C617 a_9210_19028.n3 VSSD 2.44962f
C618 a_9210_19028.t1 VSSD 0.658416f
C619 a_69210_19028.n0 VSSD 1.4589f
C620 a_69210_19028.t0 VSSD 0.246654f
C621 a_69210_19028.t6 VSSD 0.095963f
C622 a_69210_19028.t5 VSSD 0.044581f
C623 a_69210_19028.t4 VSSD 0.075381f
C624 a_69210_19028.t2 VSSD 0.075169f
C625 a_69210_19028.n1 VSSD 0.480219f
C626 a_69210_19028.t3 VSSD 0.84218f
C627 a_69210_19028.n2 VSSD 0.872922f
C628 a_69210_19028.n3 VSSD 2.44962f
C629 a_69210_19028.t1 VSSD 0.658416f
C630 a_90418_19028.n0 VSSD 1.14117f
C631 a_90418_19028.t3 VSSD 0.178154f
C632 a_90418_19028.t2 VSSD 0.054447f
C633 a_90418_19028.t4 VSSD 0.054293f
C634 a_90418_19028.n1 VSSD 0.346855f
C635 a_90418_19028.t1 VSSD 0.608293f
C636 a_90418_19028.t8 VSSD 0.069313f
C637 a_90418_19028.t7 VSSD 0.0322f
C638 a_90418_19028.n2 VSSD 0.231431f
C639 a_90418_19028.t6 VSSD 0.028117f
C640 a_90418_19028.t5 VSSD 0.066332f
C641 a_90418_19028.n3 VSSD 0.216551f
C642 a_90418_19028.n4 VSSD 1.18895f
C643 a_90418_19028.n5 VSSD 1.60832f
C644 a_90418_19028.t0 VSSD 0.475563f
C645 a_96982_19260.t1 VSSD 0.198092f
C646 a_96982_19260.t3 VSSD 0.1503f
C647 a_96982_19260.t2 VSSD 0.111361f
C648 a_96982_19260.t4 VSSD 0.210813f
C649 a_96982_19260.n0 VSSD 2.80378f
C650 a_96982_19260.t5 VSSD 0.113403f
C651 a_96982_19260.n1 VSSD 1.56811f
C652 a_96982_19260.n2 VSSD 1.46985f
C653 a_96982_19260.n3 VSSD 1.46632f
C654 a_96982_19260.t0 VSSD 0.407979f
C655 a_114210_19028.n0 VSSD 1.4589f
C656 a_114210_19028.t1 VSSD 0.246654f
C657 a_114210_19028.t6 VSSD 0.095963f
C658 a_114210_19028.t5 VSSD 0.044581f
C659 a_114210_19028.t3 VSSD 0.075381f
C660 a_114210_19028.t2 VSSD 0.075169f
C661 a_114210_19028.n1 VSSD 0.480219f
C662 a_114210_19028.t4 VSSD 0.84218f
C663 a_114210_19028.n2 VSSD 0.872922f
C664 a_114210_19028.n3 VSSD 2.44962f
C665 a_114210_19028.t0 VSSD 0.658416f
C666 a_137058_19028.t2 VSSD 0.143873f
C667 a_137058_19028.t4 VSSD 0.04397f
C668 a_137058_19028.t0 VSSD 0.043846f
C669 a_137058_19028.n0 VSSD 0.280111f
C670 a_137058_19028.t3 VSSD 0.491242f
C671 a_137058_19028.n1 VSSD 0.534715f
C672 a_137058_19028.n2 VSSD 1.07819f
C673 a_137058_19028.t1 VSSD 0.384053f
C674 a_36162_19260.n0 VSSD 1.29327f
C675 a_36162_19260.t5 VSSD 0.038174f
C676 a_36162_19260.t4 VSSD 0.090059f
C677 a_36162_19260.n1 VSSD 0.298372f
C678 a_36162_19260.t1 VSSD 0.147143f
C679 a_36162_19260.t6 VSSD 0.1636f
C680 a_36162_19260.t2 VSSD 0.130517f
C681 a_36162_19260.n2 VSSD 2.29806f
C682 a_36162_19260.t7 VSSD 0.128166f
C683 a_36162_19260.n3 VSSD 1.28395f
C684 a_36162_19260.t3 VSSD 0.088697f
C685 a_36162_19260.n4 VSSD 1.24258f
C686 a_36162_19260.t0 VSSD 0.397411f
C687 a_135418_19028.n0 VSSD 1.14117f
C688 a_135418_19028.t3 VSSD 0.178154f
C689 a_135418_19028.t1 VSSD 0.054447f
C690 a_135418_19028.t4 VSSD 0.054293f
C691 a_135418_19028.n1 VSSD 0.346855f
C692 a_135418_19028.t2 VSSD 0.608293f
C693 a_135418_19028.t6 VSSD 0.069313f
C694 a_135418_19028.t5 VSSD 0.0322f
C695 a_135418_19028.n2 VSSD 0.231431f
C696 a_135418_19028.t8 VSSD 0.028117f
C697 a_135418_19028.t7 VSSD 0.066332f
C698 a_135418_19028.n3 VSSD 0.216551f
C699 a_135418_19028.n4 VSSD 1.18895f
C700 a_135418_19028.n5 VSSD 1.60832f
C701 a_135418_19028.t0 VSSD 0.475563f
C702 a_47058_19028.t4 VSSD 0.143873f
C703 a_47058_19028.t2 VSSD 0.04397f
C704 a_47058_19028.t1 VSSD 0.043846f
C705 a_47058_19028.n0 VSSD 0.280111f
C706 a_47058_19028.t3 VSSD 0.491242f
C707 a_47058_19028.n1 VSSD 0.534715f
C708 a_47058_19028.n2 VSSD 1.07819f
C709 a_47058_19028.t0 VSSD 0.384053f
C710 a_8226_19028.n0 VSSD 1.62012f
C711 a_8226_19028.t5 VSSD 0.058764f
C712 a_8226_19028.t4 VSSD 0.026943f
C713 a_8226_19028.n1 VSSD 0.285443f
C714 a_8226_19028.t2 VSSD 0.473406f
C715 a_8226_19028.t0 VSSD 0.14055f
C716 a_8226_19028.n2 VSSD 1.44263f
C717 a_8226_19028.t3 VSSD 0.14055f
C718 a_8226_19028.t1 VSSD 0.411594f
C719 a_105418_19028.n0 VSSD 1.14117f
C720 a_105418_19028.t0 VSSD 0.178154f
C721 a_105418_19028.t3 VSSD 0.054447f
C722 a_105418_19028.t4 VSSD 0.054293f
C723 a_105418_19028.n1 VSSD 0.346855f
C724 a_105418_19028.t2 VSSD 0.608293f
C725 a_105418_19028.t8 VSSD 0.069313f
C726 a_105418_19028.t7 VSSD 0.0322f
C727 a_105418_19028.n2 VSSD 0.231431f
C728 a_105418_19028.t6 VSSD 0.028117f
C729 a_105418_19028.t5 VSSD 0.066332f
C730 a_105418_19028.n3 VSSD 0.216551f
C731 a_105418_19028.n4 VSSD 1.18895f
C732 a_105418_19028.n5 VSSD 1.60832f
C733 a_105418_19028.t1 VSSD 0.475563f
C734 a_17058_19028.t1 VSSD 0.143873f
C735 a_17058_19028.t3 VSSD 0.04397f
C736 a_17058_19028.t4 VSSD 0.043846f
C737 a_17058_19028.n0 VSSD 0.280111f
C738 a_17058_19028.t2 VSSD 0.491242f
C739 a_17058_19028.n1 VSSD 0.534715f
C740 a_17058_19028.n2 VSSD 1.07819f
C741 a_17058_19028.t0 VSSD 0.384053f
C742 a_15418_19028.n0 VSSD 1.14117f
C743 a_15418_19028.t0 VSSD 0.054447f
C744 a_15418_19028.t3 VSSD 0.054293f
C745 a_15418_19028.n1 VSSD 0.346855f
C746 a_15418_19028.t8 VSSD 0.028117f
C747 a_15418_19028.t7 VSSD 0.066332f
C748 a_15418_19028.n2 VSSD 0.216551f
C749 a_15418_19028.t2 VSSD 0.475625f
C750 a_15418_19028.t4 VSSD 0.178154f
C751 a_15418_19028.n3 VSSD 1.60826f
C752 a_15418_19028.n4 VSSD 1.18895f
C753 a_15418_19028.t6 VSSD 0.069313f
C754 a_15418_19028.t5 VSSD 0.0322f
C755 a_15418_19028.n5 VSSD 0.231431f
C756 a_15418_19028.t1 VSSD 0.608293f
C757 a_30418_19028.n0 VSSD 1.14117f
C758 a_30418_19028.t0 VSSD 0.054447f
C759 a_30418_19028.t4 VSSD 0.054293f
C760 a_30418_19028.n1 VSSD 0.346855f
C761 a_30418_19028.t5 VSSD 0.028117f
C762 a_30418_19028.t8 VSSD 0.066332f
C763 a_30418_19028.n2 VSSD 0.216551f
C764 a_30418_19028.t2 VSSD 0.475625f
C765 a_30418_19028.t3 VSSD 0.178154f
C766 a_30418_19028.n3 VSSD 1.60826f
C767 a_30418_19028.n4 VSSD 1.18895f
C768 a_30418_19028.t7 VSSD 0.069313f
C769 a_30418_19028.t6 VSSD 0.0322f
C770 a_30418_19028.n5 VSSD 0.231431f
C771 a_30418_19028.t1 VSSD 0.608293f
C772 a_6982_19260.t1 VSSD 0.198092f
C773 a_6982_19260.t5 VSSD 0.1503f
C774 a_6982_19260.t3 VSSD 0.111361f
C775 a_6982_19260.t4 VSSD 0.210813f
C776 a_6982_19260.n0 VSSD 2.80378f
C777 a_6982_19260.t2 VSSD 0.113403f
C778 a_6982_19260.n1 VSSD 1.56811f
C779 a_6982_19260.n2 VSSD 1.46985f
C780 a_6982_19260.n3 VSSD 1.46632f
C781 a_6982_19260.t0 VSSD 0.407979f
C782 a_6162_19260.n0 VSSD 1.29327f
C783 a_6162_19260.t2 VSSD 0.038174f
C784 a_6162_19260.t7 VSSD 0.090059f
C785 a_6162_19260.n1 VSSD 0.298372f
C786 a_6162_19260.t1 VSSD 0.147143f
C787 a_6162_19260.t5 VSSD 0.1636f
C788 a_6162_19260.t4 VSSD 0.130517f
C789 a_6162_19260.n2 VSSD 2.29806f
C790 a_6162_19260.t3 VSSD 0.128166f
C791 a_6162_19260.n3 VSSD 1.28395f
C792 a_6162_19260.t6 VSSD 0.088697f
C793 a_6162_19260.n4 VSSD 1.24258f
C794 a_6162_19260.t0 VSSD 0.397411f
C795 a_66982_19260.t1 VSSD 0.198092f
C796 a_66982_19260.t5 VSSD 0.1503f
C797 a_66982_19260.t4 VSSD 0.111361f
C798 a_66982_19260.t2 VSSD 0.210813f
C799 a_66982_19260.n0 VSSD 2.80378f
C800 a_66982_19260.t3 VSSD 0.113403f
C801 a_66982_19260.n1 VSSD 1.56811f
C802 a_66982_19260.n2 VSSD 1.46985f
C803 a_66982_19260.n3 VSSD 1.46632f
C804 a_66982_19260.t0 VSSD 0.407979f
C805 a_77058_19028.t2 VSSD 0.04397f
C806 a_77058_19028.t4 VSSD 0.043846f
C807 a_77058_19028.n0 VSSD 0.280111f
C808 a_77058_19028.t3 VSSD 0.384103f
C809 a_77058_19028.t0 VSSD 0.143873f
C810 a_77058_19028.n1 VSSD 1.07814f
C811 a_77058_19028.n2 VSSD 0.534715f
C812 a_77058_19028.t1 VSSD 0.491242f
C813 a_66162_19260.n0 VSSD 1.29327f
C814 a_66162_19260.t3 VSSD 0.038174f
C815 a_66162_19260.t7 VSSD 0.090059f
C816 a_66162_19260.n1 VSSD 0.298372f
C817 a_66162_19260.t1 VSSD 0.147143f
C818 a_66162_19260.t2 VSSD 0.1636f
C819 a_66162_19260.t5 VSSD 0.130517f
C820 a_66162_19260.n2 VSSD 2.29806f
C821 a_66162_19260.t4 VSSD 0.128166f
C822 a_66162_19260.n3 VSSD 1.28395f
C823 a_66162_19260.t6 VSSD 0.088697f
C824 a_66162_19260.n4 VSSD 1.24258f
C825 a_66162_19260.t0 VSSD 0.397411f
C826 a_54210_19028.n0 VSSD 1.4589f
C827 a_54210_19028.t1 VSSD 0.246654f
C828 a_54210_19028.t6 VSSD 0.095963f
C829 a_54210_19028.t5 VSSD 0.044581f
C830 a_54210_19028.t2 VSSD 0.075381f
C831 a_54210_19028.t4 VSSD 0.075169f
C832 a_54210_19028.n1 VSSD 0.480219f
C833 a_54210_19028.t3 VSSD 0.84218f
C834 a_54210_19028.n2 VSSD 0.872922f
C835 a_54210_19028.n3 VSSD 2.44962f
C836 a_54210_19028.t0 VSSD 0.658416f
C837 a_39210_19028.n0 VSSD 1.4589f
C838 a_39210_19028.t0 VSSD 0.246654f
C839 a_39210_19028.t6 VSSD 0.095963f
C840 a_39210_19028.t5 VSSD 0.044581f
C841 a_39210_19028.t3 VSSD 0.075381f
C842 a_39210_19028.t4 VSSD 0.075169f
C843 a_39210_19028.n1 VSSD 0.480219f
C844 a_39210_19028.t2 VSSD 0.84218f
C845 a_39210_19028.n2 VSSD 0.872922f
C846 a_39210_19028.n3 VSSD 2.44962f
C847 a_39210_19028.t1 VSSD 0.658416f
C848 a_36982_19260.t1 VSSD 0.198092f
C849 a_36982_19260.t3 VSSD 0.1503f
C850 a_36982_19260.t2 VSSD 0.111361f
C851 a_36982_19260.t4 VSSD 0.210813f
C852 a_36982_19260.n0 VSSD 2.80378f
C853 a_36982_19260.t5 VSSD 0.113403f
C854 a_36982_19260.n1 VSSD 1.56811f
C855 a_36982_19260.n2 VSSD 1.46985f
C856 a_36982_19260.n3 VSSD 1.46632f
C857 a_36982_19260.t0 VSSD 0.407979f
C858 a_111982_19260.t1 VSSD 0.198092f
C859 a_111982_19260.t5 VSSD 0.1503f
C860 a_111982_19260.t3 VSSD 0.111361f
C861 a_111982_19260.t2 VSSD 0.210813f
C862 a_111982_19260.n0 VSSD 2.80378f
C863 a_111982_19260.t4 VSSD 0.113403f
C864 a_111982_19260.n1 VSSD 1.56811f
C865 a_111982_19260.n2 VSSD 1.46985f
C866 a_111982_19260.n3 VSSD 1.46632f
C867 a_111982_19260.t0 VSSD 0.407979f
C868 a_145838_19028.t1 VSSD 0.143652f
C869 a_145838_19028.t4 VSSD 0.043902f
C870 a_145838_19028.t0 VSSD 0.043779f
C871 a_145838_19028.n0 VSSD 0.279682f
C872 a_145838_19028.t3 VSSD 0.49049f
C873 a_145838_19028.n1 VSSD 0.54216f
C874 a_145838_19028.n2 VSSD 1.07527f
C875 a_145838_19028.t2 VSSD 0.381063f
C876 a_144210_19028.n0 VSSD 1.4589f
C877 a_144210_19028.t1 VSSD 0.246654f
C878 a_144210_19028.t6 VSSD 0.095963f
C879 a_144210_19028.t5 VSSD 0.044581f
C880 a_144210_19028.t4 VSSD 0.075381f
C881 a_144210_19028.t3 VSSD 0.075169f
C882 a_144210_19028.n1 VSSD 0.480219f
C883 a_144210_19028.t2 VSSD 0.84218f
C884 a_144210_19028.n2 VSSD 0.872922f
C885 a_144210_19028.n3 VSSD 2.44962f
C886 a_144210_19028.t0 VSSD 0.658416f
C887 a_25838_19028.t1 VSSD 0.043902f
C888 a_25838_19028.t4 VSSD 0.043779f
C889 a_25838_19028.n0 VSSD 0.279682f
C890 a_25838_19028.t3 VSSD 0.381113f
C891 a_25838_19028.t0 VSSD 0.143652f
C892 a_25838_19028.n1 VSSD 1.07522f
C893 a_25838_19028.n2 VSSD 0.54216f
C894 a_25838_19028.t2 VSSD 0.49049f
C895 a_51162_19260.n0 VSSD 1.29327f
C896 a_51162_19260.t7 VSSD 0.038174f
C897 a_51162_19260.t4 VSSD 0.090059f
C898 a_51162_19260.n1 VSSD 0.298372f
C899 a_51162_19260.t1 VSSD 0.147143f
C900 a_51162_19260.t6 VSSD 0.1636f
C901 a_51162_19260.t2 VSSD 0.130517f
C902 a_51162_19260.n2 VSSD 2.29806f
C903 a_51162_19260.t5 VSSD 0.128166f
C904 a_51162_19260.n3 VSSD 1.28395f
C905 a_51162_19260.t3 VSSD 0.088697f
C906 a_51162_19260.n4 VSSD 1.24258f
C907 a_51162_19260.t0 VSSD 0.397411f
C908 a_122058_19028.t0 VSSD 0.143873f
C909 a_122058_19028.t3 VSSD 0.04397f
C910 a_122058_19028.t1 VSSD 0.043846f
C911 a_122058_19028.n0 VSSD 0.280111f
C912 a_122058_19028.t4 VSSD 0.491242f
C913 a_122058_19028.n1 VSSD 0.534715f
C914 a_122058_19028.n2 VSSD 1.07819f
C915 a_122058_19028.t2 VSSD 0.384053f
C916 a_111162_19260.n0 VSSD 1.29327f
C917 a_111162_19260.t3 VSSD 0.038174f
C918 a_111162_19260.t6 VSSD 0.090059f
C919 a_111162_19260.n1 VSSD 0.298372f
C920 a_111162_19260.t1 VSSD 0.147143f
C921 a_111162_19260.t2 VSSD 0.1636f
C922 a_111162_19260.t4 VSSD 0.130517f
C923 a_111162_19260.n2 VSSD 2.29806f
C924 a_111162_19260.t7 VSSD 0.128166f
C925 a_111162_19260.n3 VSSD 1.28395f
C926 a_111162_19260.t5 VSSD 0.088697f
C927 a_111162_19260.n4 VSSD 1.24258f
C928 a_111162_19260.t0 VSSD 0.397411f
C929 a_84210_19028.n0 VSSD 1.4589f
C930 a_84210_19028.t0 VSSD 0.075381f
C931 a_84210_19028.t2 VSSD 0.075169f
C932 a_84210_19028.n1 VSSD 0.480219f
C933 a_84210_19028.t5 VSSD 0.095963f
C934 a_84210_19028.t6 VSSD 0.044581f
C935 a_84210_19028.t3 VSSD 0.658502f
C936 a_84210_19028.t4 VSSD 0.246654f
C937 a_84210_19028.n2 VSSD 2.44953f
C938 a_84210_19028.n3 VSSD 0.872922f
C939 a_84210_19028.t1 VSSD 0.84218f
C940 a_2058_19028.t1 VSSD 0.04397f
C941 a_2058_19028.t2 VSSD 0.043846f
C942 a_2058_19028.n0 VSSD 0.280111f
C943 a_2058_19028.t4 VSSD 0.384103f
C944 a_2058_19028.t3 VSSD 0.143873f
C945 a_2058_19028.n1 VSSD 1.07814f
C946 a_2058_19028.n2 VSSD 0.534715f
C947 a_2058_19028.t0 VSSD 0.491242f
C948 a_n8018_19260.t1 VSSD 0.198092f
C949 a_n8018_19260.t3 VSSD 0.1503f
C950 a_n8018_19260.t4 VSSD 0.111361f
C951 a_n8018_19260.t2 VSSD 0.210813f
C952 a_n8018_19260.n0 VSSD 2.80378f
C953 a_n8018_19260.t5 VSSD 0.113403f
C954 a_n8018_19260.n1 VSSD 1.56811f
C955 a_n8018_19260.n2 VSSD 1.46985f
C956 a_n8018_19260.n3 VSSD 1.46632f
C957 a_n8018_19260.t0 VSSD 0.407979f
C958 a_n6774_19028.n0 VSSD 1.62012f
C959 a_n6774_19028.t5 VSSD 0.058764f
C960 a_n6774_19028.t4 VSSD 0.026943f
C961 a_n6774_19028.n1 VSSD 0.285443f
C962 a_n6774_19028.t3 VSSD 0.473406f
C963 a_n6774_19028.t0 VSSD 0.14055f
C964 a_n6774_19028.n2 VSSD 1.44263f
C965 a_n6774_19028.t2 VSSD 0.14055f
C966 a_n6774_19028.t1 VSSD 0.411594f
C967 a_n4162_19028.t2 VSSD 0.043902f
C968 a_n4162_19028.t0 VSSD 0.043779f
C969 a_n4162_19028.n0 VSSD 0.279682f
C970 a_n4162_19028.t4 VSSD 0.381113f
C971 a_n4162_19028.t1 VSSD 0.143652f
C972 a_n4162_19028.n1 VSSD 1.07522f
C973 a_n4162_19028.n2 VSSD 0.54216f
C974 a_n4162_19028.t3 VSSD 0.49049f
C975 a_n8838_19260.n0 VSSD 1.29327f
C976 a_n8838_19260.t5 VSSD 0.038174f
C977 a_n8838_19260.t3 VSSD 0.090059f
C978 a_n8838_19260.n1 VSSD 0.298372f
C979 a_n8838_19260.t1 VSSD 0.147143f
C980 a_n8838_19260.t6 VSSD 0.1636f
C981 a_n8838_19260.t4 VSSD 0.130517f
C982 a_n8838_19260.n2 VSSD 2.29806f
C983 a_n8838_19260.t2 VSSD 0.128166f
C984 a_n8838_19260.n3 VSSD 1.28395f
C985 a_n8838_19260.t7 VSSD 0.088697f
C986 a_n8838_19260.n4 VSSD 1.24258f
C987 a_n8838_19260.t0 VSSD 0.397411f
C988 a_75418_19028.n0 VSSD 1.14117f
C989 a_75418_19028.t0 VSSD 0.178154f
C990 a_75418_19028.t4 VSSD 0.054447f
C991 a_75418_19028.t1 VSSD 0.054293f
C992 a_75418_19028.n1 VSSD 0.346855f
C993 a_75418_19028.t3 VSSD 0.608293f
C994 a_75418_19028.t6 VSSD 0.069313f
C995 a_75418_19028.t5 VSSD 0.0322f
C996 a_75418_19028.n2 VSSD 0.231431f
C997 a_75418_19028.t8 VSSD 0.028117f
C998 a_75418_19028.t7 VSSD 0.066332f
C999 a_75418_19028.n3 VSSD 0.216551f
C1000 a_75418_19028.n4 VSSD 1.18895f
C1001 a_75418_19028.n5 VSSD 1.60832f
C1002 a_75418_19028.t2 VSSD 0.475563f
C1003 a_128226_19028.n0 VSSD 1.62012f
C1004 a_128226_19028.t5 VSSD 0.058764f
C1005 a_128226_19028.t4 VSSD 0.026943f
C1006 a_128226_19028.n1 VSSD 0.285443f
C1007 a_128226_19028.t3 VSSD 0.473406f
C1008 a_128226_19028.t1 VSSD 0.14055f
C1009 a_128226_19028.n2 VSSD 1.44263f
C1010 a_128226_19028.t2 VSSD 0.14055f
C1011 a_128226_19028.t0 VSSD 0.411594f
C1012 a_62058_19028.t4 VSSD 0.143873f
C1013 a_62058_19028.t2 VSSD 0.04397f
C1014 a_62058_19028.t3 VSSD 0.043846f
C1015 a_62058_19028.n0 VSSD 0.280111f
C1016 a_62058_19028.t1 VSSD 0.491242f
C1017 a_62058_19028.n1 VSSD 0.534715f
C1018 a_62058_19028.n2 VSSD 1.07819f
C1019 a_62058_19028.t0 VSSD 0.384053f
C1020 a_51982_19260.t1 VSSD 0.198092f
C1021 a_51982_19260.t5 VSSD 0.1503f
C1022 a_51982_19260.t3 VSSD 0.111361f
C1023 a_51982_19260.t2 VSSD 0.210813f
C1024 a_51982_19260.n0 VSSD 2.80378f
C1025 a_51982_19260.t4 VSSD 0.113403f
C1026 a_51982_19260.n1 VSSD 1.56811f
C1027 a_51982_19260.n2 VSSD 1.46985f
C1028 a_51982_19260.n3 VSSD 1.46632f
C1029 a_51982_19260.t0 VSSD 0.407979f
C1030 a_418_19028.n0 VSSD 1.14117f
C1031 a_418_19028.t4 VSSD 0.178154f
C1032 a_418_19028.t3 VSSD 0.054447f
C1033 a_418_19028.t1 VSSD 0.054293f
C1034 a_418_19028.n1 VSSD 0.346855f
C1035 a_418_19028.t2 VSSD 0.608293f
C1036 a_418_19028.t6 VSSD 0.069313f
C1037 a_418_19028.t5 VSSD 0.0322f
C1038 a_418_19028.n2 VSSD 0.231431f
C1039 a_418_19028.t8 VSSD 0.028117f
C1040 a_418_19028.t7 VSSD 0.066332f
C1041 a_418_19028.n3 VSSD 0.216551f
C1042 a_418_19028.n4 VSSD 1.18895f
C1043 a_418_19028.n5 VSSD 1.60832f
C1044 a_418_19028.t0 VSSD 0.475563f
C1045 a_129210_19028.n0 VSSD 1.4589f
C1046 a_129210_19028.t0 VSSD 0.246654f
C1047 a_129210_19028.t5 VSSD 0.095963f
C1048 a_129210_19028.t6 VSSD 0.044581f
C1049 a_129210_19028.t3 VSSD 0.075381f
C1050 a_129210_19028.t2 VSSD 0.075169f
C1051 a_129210_19028.n1 VSSD 0.480219f
C1052 a_129210_19028.t4 VSSD 0.84218f
C1053 a_129210_19028.n2 VSSD 0.872922f
C1054 a_129210_19028.n3 VSSD 2.44962f
C1055 a_129210_19028.t1 VSSD 0.658416f
C1056 a_10838_19028.t2 VSSD 0.043902f
C1057 a_10838_19028.t0 VSSD 0.043779f
C1058 a_10838_19028.n0 VSSD 0.279682f
C1059 a_10838_19028.t3 VSSD 0.381113f
C1060 a_10838_19028.t4 VSSD 0.143652f
C1061 a_10838_19028.n1 VSSD 1.07522f
C1062 a_10838_19028.n2 VSSD 0.54216f
C1063 a_10838_19028.t1 VSSD 0.49049f
C1064 a_120418_19028.n0 VSSD 1.14117f
C1065 a_120418_19028.t1 VSSD 0.054447f
C1066 a_120418_19028.t3 VSSD 0.054293f
C1067 a_120418_19028.n1 VSSD 0.346855f
C1068 a_120418_19028.t8 VSSD 0.028117f
C1069 a_120418_19028.t7 VSSD 0.066332f
C1070 a_120418_19028.n2 VSSD 0.216551f
C1071 a_120418_19028.t2 VSSD 0.475625f
C1072 a_120418_19028.t4 VSSD 0.178154f
C1073 a_120418_19028.n3 VSSD 1.60826f
C1074 a_120418_19028.n4 VSSD 1.18895f
C1075 a_120418_19028.t6 VSSD 0.069313f
C1076 a_120418_19028.t5 VSSD 0.0322f
C1077 a_120418_19028.n5 VSSD 0.231431f
C1078 a_120418_19028.t0 VSSD 0.608293f
C1079 a_32058_19028.t3 VSSD 0.143873f
C1080 a_32058_19028.t1 VSSD 0.04397f
C1081 a_32058_19028.t4 VSSD 0.043846f
C1082 a_32058_19028.n0 VSSD 0.280111f
C1083 a_32058_19028.t2 VSSD 0.491242f
C1084 a_32058_19028.n1 VSSD 0.534715f
C1085 a_32058_19028.n2 VSSD 1.07819f
C1086 a_32058_19028.t0 VSSD 0.384053f
C1087 a_45418_19028.n0 VSSD 1.14117f
C1088 a_45418_19028.t1 VSSD 0.054447f
C1089 a_45418_19028.t4 VSSD 0.054293f
C1090 a_45418_19028.n1 VSSD 0.346855f
C1091 a_45418_19028.t6 VSSD 0.028117f
C1092 a_45418_19028.t5 VSSD 0.066332f
C1093 a_45418_19028.n2 VSSD 0.216551f
C1094 a_45418_19028.t2 VSSD 0.475625f
C1095 a_45418_19028.t3 VSSD 0.178154f
C1096 a_45418_19028.n3 VSSD 1.60826f
C1097 a_45418_19028.n4 VSSD 1.18895f
C1098 a_45418_19028.t8 VSSD 0.069313f
C1099 a_45418_19028.t7 VSSD 0.0322f
C1100 a_45418_19028.n5 VSSD 0.231431f
C1101 a_45418_19028.t0 VSSD 0.608293f
C1102 clks.t16 VSSD 0.083906f
C1103 clks.t12 VSSD 0.038979f
C1104 clks.n0 VSSD 0.844969f
C1105 clks.t21 VSSD 0.084179f
C1106 clks.t19 VSSD 0.038596f
C1107 clks.n1 VSSD 0.610306f
C1108 clks.n2 VSSD 4.6257f
C1109 clks.t39 VSSD 0.083906f
C1110 clks.t35 VSSD 0.038979f
C1111 clks.n3 VSSD 0.844969f
C1112 clks.t17 VSSD 0.084179f
C1113 clks.t14 VSSD 0.038596f
C1114 clks.n4 VSSD 0.610306f
C1115 clks.n5 VSSD 2.6159f
C1116 clks.n6 VSSD 11.258599f
C1117 clks.t32 VSSD 0.083906f
C1118 clks.t26 VSSD 0.038979f
C1119 clks.n7 VSSD 0.844969f
C1120 clks.t40 VSSD 0.084179f
C1121 clks.t38 VSSD 0.038596f
C1122 clks.n8 VSSD 0.610306f
C1123 clks.n9 VSSD 2.6159f
C1124 clks.n10 VSSD 8.387019f
C1125 clks.t8 VSSD 0.083906f
C1126 clks.t4 VSSD 0.038979f
C1127 clks.n11 VSSD 0.844969f
C1128 clks.t36 VSSD 0.084179f
C1129 clks.t30 VSSD 0.038596f
C1130 clks.n12 VSSD 0.610306f
C1131 clks.n13 VSSD 2.6159f
C1132 clks.n14 VSSD 8.38494f
C1133 clks.t11 VSSD 0.083906f
C1134 clks.t7 VSSD 0.038979f
C1135 clks.n15 VSSD 0.844969f
C1136 clks.t18 VSSD 0.084179f
C1137 clks.t15 VSSD 0.038596f
C1138 clks.n16 VSSD 0.610306f
C1139 clks.n17 VSSD 2.6159f
C1140 clks.n18 VSSD 8.38754f
C1141 clks.t34 VSSD 0.083906f
C1142 clks.t28 VSSD 0.038979f
C1143 clks.n19 VSSD 0.844969f
C1144 clks.t13 VSSD 0.084179f
C1145 clks.t10 VSSD 0.038596f
C1146 clks.n20 VSSD 0.610306f
C1147 clks.n21 VSSD 2.6159f
C1148 clks.n22 VSSD 8.38806f
C1149 clks.t25 VSSD 0.083906f
C1150 clks.t23 VSSD 0.038979f
C1151 clks.n23 VSSD 0.844969f
C1152 clks.t37 VSSD 0.084179f
C1153 clks.t31 VSSD 0.038596f
C1154 clks.n24 VSSD 0.610306f
C1155 clks.n25 VSSD 2.6159f
C1156 clks.n26 VSSD 8.39015f
C1157 clks.t3 VSSD 0.083906f
C1158 clks.t0 VSSD 0.038979f
C1159 clks.n27 VSSD 0.844969f
C1160 clks.t29 VSSD 0.084179f
C1161 clks.t24 VSSD 0.038596f
C1162 clks.n28 VSSD 0.610306f
C1163 clks.n29 VSSD 2.6159f
C1164 clks.n30 VSSD 8.38806f
C1165 clks.t43 VSSD 0.083906f
C1166 clks.t41 VSSD 0.038979f
C1167 clks.n31 VSSD 0.844969f
C1168 clks.t6 VSSD 0.084179f
C1169 clks.t2 VSSD 0.038596f
C1170 clks.n32 VSSD 0.610306f
C1171 clks.n33 VSSD 2.6159f
C1172 clks.n34 VSSD 8.3865f
C1173 clks.t22 VSSD 0.083906f
C1174 clks.t20 VSSD 0.038979f
C1175 clks.n35 VSSD 0.844969f
C1176 clks.t1 VSSD 0.084179f
C1177 clks.t42 VSSD 0.038596f
C1178 clks.n36 VSSD 0.610306f
C1179 clks.n37 VSSD 2.6159f
C1180 clks.n38 VSSD 8.38911f
C1181 clks.t33 VSSD 0.083906f
C1182 clks.t27 VSSD 0.038979f
C1183 clks.n39 VSSD 0.844969f
C1184 clks.t9 VSSD 0.084179f
C1185 clks.t5 VSSD 0.038596f
C1186 clks.n40 VSSD 0.610306f
C1187 clks.n41 VSSD 2.6159f
C1188 clks.n42 VSSD 4.50724f
C1189 a_126982_19260.t1 VSSD 0.198092f
C1190 a_126982_19260.t2 VSSD 0.1503f
C1191 a_126982_19260.t5 VSSD 0.111361f
C1192 a_126982_19260.t3 VSSD 0.210813f
C1193 a_126982_19260.n0 VSSD 2.80378f
C1194 a_126982_19260.t4 VSSD 0.113403f
C1195 a_126982_19260.n1 VSSD 1.56811f
C1196 a_126982_19260.n2 VSSD 1.46985f
C1197 a_126982_19260.n3 VSSD 1.46632f
C1198 a_126982_19260.t0 VSSD 0.407979f
C1199 a_126162_19260.n0 VSSD 1.29327f
C1200 a_126162_19260.t4 VSSD 0.038174f
C1201 a_126162_19260.t2 VSSD 0.090059f
C1202 a_126162_19260.n1 VSSD 0.298372f
C1203 a_126162_19260.t1 VSSD 0.147143f
C1204 a_126162_19260.t3 VSSD 0.1636f
C1205 a_126162_19260.t6 VSSD 0.130517f
C1206 a_126162_19260.n2 VSSD 2.29806f
C1207 a_126162_19260.t5 VSSD 0.128166f
C1208 a_126162_19260.n3 VSSD 1.28395f
C1209 a_126162_19260.t7 VSSD 0.088697f
C1210 a_126162_19260.n4 VSSD 1.24258f
C1211 a_126162_19260.t0 VSSD 0.397411f
C1212 a_60418_19028.n0 VSSD 1.14117f
C1213 a_60418_19028.t4 VSSD 0.178154f
C1214 a_60418_19028.t1 VSSD 0.054447f
C1215 a_60418_19028.t3 VSSD 0.054293f
C1216 a_60418_19028.n1 VSSD 0.346855f
C1217 a_60418_19028.t2 VSSD 0.608293f
C1218 a_60418_19028.t6 VSSD 0.069313f
C1219 a_60418_19028.t5 VSSD 0.0322f
C1220 a_60418_19028.n2 VSSD 0.231431f
C1221 a_60418_19028.t8 VSSD 0.028117f
C1222 a_60418_19028.t7 VSSD 0.066332f
C1223 a_60418_19028.n3 VSSD 0.216551f
C1224 a_60418_19028.n4 VSSD 1.18895f
C1225 a_60418_19028.n5 VSSD 1.60832f
C1226 a_60418_19028.t0 VSSD 0.475563f
C1227 VDDD.t154 VSSD 0.063423f
C1228 VDDD.n0 VSSD 2.71121f
C1229 VDDD.t221 VSSD 0.044591f
C1230 VDDD.n1 VSSD 0.105297f
C1231 VDDD.t46 VSSD 0.044591f
C1232 VDDD.t212 VSSD 0.257442f
C1233 VDDD.t177 VSSD 0.063423f
C1234 VDDD.t104 VSSD 0.063423f
C1235 VDDD.n2 VSSD 4.98182f
C1236 VDDD.n3 VSSD 5.01657f
C1237 VDDD.t211 VSSD 0.063423f
C1238 VDDD.n4 VSSD 3.29393f
C1239 VDDD.t167 VSSD 0.044591f
C1240 VDDD.n5 VSSD 0.105297f
C1241 VDDD.t40 VSSD 0.044591f
C1242 VDDD.n6 VSSD 0.296953f
C1243 VDDD.t10 VSSD 0.063423f
C1244 VDDD.t63 VSSD 0.044591f
C1245 VDDD.n7 VSSD 0.105297f
C1246 VDDD.t38 VSSD 0.044591f
C1247 VDDD.n8 VSSD 0.296953f
C1248 VDDD.t59 VSSD 0.063423f
C1249 VDDD.t95 VSSD 0.044591f
C1250 VDDD.n9 VSSD 0.105297f
C1251 VDDD.t52 VSSD 0.044591f
C1252 VDDD.n10 VSSD 0.296953f
C1253 VDDD.t179 VSSD 0.063423f
C1254 VDDD.t238 VSSD 0.044591f
C1255 VDDD.n11 VSSD 0.105297f
C1256 VDDD.t48 VSSD 0.044591f
C1257 VDDD.n12 VSSD 0.296953f
C1258 VDDD.t27 VSSD 0.063423f
C1259 VDDD.t67 VSSD 0.044591f
C1260 VDDD.n13 VSSD 0.105297f
C1261 VDDD.t36 VSSD 0.044591f
C1262 VDDD.n14 VSSD 0.296953f
C1263 VDDD.t199 VSSD 0.063423f
C1264 VDDD.t107 VSSD 0.044591f
C1265 VDDD.n15 VSSD 0.105297f
C1266 VDDD.t32 VSSD 0.044591f
C1267 VDDD.n16 VSSD 0.296953f
C1268 VDDD.t196 VSSD 0.063423f
C1269 VDDD.t118 VSSD 0.044591f
C1270 VDDD.n17 VSSD 0.105297f
C1271 VDDD.t50 VSSD 0.044591f
C1272 VDDD.n18 VSSD 0.296953f
C1273 VDDD.t23 VSSD 0.063423f
C1274 VDDD.t215 VSSD 0.044591f
C1275 VDDD.n19 VSSD 0.105297f
C1276 VDDD.t44 VSSD 0.044591f
C1277 VDDD.n20 VSSD 0.296953f
C1278 VDDD.t78 VSSD 0.063423f
C1279 VDDD.t21 VSSD 0.044591f
C1280 VDDD.n21 VSSD 0.105297f
C1281 VDDD.t34 VSSD 0.044591f
C1282 VDDD.n22 VSSD 0.296953f
C1283 VDDD.t100 VSSD 0.063423f
C1284 VDDD.t209 VSSD 0.044591f
C1285 VDDD.t208 VSSD 0.257442f
C1286 VDDD.t33 VSSD 0.290229f
C1287 VDDD.n23 VSSD 0.2509f
C1288 VDDD.t20 VSSD 0.514243f
C1289 VDDD.t1 VSSD 1.08296f
C1290 VDDD.t133 VSSD 0.800702f
C1291 VDDD.t53 VSSD 0.814715f
C1292 VDDD.t86 VSSD 0.814715f
C1293 VDDD.t175 VSSD 0.990869f
C1294 VDDD.t74 VSSD 1.42125f
C1295 VDDD.t0 VSSD 1.30114f
C1296 VDDD.t99 VSSD 0.870764f
C1297 VDDD.t12 VSSD 0.82072f
C1298 VDDD.t204 VSSD 0.82072f
C1299 VDDD.t148 VSSD 0.894785f
C1300 VDDD.t2 VSSD 0.978147f
C1301 VDDD.n24 VSSD 0.300246f
C1302 VDDD.n25 VSSD 0.654808f
C1303 VDDD.t205 VSSD 0.063423f
C1304 VDDD.n26 VSSD 5.99023f
C1305 VDDD.n27 VSSD 5.01657f
C1306 VDDD.t87 VSSD 0.063423f
C1307 VDDD.n28 VSSD 4.98182f
C1308 VDDD.t134 VSSD 0.063423f
C1309 VDDD.n29 VSSD 3.39333f
C1310 VDDD.n30 VSSD 3.22077f
C1311 VDDD.t114 VSSD 0.044591f
C1312 VDDD.t113 VSSD 0.257442f
C1313 VDDD.t43 VSSD 0.290229f
C1314 VDDD.n31 VSSD 0.2509f
C1315 VDDD.t214 VSSD 0.514243f
C1316 VDDD.t3 VSSD 1.08296f
C1317 VDDD.t150 VSSD 0.800702f
C1318 VDDD.t201 VSSD 0.814715f
C1319 VDDD.t115 VSSD 0.814715f
C1320 VDDD.t101 VSSD 0.990869f
C1321 VDDD.t14 VSSD 1.42125f
C1322 VDDD.t126 VSSD 1.30114f
C1323 VDDD.t77 VSSD 0.870764f
C1324 VDDD.t16 VSSD 0.82072f
C1325 VDDD.t191 VSSD 0.82072f
C1326 VDDD.t130 VSSD 0.894785f
C1327 VDDD.t15 VSSD 0.978147f
C1328 VDDD.n32 VSSD 0.300246f
C1329 VDDD.n33 VSSD 0.189478f
C1330 VDDD.n34 VSSD 4.01054f
C1331 VDDD.t192 VSSD 0.063423f
C1332 VDDD.n35 VSSD 3.29393f
C1333 VDDD.n36 VSSD 5.01657f
C1334 VDDD.t116 VSSD 0.063423f
C1335 VDDD.n37 VSSD 4.98182f
C1336 VDDD.t151 VSSD 0.063423f
C1337 VDDD.n38 VSSD 3.39333f
C1338 VDDD.n39 VSSD 3.22077f
C1339 VDDD.t186 VSSD 0.044591f
C1340 VDDD.t185 VSSD 0.257442f
C1341 VDDD.t49 VSSD 0.290229f
C1342 VDDD.n40 VSSD 0.2509f
C1343 VDDD.t117 VSSD 0.514243f
C1344 VDDD.t180 VSSD 1.08296f
C1345 VDDD.t157 VSSD 0.800702f
C1346 VDDD.t225 VSSD 0.814715f
C1347 VDDD.t189 VSSD 0.814715f
C1348 VDDD.t8 VSSD 0.990869f
C1349 VDDD.t119 VSSD 1.42125f
C1350 VDDD.t120 VSSD 1.30114f
C1351 VDDD.t22 VSSD 0.870764f
C1352 VDDD.t17 VSSD 0.82072f
C1353 VDDD.t235 VSSD 0.82072f
C1354 VDDD.t138 VSSD 0.894785f
C1355 VDDD.t73 VSSD 0.978147f
C1356 VDDD.n41 VSSD 0.300246f
C1357 VDDD.n42 VSSD 0.189478f
C1358 VDDD.n43 VSSD 4.01054f
C1359 VDDD.t236 VSSD 0.063423f
C1360 VDDD.n44 VSSD 3.29393f
C1361 VDDD.n45 VSSD 5.01657f
C1362 VDDD.t190 VSSD 0.063423f
C1363 VDDD.n46 VSSD 4.98182f
C1364 VDDD.t158 VSSD 0.063423f
C1365 VDDD.n47 VSSD 3.39333f
C1366 VDDD.n48 VSSD 3.22077f
C1367 VDDD.t219 VSSD 0.044591f
C1368 VDDD.t218 VSSD 0.257442f
C1369 VDDD.t31 VSSD 0.290229f
C1370 VDDD.n49 VSSD 0.2509f
C1371 VDDD.t106 VSSD 0.514243f
C1372 VDDD.t109 VSSD 1.08296f
C1373 VDDD.t131 VSSD 0.800702f
C1374 VDDD.t13 VSSD 0.814715f
C1375 VDDD.t6 VSSD 0.814715f
C1376 VDDD.t75 VSSD 0.990869f
C1377 VDDD.t105 VSSD 1.42125f
C1378 VDDD.t108 VSSD 1.30114f
C1379 VDDD.t195 VSSD 0.870764f
C1380 VDDD.t56 VSSD 0.82072f
C1381 VDDD.t216 VSSD 0.82072f
C1382 VDDD.t152 VSSD 0.894785f
C1383 VDDD.t168 VSSD 0.978147f
C1384 VDDD.n50 VSSD 0.300246f
C1385 VDDD.n51 VSSD 0.189478f
C1386 VDDD.n52 VSSD 4.01054f
C1387 VDDD.t217 VSSD 0.063423f
C1388 VDDD.n53 VSSD 3.29393f
C1389 VDDD.n54 VSSD 5.01657f
C1390 VDDD.t7 VSSD 0.063423f
C1391 VDDD.n55 VSSD 4.98182f
C1392 VDDD.t132 VSSD 0.063423f
C1393 VDDD.n56 VSSD 3.39333f
C1394 VDDD.n57 VSSD 3.22077f
C1395 VDDD.t81 VSSD 0.044591f
C1396 VDDD.t80 VSSD 0.257442f
C1397 VDDD.t35 VSSD 0.290229f
C1398 VDDD.n58 VSSD 0.2509f
C1399 VDDD.t66 VSSD 0.514243f
C1400 VDDD.t194 VSSD 1.08296f
C1401 VDDD.t139 VSSD 0.800702f
C1402 VDDD.t68 VSSD 0.814715f
C1403 VDDD.t173 VSSD 0.814715f
C1404 VDDD.t102 VSSD 0.990869f
C1405 VDDD.t228 VSSD 1.42125f
C1406 VDDD.t200 VSSD 1.30114f
C1407 VDDD.t198 VSSD 0.870764f
C1408 VDDD.t55 VSSD 0.82072f
C1409 VDDD.t232 VSSD 0.82072f
C1410 VDDD.t149 VSSD 0.894785f
C1411 VDDD.t227 VSSD 0.978147f
C1412 VDDD.n59 VSSD 0.300246f
C1413 VDDD.n60 VSSD 0.189478f
C1414 VDDD.n61 VSSD 4.01054f
C1415 VDDD.t233 VSSD 0.063423f
C1416 VDDD.n62 VSSD 3.29393f
C1417 VDDD.n63 VSSD 5.01657f
C1418 VDDD.t174 VSSD 0.063423f
C1419 VDDD.n64 VSSD 4.98182f
C1420 VDDD.t140 VSSD 0.063423f
C1421 VDDD.n65 VSSD 3.39333f
C1422 VDDD.n66 VSSD 3.22077f
C1423 VDDD.t172 VSSD 0.044591f
C1424 VDDD.t171 VSSD 0.257442f
C1425 VDDD.t47 VSSD 0.290229f
C1426 VDDD.n67 VSSD 0.2509f
C1427 VDDD.t237 VSSD 0.514243f
C1428 VDDD.t72 VSSD 1.08296f
C1429 VDDD.t155 VSSD 0.800702f
C1430 VDDD.t226 VSSD 0.814715f
C1431 VDDD.t92 VSSD 0.814715f
C1432 VDDD.t98 VSSD 0.990869f
C1433 VDDD.t183 VSSD 1.42125f
C1434 VDDD.t184 VSSD 1.30114f
C1435 VDDD.t26 VSSD 0.870764f
C1436 VDDD.t234 VSSD 0.82072f
C1437 VDDD.t122 VSSD 0.82072f
C1438 VDDD.t135 VSSD 0.894785f
C1439 VDDD.t224 VSSD 0.978147f
C1440 VDDD.n68 VSSD 0.300246f
C1441 VDDD.n69 VSSD 0.189478f
C1442 VDDD.n70 VSSD 4.01054f
C1443 VDDD.t123 VSSD 0.063423f
C1444 VDDD.n71 VSSD 3.29393f
C1445 VDDD.n72 VSSD 5.01657f
C1446 VDDD.t93 VSSD 0.063423f
C1447 VDDD.n73 VSSD 4.98182f
C1448 VDDD.t156 VSSD 0.063423f
C1449 VDDD.n74 VSSD 3.39333f
C1450 VDDD.n75 VSSD 3.22077f
C1451 VDDD.t61 VSSD 0.044591f
C1452 VDDD.t60 VSSD 0.257442f
C1453 VDDD.t51 VSSD 0.290229f
C1454 VDDD.n76 VSSD 0.2509f
C1455 VDDD.t94 VSSD 0.514243f
C1456 VDDD.t30 VSSD 1.08296f
C1457 VDDD.t160 VSSD 0.800702f
C1458 VDDD.t97 VSSD 0.814715f
C1459 VDDD.t181 VSSD 0.814715f
C1460 VDDD.t76 VSSD 0.990869f
C1461 VDDD.t96 VSSD 1.42125f
C1462 VDDD.t129 VSSD 1.30114f
C1463 VDDD.t178 VSSD 0.870764f
C1464 VDDD.t169 VSSD 0.82072f
C1465 VDDD.t206 VSSD 0.82072f
C1466 VDDD.t142 VSSD 0.894785f
C1467 VDDD.t85 VSSD 0.978147f
C1468 VDDD.n77 VSSD 0.300246f
C1469 VDDD.n78 VSSD 0.189478f
C1470 VDDD.n79 VSSD 4.01054f
C1471 VDDD.t207 VSSD 0.063423f
C1472 VDDD.n80 VSSD 3.29393f
C1473 VDDD.n81 VSSD 5.01657f
C1474 VDDD.t182 VSSD 0.063423f
C1475 VDDD.n82 VSSD 4.98182f
C1476 VDDD.t161 VSSD 0.063423f
C1477 VDDD.n83 VSSD 3.39333f
C1478 VDDD.n84 VSSD 3.22077f
C1479 VDDD.t230 VSSD 0.044591f
C1480 VDDD.t229 VSSD 0.257442f
C1481 VDDD.t37 VSSD 0.290229f
C1482 VDDD.n85 VSSD 0.2509f
C1483 VDDD.t62 VSSD 0.514243f
C1484 VDDD.t163 VSSD 1.08296f
C1485 VDDD.t143 VSSD 0.800702f
C1486 VDDD.t84 VSSD 0.814715f
C1487 VDDD.t127 VSSD 0.814715f
C1488 VDDD.t5 VSSD 0.990869f
C1489 VDDD.t202 VSSD 1.42125f
C1490 VDDD.t69 VSSD 1.30114f
C1491 VDDD.t58 VSSD 0.870764f
C1492 VDDD.t11 VSSD 0.82072f
C1493 VDDD.t70 VSSD 0.82072f
C1494 VDDD.t159 VSSD 0.894785f
C1495 VDDD.t239 VSSD 0.978147f
C1496 VDDD.n86 VSSD 0.300246f
C1497 VDDD.n87 VSSD 0.189478f
C1498 VDDD.n88 VSSD 4.01054f
C1499 VDDD.t71 VSSD 0.063423f
C1500 VDDD.n89 VSSD 3.29393f
C1501 VDDD.n90 VSSD 5.01657f
C1502 VDDD.t128 VSSD 0.063423f
C1503 VDDD.n91 VSSD 4.98182f
C1504 VDDD.t144 VSSD 0.063423f
C1505 VDDD.n92 VSSD 3.39333f
C1506 VDDD.n93 VSSD 3.22077f
C1507 VDDD.t188 VSSD 0.044591f
C1508 VDDD.t187 VSSD 0.257442f
C1509 VDDD.t39 VSSD 0.290229f
C1510 VDDD.n94 VSSD 0.2509f
C1511 VDDD.t166 VSSD 0.514243f
C1512 VDDD.t124 VSSD 1.08296f
C1513 VDDD.t146 VSSD 0.800702f
C1514 VDDD.t121 VSSD 0.814715f
C1515 VDDD.t28 VSSD 0.814715f
C1516 VDDD.t231 VSSD 0.990869f
C1517 VDDD.t165 VSSD 1.42125f
C1518 VDDD.t164 VSSD 1.30114f
C1519 VDDD.t9 VSSD 0.870764f
C1520 VDDD.t4 VSSD 0.82072f
C1521 VDDD.t240 VSSD 0.82072f
C1522 VDDD.t162 VSSD 0.894785f
C1523 VDDD.t125 VSSD 0.978147f
C1524 VDDD.n95 VSSD 0.300246f
C1525 VDDD.n96 VSSD 0.189478f
C1526 VDDD.n97 VSSD 4.01054f
C1527 VDDD.t241 VSSD 0.063423f
C1528 VDDD.n98 VSSD 3.29393f
C1529 VDDD.n99 VSSD 5.01657f
C1530 VDDD.t29 VSSD 0.063423f
C1531 VDDD.n100 VSSD 4.98182f
C1532 VDDD.t147 VSSD 0.063423f
C1533 VDDD.n101 VSSD 3.39333f
C1534 VDDD.n102 VSSD 3.22077f
C1535 VDDD.n103 VSSD 4.01054f
C1536 VDDD.t213 VSSD 0.044591f
C1537 VDDD.n104 VSSD 0.189478f
C1538 VDDD.n105 VSSD 0.300246f
C1539 VDDD.t193 VSSD 0.978147f
C1540 VDDD.t145 VSSD 0.894785f
C1541 VDDD.t210 VSSD 0.82072f
C1542 VDDD.t54 VSSD 0.82072f
C1543 VDDD.t176 VSSD 0.870764f
C1544 VDDD.t223 VSSD 1.30114f
C1545 VDDD.t222 VSSD 1.42125f
C1546 VDDD.t57 VSSD 0.990869f
C1547 VDDD.t103 VSSD 0.814715f
C1548 VDDD.t79 VSSD 0.814715f
C1549 VDDD.t153 VSSD 0.800702f
C1550 VDDD.t110 VSSD 1.08296f
C1551 VDDD.t220 VSSD 0.514243f
C1552 VDDD.n106 VSSD 0.2509f
C1553 VDDD.t45 VSSD 0.290229f
C1554 VDDD.n107 VSSD 0.296953f
C1555 VDDD.t83 VSSD 0.063423f
C1556 VDDD.n108 VSSD 3.29393f
C1557 VDDD.t65 VSSD 0.044591f
C1558 VDDD.t64 VSSD 0.257442f
C1559 VDDD.t41 VSSD 0.290229f
C1560 VDDD.t25 VSSD 0.063423f
C1561 VDDD.n109 VSSD 5.01657f
C1562 VDDD.t19 VSSD 0.063423f
C1563 VDDD.n110 VSSD 4.98182f
C1564 VDDD.t137 VSSD 0.063423f
C1565 VDDD.n111 VSSD 3.39333f
C1566 VDDD.t42 VSSD 0.044591f
C1567 VDDD.n112 VSSD 0.296953f
C1568 VDDD.n113 VSSD 3.24228f
C1569 VDDD.t90 VSSD 0.044591f
C1570 VDDD.n114 VSSD 0.105297f
C1571 VDDD.n115 VSSD 0.2509f
C1572 VDDD.t89 VSSD 0.514243f
C1573 VDDD.t112 VSSD 1.08296f
C1574 VDDD.t136 VSSD 0.800702f
C1575 VDDD.t170 VSSD 0.814715f
C1576 VDDD.t18 VSSD 0.814715f
C1577 VDDD.t197 VSSD 0.990869f
C1578 VDDD.t88 VSSD 1.42125f
C1579 VDDD.t91 VSSD 1.30114f
C1580 VDDD.t24 VSSD 0.870764f
C1581 VDDD.t203 VSSD 0.82072f
C1582 VDDD.t82 VSSD 0.82072f
C1583 VDDD.t141 VSSD 0.894785f
C1584 VDDD.t111 VSSD 0.978147f
C1585 VDDD.n116 VSSD 0.300246f
C1586 VDDD.n117 VSSD 0.189478f
C1587 VDDD.n118 VSSD 4.01054f
C1588 VDDD.n119 VSSD 2.02988f
C1589 a_99210_19028.n0 VSSD 1.4589f
C1590 a_99210_19028.t1 VSSD 0.075381f
C1591 a_99210_19028.t4 VSSD 0.075169f
C1592 a_99210_19028.n1 VSSD 0.480219f
C1593 a_99210_19028.t6 VSSD 0.095963f
C1594 a_99210_19028.t5 VSSD 0.044581f
C1595 a_99210_19028.t2 VSSD 0.658502f
C1596 a_99210_19028.t3 VSSD 0.246654f
C1597 a_99210_19028.n2 VSSD 2.44953f
C1598 a_99210_19028.n3 VSSD 0.872922f
C1599 a_99210_19028.t0 VSSD 0.84218f
C1600 a_98226_19028.n0 VSSD 1.62008f
C1601 a_98226_19028.t4 VSSD 0.058764f
C1602 a_98226_19028.t5 VSSD 0.026943f
C1603 a_98226_19028.n1 VSSD 0.285443f
C1604 a_98226_19028.t2 VSSD 0.411632f
C1605 a_98226_19028.t1 VSSD 0.14055f
C1606 a_98226_19028.t3 VSSD 0.14055f
C1607 a_98226_19028.n2 VSSD 1.44268f
C1608 a_98226_19028.t0 VSSD 0.473359f
.ends
