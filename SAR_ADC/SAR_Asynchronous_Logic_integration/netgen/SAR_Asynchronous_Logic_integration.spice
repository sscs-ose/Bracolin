* NGSPICE file created from SAR_Asynchronous_Logic_integration.ext - technology: gf180mcuD

.subckt SAR_Asynchronous_Logic_integration out_11 out_10 out_9 out_8 out_7 out_6 out_5
+ out_4 out_3 out_2 out_1 CK_11 CK_10 CK_9 CK_8 CK_7 CK_6 CK_5 CK_4 CK_3 CK_2 CK_1
+ D_C_11 D_C_10 D_C_9 D_C_8 D_C_7 D_C_6 D_C_5 D_C_4 D_C_3 D_C_2 D_C_1 Reset Bit_10
+ Bit_9 Bit_8 Bit_7 Bit_6 Bit_5 Bit_4 Bit_3 Bit_2 Bit_1 Bit_0 clks Set VCM VDDD VSSD
X0 a_76034_n314# a_67902_n82.t2 a_70950_n314.t4 VDDD.t495 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X1 a_12918_n14314.t2 a_6822_n13946.t2 a_12732_n13054.t2 VDDD.t0 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X2 a_99002_n80.t1 a_98110_n80.t2 VDDD.t76 VDDD.t75 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X3 a_n18190_n3162# a_n21368_n3162.t4 a_n22658_n4422.t2 VDDD.t230 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X4 VSSD.t318 SAR_Asynchronous_Logic_0/D_reset_FF_0.Q.t3 a_n27210_n4422.t1 VSSD.t317 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X5 a_4790_n4422.t3 Set.t0 VSSD.t661 VSSD.t660 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X6 VSSD.t369 a_105342_n4422.t5 a_106818_n4422.t1 VSSD.t368 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X7 a_10818_n4422.t1 a_4722_n3300.t2 a_10632_n3162.t0 VSSD.t399 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X8 VSSD.t105 a_78134_n18422.t4 SAR_Asynchronous_Logic_7/D_reset_FF_0.Q.t0 VSSD.t104 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X9 VSSD.t459 Reset.t0 a_n23422_n314.t1 VSSD.t458 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X10 VSSD.t107 a_133966_n314.t4 a_134950_n314.t2 VSSD.t106 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X11 a_n21182_n4422.t2 a_n27278_n4054.t2 a_n21368_n3162.t0 VDDD.t333 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X12 a_110134_n18422.t0 a_102002_n18190.t2 a_112898_n18422.t0 VSSD.t619 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X13 VSSD.t439 a_96736_n13096.t2 a_102822_n13946.t1 VSSD.t438 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X14 VSSD.t276 a_107442_n14314.t5 a_108918_n14314.t4 VSSD.t275 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X15 VDDD.t7 a_6822_n13946.t3 a_6822_n13192.t0 VDDD.t6 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X16 VSSD.t577 a_41342_n4422.t5 a_42818_n4422.t4 VSSD.t576 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X17 a_8066_n18422.t2 a_6822_n18190.t2 SAR_Asynchronous_Logic_4/D_reset_FF_1.Q.t8 VDDD.t378 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X18 D_C_2.t1 a_38822_n13192.t2 a_44732_n13054.t3 VDDD.t430 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X19 SAR_Asynchronous_Logic_5/D_reset_FF_1.nQ SAR_Asynchronous_Logic_5/D_reset_FF_1.Q.t9 VDDD.t263 VDDD.t262 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X20 VDDD.t271 a_132722_n4054.t2 a_132722_n3300.t0 VDDD.t270 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X21 a_146854_1076.t0 a_131002_n80.t2 VDDD.t273 VDDD.t272 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=1.1u
X22 a_102822_n18190.t1 a_102002_n18190.t3 VSSD.t621 VSSD.t620 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X23 VSSD.t663 Set.t1 a_139442_n14314.t3 VSSD.t662 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X24 VSSD.t494 a_64736_n13096.t2 a_70822_n13946.t1 VSSD.t493 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X25 a_78134_n18422.t0 a_70002_n18190.t2 a_80898_n18422.t2 VSSD.t24 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X26 a_110134_n18422.t3 a_102822_n18190.t2 a_105050_n18422.t0 VSSD.t690 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X27 SAR_Asynchronous_Logic_1/D_reset_FF_1.Q.t1 a_34110_n80.t2 a_50854_1076.t0 VDDD.t190 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X28 SAR_Asynchronous_Logic_3/D_reset_FF_1.Q.t2 Reset.t1 VSSD.t461 VSSD.t460 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X29 VSSD.t665 Set.t2 a_144898_n18422.t4 VSSD.t664 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X30 SAR_Asynchronous_Logic_4/D_reset_FF_1.Q.t0 a_6704_n13054# VSSD.t40 VSSD.t39 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X31 a_46798_n314.t1 SAR_Asynchronous_Logic_1/D_reset_FF_1.Q.t9 VSSD.t162 VSSD.t161 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X32 VDDD.t393 a_68722_n4054.t2 a_68722_n3300.t0 VDDD.t392 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X33 VDDD.t426 Reset.t2 a_41702_n13054# VDDD.t425 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X34 VDDD.t480 clks.t0 a_132722_n4054.t1 VDDD.t479 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X35 a_70822_n18190.t1 a_70002_n18190.t3 VSSD.t26 VSSD.t25 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X36 a_67002_n80.t1 a_66110_n80.t2 VSSD.t44 VSSD.t43 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X37 a_98012_n13060.t1 a_96736_n13096.t3 SAR_Asynchronous_Logic_8/D_reset_FF_1.Q.t6 VSSD.t440 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X38 VDDD.t55 a_36722_n4054.t2 a_36722_n3300.t0 VDDD.t54 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X39 SAR_Asynchronous_Logic_5/D_reset_FF_1.Q.t8 a_68722_n4054.t3 a_74632_n3162.t1 VSSD.t419 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X40 a_111258_n17162# Reset.t3 VDDD.t428 VDDD.t427 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X41 VDDD.t482 clks.t1 a_68722_n4054.t1 VDDD.t481 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X42 a_144898_n17162# SAR_Asynchronous_Logic_10/D_reset_FF_0.Q.t3 VDDD.t9 VDDD.t8 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X43 Bit_4.t2 a_129966_n18540# VSSD.t472 VSSD.t471 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=1.1u
X44 a_12182_n3162# Reset.t4 a_10818_n4422.t2 VDDD.t429 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X45 VDDD.t484 clks.t2 a_36722_n4054.t0 VDDD.t483 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X46 VDDD.t50 SAR_Asynchronous_Logic_7/D_reset_FF_1.Q.t9 SAR_Asynchronous_Logic_7/D_reset_FF_1.nQ VDDD.t49 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X47 SAR_Asynchronous_Logic_0/D_reset_FF_1.Q.t0 Reset.t5 VSSD.t423 VSSD.t422 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X48 Bit_3.t1 a_97966_n18540# VSSD.t217 VSSD.t216 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=1.1u
X49 a_75442_n14314.t2 a_76732_n13054.t4 VSSD.t33 VSSD.t32 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X50 VSSD.t189 SAR_Asynchronous_Logic_4/D_reset_FF_1.Q.t9 SAR_Asynchronous_Logic_4/D_reset_FF_1.nQ VSSD.t188 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X51 a_108034_n314# a_99902_n82.t2 a_102950_n314.t0 VDDD.t60 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X52 VSSD.t73 SAR_Asynchronous_Logic_3/D_reset_FF_0.Q.t3 a_4790_n4422.t0 VSSD.t72 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X53 VSSD.t633 a_102822_n13946.t2 a_102822_n13192.t1 VSSD.t632 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X54 a_43442_n14314.t0 a_38822_n13946.t2 a_38704_n13054# VDDD.t69 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X55 a_n23422_n314.t0 a_n25050_n314.t5 VSSD.t31 VSSD.t30 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X56 a_n27210_n4422.t0 Set.t3 VSSD.t168 VSSD.t167 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X57 VSSD.t408 a_136066_n18422.t4 a_137050_n18422.t0 VSSD.t407 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X58 a_134890_n14314.t3 Set.t4 VSSD.t170 VSSD.t169 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X59 a_67902_n82.t1 a_67002_n80.t2 VSSD.t449 VSSD.t448 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X60 VSSD.t209 a_70822_n13946.t2 a_70822_n13192.t1 VSSD.t208 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X61 SAR_Asynchronous_Logic_9/D_reset_FF_1.nQ SAR_Asynchronous_Logic_9/D_reset_FF_1.Q.t9 VDDD.t456 VDDD.t455 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X62 a_142134_n18422.t0 a_134822_n18190.t2 a_144898_n18422.t2 VDDD.t244 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X63 a_38002_n18190.t1 clks.t3 VSSD.t528 VSSD.t527 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X64 VDDD.t571 a_139442_n14314.t5 a_142282_n13054# VDDD.t570 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X65 a_129966_n18540# a_128736_n13850.t2 SAR_Asynchronous_Logic_10/D_reset_FF_1.Q.t1 VDDD.t165 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X66 a_100722_n82.t0 a_99902_n82.t3 VDDD.t62 VDDD.t61 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X67 a_37966_n314.t2 a_36722_n82.t2 a_40578_n314.t4 VSSD.t638 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X68 VSSD.t172 Set.t5 a_46798_n314.t3 VSSD.t171 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X69 a_4790_n4422.t1 a_4722_n4054.t2 a_4604_n3162.t0 VSSD.t75 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X70 VSSD.t61 a_147052_n4460# Bit_5.t0 VSSD.t60 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=1.1u
X71 a_108034_n314# a_100722_n82.t2 a_102950_n314.t2 VSSD.t405 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X72 VDDD.t47 a_98012_n13060.t3 Bit_3.t2 VDDD.t46 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=1.1u
X73 a_133962_n3162# Set.t6 a_132790_n4422.t3 VDDD.t169 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X74 a_142134_n18422.t2 a_134002_n18190.t2 a_137050_n18422.t2 VDDD.t225 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X75 a_9050_n18422.t1 a_8066_n18422.t4 a_9050_n17162# VDDD.t460 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X76 a_98110_n80.t0 CK_7.t0 VDDD.t288 VDDD.t287 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X77 a_99902_n82.t0 a_99002_n80.t2 VDDD.t81 VDDD.t80 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X78 a_8062_n13054# Set.t7 a_6890_n14314.t3 VDDD.t170 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X79 a_14798_946# SAR_Asynchronous_Logic_3/D_reset_FF_1.Q.t9 VDDD.t210 VDDD.t209 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X80 VSSD.t530 clks.t4 a_n27278_n4054.t1 VSSD.t529 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X81 VSSD.t67 a_83052_n4460# Bit_7.t1 VSSD.t66 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=1.1u
X82 VSSD.t205 SAR_Asynchronous_Logic_5/D_reset_FF_0.Q.t3 SAR_Asynchronous_Logic_5/D_reset_FF_0.nQ VSSD.t204 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X83 a_137050_n18422.t4 Set.t8 VSSD.t174 VSSD.t173 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X84 a_102002_n18190.t1 clks.t5 VDDD.t470 VDDD.t469 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X85 a_46798_n314.t2 Set.t9 a_46798_946# VDDD.t171 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X86 SAR_Asynchronous_Logic_4/D_reset_FF_0.Q.t0 Reset.t6 VSSD.t425 VSSD.t424 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X87 a_n25050_946# Set.t10 VDDD.t173 VDDD.t172 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X88 a_12034_n314# a_4722_n82.t2 a_14798_n314.t0 VDDD.t242 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X89 a_8578_n314.t2 a_6950_n314.t5 VSSD.t310 VSSD.t309 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X90 VSSD.t354 a_n27278_n4054.t3 a_n27278_n3300.t1 VSSD.t353 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X91 a_48898_n18422.t0 SAR_Asynchronous_Logic_2/D_reset_FF_0.Q.t3 VSSD.t642 VSSD.t641 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X92 VCM.t17 a_n29890_n80.t2 Bit_10.t2 VSSD.t303 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X93 a_37962_n3162# Set.t11 a_36790_n4422.t4 VDDD.t174 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X94 SAR_Asynchronous_Logic_9/D_reset_FF_0.Q.t1 a_100604_n3162.t4 VSSD.t592 VSSD.t591 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X95 a_42678_n18422.t2 a_41050_n18422.t5 VSSD.t226 VSSD.t225 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X96 VCM.t12 a_3002_n80.t2 Bit_9.t2 VDDD.t251 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X97 a_136578_n314.t4 a_134950_n314.t5 VSSD.t371 VSSD.t370 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X98 a_n25050_n314.t0 a_n26034_n314.t4 a_n25050_946# VDDD.t107 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X99 SAR_Asynchronous_Logic_6/D_reset_FF_1.Q.t2 Reset.t7 VSSD.t427 VSSD.t426 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X100 VDDD.t161 a_32736_n13850.t2 a_32736_n13096.t0 VDDD.t160 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X101 a_7602_n3162# a_4604_n3162.t4 SAR_Asynchronous_Logic_3/D_reset_FF_0.Q.t1 VDDD.t520 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X102 a_9050_n17162# Set.t12 VDDD.t176 VDDD.t175 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X103 a_5966_n314.t1 a_4722_n82.t3 D_C_10.t0 VDDD.t243 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X104 a_66110_n80.t1 CK_8.t0 VSSD.t295 VSSD.t294 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X105 a_110282_n13054# Reset.t8 a_108918_n14314.t2 VDDD.t401 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X106 a_105342_n4422.t0 a_100722_n4054.t2 a_100604_n3162.t1 VDDD.t106 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X107 a_n13146_1076.t1 a_n28998_n80.t2 VDDD.t439 VDDD.t438 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=1.1u
X108 a_41342_n4422.t0 a_36722_n4054.t3 a_36604_n3162.t1 VDDD.t379 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X109 a_33966_n18540# a_32736_n13096.t2 SAR_Asynchronous_Logic_2/D_reset_FF_1.Q.t5 VSSD.t110 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X110 VSSD.t447 a_43442_n14314.t5 a_44918_n14314.t4 VSSD.t446 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X111 a_138818_n4422.t4 a_132722_n3300.t2 a_138632_n3162.t3 VSSD.t281 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X112 a_76034_n314# a_68722_n82.t2 a_70950_n314.t0 VSSD.t22 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X113 D_C_4.t0 a_102822_n13946.t3 a_108732_n13054.t1 VSSD.t190 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X114 VDDD.t95 SAR_Asynchronous_Logic_6/D_reset_FF_0.Q.t3 a_133962_n3162# VDDD.t94 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X115 VSSD.t429 Reset.t9 a_106678_n18422.t2 VSSD.t428 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X116 VSSD.t63 SAR_Asynchronous_Logic_2/D_reset_FF_1.Q.t9 a_38890_n14314.t0 VSSD.t62 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X117 a_137342_n4422.t4 a_138632_n3162.t4 VSSD.t241 VSSD.t240 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X118 a_72578_946# a_70950_n314.t5 VDDD.t102 VDDD.t101 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X119 a_38822_n18190.t1 a_38002_n18190.t2 VSSD.t313 VSSD.t312 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X120 SAR_Asynchronous_Logic_1/D_reset_FF_1.Q.t7 a_35002_n80.t2 a_50854_1076.t2 VSSD.t691 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X121 a_74818_n4422.t3 a_68722_n3300.t2 a_74632_n3162.t2 VSSD.t531 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X122 VDDD.t93 a_n22658_n4422.t5 a_n19818_n3162# VDDD.t92 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X123 a_105342_n4422.t2 a_106632_n3162.t4 VSSD.t381 VSSD.t380 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X124 a_46134_n18422.t1 a_38822_n18190.t2 a_41050_n18422.t0 VSSD.t263 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X125 VSSD.t265 CK_2.t0 a_32736_n13850.t1 VSSD.t264 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X126 VSSD.t431 Reset.t10 a_8578_n314.t4 VSSD.t430 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X127 a_44034_n314# a_35902_n82.t2 a_46798_n314.t0 VSSD.t74 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X128 VDDD.t197 SAR_Asynchronous_Logic_5/D_reset_FF_0.Q.t4 a_69962_n3162# VDDD.t196 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X129 D_C_3.t1 a_70822_n13946.t3 a_76732_n13054.t3 VSSD.t210 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X130 VSSD.t433 Reset.t11 a_74678_n18422.t0 VSSD.t432 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X131 VDDD.t407 a_96736_n13096.t4 a_102822_n13946.t0 VDDD.t406 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X132 a_13158_946# Reset.t12 VDDD.t403 VDDD.t402 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X133 a_34012_n13060.t0 a_32736_n13850.t3 SAR_Asynchronous_Logic_2/D_reset_FF_1.Q.t1 VDDD.t162 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X134 VDDD.t261 SAR_Asynchronous_Logic_1/D_reset_FF_0.Q.t3 a_37962_n3162# VDDD.t260 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X135 a_41342_n4422.t3 a_42632_n3162.t4 VSSD.t679 VSSD.t678 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X136 a_106678_n17162# a_105050_n18422.t5 VDDD.t452 VDDD.t451 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X137 VSSD.t103 a_n26034_n314.t5 a_n25050_n314.t1 VSSD.t102 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X138 VSSD.t435 Reset.t13 a_136578_n314.t1 VSSD.t434 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X139 VSSD.t437 Reset.t14 SAR_Asynchronous_Logic_9/D_reset_FF_0.Q.t0 VSSD.t436 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X140 a_47258_n17162# Reset.t15 VDDD.t405 VDDD.t404 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X141 a_102890_n14314.t2 a_102822_n13192.t2 a_102704_n13054# VDDD.t38 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X142 a_132790_n4422.t2 a_132722_n3300.t3 a_132604_n3162.t2 VDDD.t194 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X143 a_8066_n18422.t0 a_6002_n18190.t2 a_10678_n18422.t4 VDDD.t229 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X144 a_n12948_n4460# a_n29890_n80.t3 VSSD.t579 VSSD.t578 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=1.1u
X145 a_102822_n18190.t0 a_102002_n18190.t4 VDDD.t546 VDDD.t545 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X146 VDDD.t208 a_64736_n13096.t3 a_70822_n13946.t0 VDDD.t207 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X147 a_69966_n314.t2 a_67902_n82.t3 a_72578_n314.t4 VDDD.t494 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X148 VDDD.t147 Reset.t16 a_7602_n3162# VDDD.t146 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X149 VSSD.t137 Reset.t17 SAR_Asynchronous_Logic_1/D_reset_FF_0.Q.t2 VSSD.t136 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X150 a_74678_n17162# a_73050_n18422.t5 VDDD.t433 VDDD.t432 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X151 a_70890_n14314.t1 a_70822_n13192.t2 a_70704_n13054# VDDD.t125 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X152 SAR_Asynchronous_Logic_3/D_reset_FF_1.Q.t1 a_12034_n314# a_13158_946# VDDD.t24 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X153 a_70822_n18190.t0 a_70002_n18190.t4 VDDD.t33 VDDD.t32 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X154 a_40066_n18422.t0 a_38822_n18190.t3 SAR_Asynchronous_Logic_2/D_reset_FF_1.Q.t8 VDDD.t581 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X155 a_36790_n4422.t1 a_36722_n3300.t2 a_36604_n3162.t2 VDDD.t399 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X156 SAR_Asynchronous_Logic_4/D_reset_FF_0.Q.t1 a_14134_n18422.t4 a_15258_n17162# VDDD.t344 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X157 a_12918_n14314.t0 Reset.t18 VSSD.t139 VSSD.t138 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X158 a_76182_n3162# Reset.t19 a_74818_n4422.t2 VDDD.t148 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X159 SAR_Asynchronous_Logic_2/D_reset_FF_0.nQ SAR_Asynchronous_Logic_2/D_reset_FF_0.Q.t4 VSSD.t287 VSSD.t286 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X160 VSSD.t17 a_108034_n314# SAR_Asynchronous_Logic_9/D_reset_FF_1.Q.t0 VSSD.t16 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X161 VDDD.t387 SAR_Asynchronous_Logic_8/D_reset_FF_1.Q.t9 a_104062_n13054# VDDD.t386 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X162 SAR_Asynchronous_Logic_2/D_reset_FF_1.Q.t3 a_38704_n13054# VSSD.t7 VSSD.t6 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X163 VSSD.t176 Set.t13 a_137342_n4422.t2 VSSD.t175 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X164 VDDD.t184 a_75442_n14314.t5 a_78282_n13054# VDDD.t183 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X165 a_104578_946# a_102950_n314.t5 VDDD.t37 VDDD.t36 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X166 VSSD.t245 SAR_Asynchronous_Logic_3/D_reset_FF_0.Q.t4 SAR_Asynchronous_Logic_3/D_reset_FF_0.nQ VSSD.t244 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X167 a_65966_n18540# a_64736_n13850.t2 SAR_Asynchronous_Logic_7/D_reset_FF_1.Q.t5 VDDD.t434 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X168 VCM.t7 a_131002_n80.t3 Bit_5.t1 VDDD.t274 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X169 VSSD.t178 Set.t14 a_n22658_n4422.t0 VSSD.t177 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X170 VDDD.t180 SAR_Asynchronous_Logic_4/D_reset_FF_1.Q.t10 SAR_Asynchronous_Logic_4/D_reset_FF_1.nQ VDDD.t179 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X171 D_C_5.t0 a_134822_n13192.t2 a_140732_n13054.t1 VDDD.t559 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X172 VDDD.t187 a_102822_n13946.t4 a_102822_n13192.t0 VDDD.t186 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X173 VDDD.t52 SAR_Asynchronous_Logic_7/D_reset_FF_1.Q.t10 a_72062_n13054# VDDD.t51 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X174 SAR_Asynchronous_Logic_3/D_reset_FF_1.nQ SAR_Asynchronous_Logic_3/D_reset_FF_1.Q.t10 VDDD.t212 VDDD.t211 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X175 a_138678_n18422.t1 Reset.t20 a_138678_n17162# VDDD.t149 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X176 a_136578_n314.t0 Reset.t21 a_136578_946# VDDD.t150 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X177 SAR_Asynchronous_Logic_9/D_reset_FF_1.Q.t7 a_99002_n80.t3 a_115052_n4460# VSSD.t414 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X178 a_78134_n18422.t1 a_70002_n18190.t5 a_73050_n18422.t0 VDDD.t34 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X179 a_142798_946# SAR_Asynchronous_Logic_6/D_reset_FF_1.Q.t9 VDDD.t124 VDDD.t123 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X180 a_102950_n314.t4 Set.t15 VSSD.t180 VSSD.t179 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X181 SAR_Asynchronous_Logic_0/D_reset_FF_1.Q.t2 a_n28998_n80.t3 a_n12948_n4460# VSSD.t482 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X182 VSSD.t182 Set.t16 a_41342_n4422.t2 VSSD.t181 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X183 VDDD.t203 a_70822_n13946.t4 a_70822_n13192.t0 VDDD.t202 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X184 a_n25050_n314.t4 Set.t17 VSSD.t123 VSSD.t122 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X185 a_5966_n314.t3 a_3902_n82.t2 D_C_10.t1 VSSD.t537 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X186 SAR_Asynchronous_Logic_1/D_reset_FF_1.Q.t8 a_35002_n80.t3 a_51052_n4460# VSSD.t692 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X187 a_38002_n18190.t0 clks.t6 VDDD.t472 VDDD.t471 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X188 a_n29890_n80.t0 CK_11.t0 VDDD.t215 VDDD.t214 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X189 VDDD.t490 a_9342_n4422.t5 a_12182_n3162# VDDD.t489 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X190 VSSD.t12 a_96736_n13850.t2 a_97966_n18540# VSSD.t11 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=1.1u
X191 Bit_4.t0 a_128736_n13096.t2 VCM.t1 VDDD.t45 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X192 a_140034_n314# a_132722_n82.t2 a_142798_n314.t1 VDDD.t437 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X193 Bit_2.t2 a_64736_n13850.t3 VCM.t20 VSSD.t477 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X194 a_101966_n314.t0 a_99902_n82.t4 a_104578_n314.t0 VDDD.t63 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X195 a_n22658_n4422.t3 a_n27278_n4054.t4 a_n27396_n3162.t0 VDDD.t334 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X196 SAR_Asynchronous_Logic_6/D_reset_FF_1.Q.t6 a_132722_n3300.t4 a_138632_n3162.t2 VDDD.t195 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X197 a_133966_n314.t1 a_131902_n82.t2 D_C_6.t1 VSSD.t338 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X198 a_15910_n13054# a_12732_n13054.t4 a_11442_n14314.t0 VDDD.t18 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X199 VCM.t15 a_2110_n80.t2 Bit_9.t1 VSSD.t331 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X200 VDDD.t474 clks.t7 a_n27278_n4054.t0 VDDD.t473 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X201 Bit_3.t3 a_96736_n13096.t5 VCM.t13 VDDD.t408 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X202 a_n26034_n314.t2 a_n28098_n82.t2 a_n23422_n314.t4 VDDD.t315 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X203 VDDD.t199 SAR_Asynchronous_Logic_5/D_reset_FF_0.Q.t5 SAR_Asynchronous_Logic_5/D_reset_FF_0.nQ VDDD.t198 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X204 a_69966_n314.t0 a_68722_n82.t3 D_C_8.t0 VDDD.t30 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X205 SAR_Asynchronous_Logic_1/D_reset_FF_1.Q.t4 a_36722_n3300.t3 a_42632_n3162.t3 VDDD.t400 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X206 VSSD.t95 a_76034_n314# SAR_Asynchronous_Logic_5/D_reset_FF_1.Q.t2 VSSD.t94 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X207 a_105702_n13054# a_102704_n13054# SAR_Asynchronous_Logic_8/D_reset_FF_1.Q.t4 VDDD.t91 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X208 VDDD.t410 a_96736_n13096.t6 a_98012_n13060.t2 VDDD.t409 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=1.1u
X209 a_46282_n13054# Reset.t22 a_44918_n14314.t2 VDDD.t151 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X210 VDDD.t336 a_n27278_n4054.t5 a_n27278_n3300.t0 VDDD.t335 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X211 a_41050_n18422.t1 a_40066_n18422.t4 a_41050_n17162# VDDD.t374 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X212 SAR_Asynchronous_Logic_5/D_reset_FF_1.nQ SAR_Asynchronous_Logic_5/D_reset_FF_1.Q.t10 VSSD.t274 VSSD.t273 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X213 a_12918_n14314.t1 a_6822_n13192.t2 a_12732_n13054.t0 VSSD.t183 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X214 a_40062_n13054# Set.t18 a_38890_n14314.t3 VDDD.t131 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X215 Bit_9.t0 a_18854_1076.t3 VDDD.t159 VDDD.t158 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=1.1u
X216 a_n22658_n4422.t1 a_n21368_n3162.t5 VSSD.t320 VSSD.t319 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X217 a_73702_n13054# a_70704_n13054# SAR_Asynchronous_Logic_7/D_reset_FF_1.Q.t6 VDDD.t457 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X218 a_115052_n4460# a_98110_n80.t3 VSSD.t92 VSSD.t91 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=1.1u
X219 a_n21182_n4422.t4 a_n27278_n3300.t2 a_n21368_n3162.t2 VSSD.t574 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X220 a_n23422_946# a_n25050_n314.t6 VDDD.t43 VDDD.t42 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X221 a_8066_n18422.t1 a_6002_n18190.t3 SAR_Asynchronous_Logic_4/D_reset_FF_1.Q.t5 VSSD.t235 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X222 a_134002_n18190.t1 clks.t8 VSSD.t520 VSSD.t519 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X223 D_C_2.t0 a_38822_n13946.t3 a_44732_n13054.t0 VSSD.t56 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X224 a_70950_n314.t2 Set.t19 VSSD.t125 VSSD.t124 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X225 a_51052_n4460# a_34110_n80.t3 VSSD.t193 VSSD.t192 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=1.1u
X226 a_n28098_n82.t0 a_n28998_n80.t4 VDDD.t441 VDDD.t440 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X227 VSSD.t38 a_101966_n314.t4 a_102950_n314.t1 VSSD.t37 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X228 VSSD.t14 a_96736_n13850.t3 a_96736_n13096.t0 VSSD.t13 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X229 a_141158_946# Reset.t23 VDDD.t153 VDDD.t152 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X230 a_19052_n4460# a_2110_n80.t3 VSSD.t506 VSSD.t505 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=1.1u
X231 VSSD.t141 Reset.t24 SAR_Asynchronous_Logic_2/D_reset_FF_1.Q.t4 VSSD.t140 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X232 a_114854_1076.t2 a_99002_n80.t4 VDDD.t79 VDDD.t78 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=1.1u
X233 a_41050_n17162# Set.t20 VDDD.t133 VDDD.t132 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X234 VSSD.t479 a_64736_n13850.t4 a_64736_n13096.t0 VSSD.t478 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X235 a_38890_n14314.t2 a_38822_n13192.t3 a_38704_n13054# VDDD.t431 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X236 SAR_Asynchronous_Logic_3/D_reset_FF_1.Q.t6 a_2110_n80.t4 a_18854_1076.t2 VDDD.t458 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X237 a_99002_n80.t0 a_98110_n80.t4 VSSD.t90 VSSD.t89 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X238 SAR_Asynchronous_Logic_8/D_reset_FF_0.Q.t0 Reset.t25 VSSD.t143 VSSD.t142 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X239 a_38822_n18190.t0 a_38002_n18190.t3 VDDD.t301 VDDD.t300 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X240 a_14798_n314.t1 SAR_Asynchronous_Logic_3/D_reset_FF_1.Q.t11 VSSD.t213 VSSD.t212 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X241 a_70950_n314.t1 a_69966_n314.t4 a_70950_946# VDDD.t90 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X242 a_144898_n18422.t0 SAR_Asynchronous_Logic_10/D_reset_FF_0.Q.t4 VSSD.t1 VSSD.t0 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X243 VDDD.t241 CK_2.t1 a_32736_n13850.t0 VDDD.t240 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X244 SAR_Asynchronous_Logic_6/D_reset_FF_1.Q.t7 a_140034_n314# a_141158_946# VDDD.t453 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X245 a_10818_n4422.t0 Reset.t26 VSSD.t145 VSSD.t144 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X246 SAR_Asynchronous_Logic_4/D_reset_FF_0.nQ SAR_Asynchronous_Logic_4/D_reset_FF_0.Q.t3 VSSD.t267 VSSD.t266 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X247 a_n28998_n80.t0 a_n29890_n80.t4 VDDD.t519 VDDD.t518 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X248 a_70950_946# Set.t21 VDDD.t135 VDDD.t134 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X249 SAR_Asynchronous_Logic_9/D_reset_FF_1.nQ SAR_Asynchronous_Logic_9/D_reset_FF_1.Q.t10 VSSD.t500 VSSD.t499 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X250 a_140034_n314# a_131902_n82.t3 a_134950_n314.t0 VDDD.t337 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X251 a_43442_n14314.t3 a_38822_n13192.t4 a_38704_n13054# VSSD.t462 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X252 Bit_0.t0 a_736_n13096.t2 VCM.t14 VDDD.t304 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X253 a_100722_n82.t1 a_99902_n82.t5 VSSD.t52 VSSD.t51 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X254 a_44918_n14314.t0 a_38822_n13946.t4 a_44732_n13054.t1 VDDD.t70 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X255 VDDD.t137 Set.t22 a_15910_n13054# VDDD.t136 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X256 a_n19818_n3162# Reset.t27 a_n21182_n4422.t0 VDDD.t154 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X257 a_16898_n18422.t3 Set.t23 a_16898_n17162# VDDD.t138 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X258 VSSD.t35 a_128736_n13096.t3 a_134822_n13946.t1 VSSD.t34 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X259 SAR_Asynchronous_Logic_6/D_reset_FF_1.nQ SAR_Asynchronous_Logic_6/D_reset_FF_1.Q.t10 VDDD.t164 VDDD.t163 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X260 a_99902_n82.t1 a_99002_n80.t5 VSSD.t413 VSSD.t412 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X261 VCM.t18 a_130110_n80.t2 Bit_5.t2 VSSD.t384 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X262 a_142134_n18422.t3 a_134002_n18190.t3 a_144898_n18422.t1 VSSD.t231 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X263 VSSD.t650 a_139442_n14314.t6 a_140918_n14314.t0 VSSD.t649 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X264 a_129966_n18540# a_128736_n13096.t4 SAR_Asynchronous_Logic_10/D_reset_FF_1.Q.t0 VSSD.t36 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X265 VSSD.t272 a_69966_n314.t5 a_70950_n314.t3 VSSD.t271 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X266 a_10678_n18422.t1 Reset.t28 a_10678_n17162# VDDD.t416 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X267 VSSD.t85 a_100722_n4054.t3 a_100722_n3300.t1 VSSD.t84 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X268 VDDD.t418 Reset.t29 a_105702_n13054# VDDD.t417 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X269 SAR_Asynchronous_Logic_2/D_reset_FF_0.nQ SAR_Asynchronous_Logic_2/D_reset_FF_0.Q.t5 VDDD.t280 VDDD.t279 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X270 a_132722_n82.t1 a_131902_n82.t4 VDDD.t339 VDDD.t338 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X271 a_134822_n18190.t0 a_134002_n18190.t4 VSSD.t233 VSSD.t232 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X272 a_132790_n4422.t4 Set.t24 VSSD.t127 VSSD.t126 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X273 VSSD.t508 a_8066_n18422.t5 a_9050_n18422.t2 VSSD.t507 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X274 a_142134_n18422.t1 a_134822_n18190.t3 a_137050_n18422.t3 VSSD.t248 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X275 a_82854_1076.t1 a_67002_n80.t3 VDDD.t373 VDDD.t372 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=1.1u
X276 a_6890_n14314.t4 Set.t25 VSSD.t129 VSSD.t128 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X277 a_5966_n314.t2 a_4722_n82.t4 a_8578_n314.t1 VSSD.t246 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X278 VSSD.t131 Set.t26 a_14798_n314.t4 VSSD.t130 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X279 a_106818_n4422.t0 a_100722_n4054.t4 a_106632_n3162.t3 VDDD.t96 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X280 VDDD.t420 Reset.t30 a_73702_n13054# VDDD.t419 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X281 a_46798_946# SAR_Asynchronous_Logic_1/D_reset_FF_1.Q.t10 VDDD.t128 VDDD.t127 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X282 VDDD.t66 SAR_Asynchronous_Logic_3/D_reset_FF_0.Q.t5 SAR_Asynchronous_Logic_3/D_reset_FF_0.nQ VDDD.t65 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X283 VSSD.t522 clks.t9 a_100722_n4054.t1 VSSD.t521 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X284 VSSD.t113 a_32736_n13850.t4 a_33966_n18540# VSSD.t112 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=1.1u
X285 a_102950_n314.t3 a_101966_n314.t5 a_102950_946# VDDD.t491 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X286 a_1966_n18540# a_736_n13850.t2 SAR_Asynchronous_Logic_4/D_reset_FF_1.Q.t3 VDDD.t126 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X287 a_130012_n13060.t0 a_128736_n13850.t3 SAR_Asynchronous_Logic_10/D_reset_FF_1.Q.t2 VDDD.t540 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X288 a_n19966_n314# a_n27278_n82.t2 a_n25050_n314.t2 VSSD.t330 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X289 VSSD.t77 a_4722_n4054.t3 a_4722_n3300.t0 VSSD.t76 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X290 a_42818_n4422.t3 a_36722_n4054.t4 a_42632_n3162.t0 VDDD.t380 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X291 a_143258_n17162# Reset.t31 VDDD.t422 VDDD.t421 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X292 a_78798_n314.t3 Set.t27 a_78798_946# VDDD.t139 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X293 a_36790_n4422.t3 Set.t28 VSSD.t133 VSSD.t132 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X294 a_44034_n314# a_36722_n82.t3 a_46798_n314.t4 VDDD.t562 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X295 VDDD.t369 a_73342_n4422.t5 a_76182_n3162# VDDD.t368 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X296 a_107442_n14314.t0 a_102822_n13946.t5 a_102704_n13054# VDDD.t188 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X297 a_102950_946# Set.t29 VDDD.t141 VDDD.t140 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X298 VSSD.t524 clks.t10 a_4722_n4054.t1 VSSD.t523 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X299 VSSD.t590 a_n19966_n314# SAR_Asynchronous_Logic_0/D_reset_FF_1.Q.t6 VSSD.t589 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X300 a_13810_n3162# a_10632_n3162.t4 a_9342_n4422.t1 VDDD.t289 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X301 SAR_Asynchronous_Logic_3/D_reset_FF_0.Q.t2 a_4604_n3162.t5 VSSD.t581 VSSD.t580 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X302 a_9050_n18422.t4 Set.t30 VSSD.t308 VSSD.t307 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X303 VDDD.t121 a_32736_n13096.t3 a_34012_n13060.t2 VDDD.t120 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=1.1u
X304 SAR_Asynchronous_Logic_8/D_reset_FF_0.Q.t2 a_110134_n18422.t4 a_111258_n17162# VDDD.t375 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X305 VSSD.t351 a_134822_n13946.t2 a_134822_n13192.t1 VSSD.t350 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X306 a_75442_n14314.t3 a_70822_n13946.t5 a_70704_n13054# VDDD.t204 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X307 a_98110_n80.t1 CK_7.t1 VSSD.t445 VSSD.t444 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X308 a_104578_n314.t2 a_102950_n314.t6 VSSD.t55 VSSD.t54 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X309 a_108918_n14314.t3 Reset.t32 VSSD.t451 VSSD.t450 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X310 a_105342_n4422.t1 a_100722_n3300.t2 a_100604_n3162.t2 VSSD.t378 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X311 a_142798_n314.t0 SAR_Asynchronous_Logic_6/D_reset_FF_1.Q.t11 VSSD.t149 VSSD.t148 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X312 a_9342_n4422.t2 a_4722_n4054.t4 a_4604_n3162.t1 VDDD.t87 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X313 a_41342_n4422.t1 a_36722_n3300.t4 a_36604_n3162.t3 VSSD.t421 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X314 a_70002_n18190.t1 clks.t11 VSSD.t526 VSSD.t525 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X315 VSSD.t251 SAR_Asynchronous_Logic_6/D_reset_FF_0.Q.t4 a_132790_n4422.t0 VSSD.t250 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X316 VSSD.t468 a_n22658_n4422.t6 a_n21182_n4422.t3 VSSD.t467 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X317 a_44034_n314# a_36722_n82.t4 a_38950_n314.t4 VSSD.t583 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X318 VDDD.t415 Set.t31 a_109810_n3162# VDDD.t414 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X319 VSSD.t207 SAR_Asynchronous_Logic_5/D_reset_FF_0.Q.t6 a_68790_n4422.t0 VSSD.t206 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X320 a_n19966_n314# a_n28098_n82.t3 a_n25050_n314.t3 VDDD.t310 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X321 a_45158_946# Reset.t33 VDDD.t424 VDDD.t423 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X322 SAR_Asynchronous_Logic_3/D_reset_FF_1.Q.t3 a_3002_n80.t3 a_18854_1076.t1 VSSD.t290 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X323 VSSD.t476 SAR_Asynchronous_Logic_1/D_reset_FF_0.Q.t4 a_36790_n4422.t2 VSSD.t475 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X324 a_134002_n18190.t0 clks.t12 VDDD.t476 VDDD.t475 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X325 a_106678_n18422.t3 a_105050_n18422.t6 VSSD.t492 VSSD.t491 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X326 a_12034_n314# a_3902_n82.t3 a_14798_n314.t2 VSSD.t534 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X327 SAR_Asynchronous_Logic_2/D_reset_FF_0.Q.t0 Reset.t34 VSSD.t453 VSSD.t452 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X328 a_102890_n14314.t0 a_102822_n13946.t6 a_102704_n13054# VSSD.t191 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X329 a_131002_n80.t0 a_130110_n80.t3 VDDD.t355 VDDD.t354 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X330 a_132790_n4422.t1 a_132722_n4054.t3 a_132604_n3162.t0 VSSD.t279 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X331 a_8066_n18422.t3 a_6822_n18190.t3 a_10678_n18422.t3 VSSD.t582 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X332 VDDD.t16 a_96736_n13850.t4 a_96736_n13096.t1 VDDD.t15 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X333 VDDD.t522 Set.t32 a_13810_n3162# VDDD.t521 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X334 a_111910_n13054# a_108732_n13054.t4 a_107442_n14314.t3 VDDD.t534 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X335 SAR_Asynchronous_Logic_0/D_reset_FF_1.Q.t7 a_n19966_n314# a_n18842_946# VDDD.t532 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X336 VSSD.t455 Reset.t35 a_104578_n314.t3 VSSD.t454 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X337 VSSD.t457 Reset.t36 SAR_Asynchronous_Logic_3/D_reset_FF_0.Q.t0 VSSD.t456 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X338 a_74678_n18422.t3 a_73050_n18422.t6 VSSD.t474 VSSD.t473 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X339 a_70890_n14314.t2 a_70822_n13946.t6 a_70704_n13054# VSSD.t211 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X340 SAR_Asynchronous_Logic_3/D_reset_FF_1.Q.t7 a_2110_n80.t5 a_19052_n4460# VDDD.t459 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X341 SAR_Asynchronous_Logic_1/D_reset_FF_1.Q.t6 a_44034_n314# a_45158_946# VDDD.t454 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X342 a_40066_n18422.t2 a_38002_n18190.t4 SAR_Asynchronous_Logic_2/D_reset_FF_1.Q.t7 VSSD.t314 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X343 VDDD.t436 a_64736_n13850.t5 a_64736_n13096.t1 VDDD.t435 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X344 a_72578_n314.t0 a_70950_n314.t6 VSSD.t97 VSSD.t96 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X345 VSSD.t50 Set.t33 a_142798_n314.t3 VSSD.t49 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X346 a_36790_n4422.t0 a_36722_n4054.t5 a_36604_n3162.t0 VSSD.t401 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X347 VSSD.t367 a_14134_n18422.t5 SAR_Asynchronous_Logic_4/D_reset_FF_0.Q.t2 VSSD.t366 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X348 a_n27278_n82.t0 a_n28098_n82.t4 VDDD.t312 VDDD.t311 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X349 a_74818_n4422.t1 Reset.t37 VSSD.t653 VSSD.t652 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X350 a_142282_n13054# Reset.t38 a_140918_n14314.t1 VDDD.t573 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X351 a_n18842_946# Reset.t39 VDDD.t575 VDDD.t574 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X352 SAR_Asynchronous_Logic_3/D_reset_FF_1.nQ SAR_Asynchronous_Logic_3/D_reset_FF_1.Q.t12 VSSD.t215 VSSD.t214 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X353 VDDD.t577 Reset.t40 a_n24398_n3162# VDDD.t576 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X354 VSSD.t416 SAR_Asynchronous_Logic_8/D_reset_FF_1.Q.t10 a_102890_n14314.t1 VSSD.t415 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X355 SAR_Asynchronous_Logic_0/D_reset_FF_1.nQ SAR_Asynchronous_Logic_0/D_reset_FF_1.Q.t9 VDDD.t26 VDDD.t25 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X356 SAR_Asynchronous_Logic_4/D_reset_FF_0.nQ SAR_Asynchronous_Logic_4/D_reset_FF_0.Q.t4 VDDD.t118 VDDD.t117 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X357 VSSD.t187 a_75442_n14314.t6 a_76918_n14314.t3 VSSD.t186 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X358 a_65966_n18540# a_64736_n13096.t4 SAR_Asynchronous_Logic_7/D_reset_FF_1.Q.t0 VSSD.t268 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X359 VSSD.t392 CK_4.t0 a_96736_n13850.t1 VSSD.t391 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X360 a_136578_946# a_134950_n314.t6 VDDD.t351 VDDD.t350 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X361 a_135602_n3162# a_132604_n3162.t4 SAR_Asynchronous_Logic_6/D_reset_FF_0.Q.t2 VDDD.t296 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X362 D_C_5.t1 a_134822_n13946.t3 a_140732_n13054.t3 VSSD.t352 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X363 VSSD.t42 SAR_Asynchronous_Logic_7/D_reset_FF_1.Q.t11 a_70890_n14314.t0 VSSD.t41 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X364 VSSD.t655 Reset.t41 a_138678_n18422.t2 VSSD.t654 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X365 SAR_Asynchronous_Logic_1/D_reset_FF_1.nQ SAR_Asynchronous_Logic_1/D_reset_FF_1.Q.t11 VDDD.t130 VDDD.t129 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X366 a_78134_n18422.t3 a_70822_n18190.t2 a_73050_n18422.t3 VSSD.t420 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X367 a_34012_n13060.t1 a_32736_n13096.t4 SAR_Asynchronous_Logic_2/D_reset_FF_1.Q.t6 VSSD.t111 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X368 a_71602_n3162# a_68604_n3162.t4 SAR_Asynchronous_Logic_5/D_reset_FF_0.Q.t1 VDDD.t303 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X369 VSSD.t349 CK_3.t0 a_64736_n13850.t0 VSSD.t348 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X370 Bit_5.t3 a_146854_1076.t3 VDDD.t278 VDDD.t277 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=1.1u
X371 a_36722_n82.t0 a_35902_n82.t3 VDDD.t86 VDDD.t85 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X372 a_39602_n3162# a_36604_n3162.t4 SAR_Asynchronous_Logic_1/D_reset_FF_0.Q.t0 VDDD.t155 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X373 VDDD.t443 a_128736_n13096.t5 a_134822_n13946.t0 VDDD.t442 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X374 a_66012_n13060.t2 a_64736_n13850.t6 SAR_Asynchronous_Logic_7/D_reset_FF_1.Q.t3 VDDD.t256 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X375 a_8578_n314.t3 Reset.t42 a_8578_946# VDDD.t578 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X376 VSSD.t539 a_9342_n4422.t6 a_10818_n4422.t3 VSSD.t538 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X377 a_138678_n17162# a_137050_n18422.t5 VDDD.t84 VDDD.t83 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X378 a_134890_n14314.t4 a_134822_n13192.t3 a_134704_n13054# VDDD.t560 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X379 VDDD.t98 a_100722_n4054.t5 a_100722_n3300.t0 VDDD.t97 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X380 a_n22658_n4422.t4 a_n27278_n3300.t3 a_n27396_n3162.t2 VSSD.t575 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X381 a_79258_n17162# Reset.t43 VDDD.t580 VDDD.t579 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X382 SAR_Asynchronous_Logic_6/D_reset_FF_1.Q.t3 a_132722_n4054.t4 a_138632_n3162.t0 VSSD.t280 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X383 a_133966_n314.t2 a_131902_n82.t5 a_136578_n314.t2 VDDD.t340 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X384 a_134822_n18190.t1 a_134002_n18190.t5 VDDD.t227 VDDD.t226 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X385 a_40066_n18422.t3 a_38002_n18190.t5 a_42678_n18422.t3 VDDD.t302 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X386 VSSD.t657 Reset.t44 a_72578_n314.t1 VSSD.t656 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X387 Bit_1.t2 a_33966_n18540# VSSD.t289 VSSD.t288 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=1.1u
X388 a_104066_n18422.t0 a_102822_n18190.t3 SAR_Asynchronous_Logic_8/D_reset_FF_1.Q.t2 VDDD.t485 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X389 a_11442_n14314.t1 a_12732_n13054.t5 VSSD.t69 VSSD.t68 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X390 VDDD.t478 clks.t13 a_100722_n4054.t0 VDDD.t477 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X391 SAR_Asynchronous_Logic_8/D_reset_FF_0.nQ SAR_Asynchronous_Logic_8/D_reset_FF_0.Q.t3 VSSD.t629 VSSD.t628 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X392 a_n19966_n314# a_n27278_n82.t3 a_n17202_n314.t1 VDDD.t213 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X393 a_101966_n314.t1 a_99902_n82.t6 D_C_7.t0 VSSD.t53 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X394 VDDD.t89 a_4722_n4054.t5 a_4722_n3300.t1 VDDD.t88 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X395 a_72066_n18422.t2 a_70822_n18190.t3 SAR_Asynchronous_Logic_7/D_reset_FF_1.Q.t8 VDDD.t394 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X396 a_n24398_n3162# a_n27396_n3162.t4 SAR_Asynchronous_Logic_0/D_reset_FF_0.Q.t0 VDDD.t17 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X397 SAR_Asynchronous_Logic_1/D_reset_FF_1.Q.t3 a_36722_n4054.t6 a_42632_n3162.t1 VSSD.t402 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X398 SAR_Asynchronous_Logic_2/D_reset_FF_0.Q.t1 a_46134_n18422.t4 a_47258_n17162# VDDD.t293 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X399 SAR_Asynchronous_Logic_8/D_reset_FF_1.Q.t3 a_102704_n13054# VSSD.t81 VSSD.t80 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X400 SAR_Asynchronous_Logic_6/D_reset_FF_1.Q.t4 a_130110_n80.t4 a_146854_1076.t2 VDDD.t356 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X401 SAR_Asynchronous_Logic_9/D_reset_FF_1.Q.t5 Reset.t45 VSSD.t659 VSSD.t658 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X402 VSSD.t316 SAR_Asynchronous_Logic_0/D_reset_FF_0.Q.t4 SAR_Asynchronous_Logic_0/D_reset_FF_0.nQ VSSD.t315 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X403 a_44918_n14314.t1 Reset.t46 VSSD.t681 VSSD.t680 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X404 a_130110_n80.t1 CK_6.t0 VDDD.t363 VDDD.t362 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X405 a_131902_n82.t0 a_131002_n80.t4 VDDD.t276 VDDD.t275 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X406 VSSD.t396 a_40066_n18422.t5 a_41050_n18422.t2 VSSD.t395 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X407 SAR_Asynchronous_Logic_7/D_reset_FF_0.nQ SAR_Asynchronous_Logic_7/D_reset_FF_0.Q.t3 VSSD.t197 VSSD.t196 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X408 a_140034_n314# a_131902_n82.t6 a_142798_n314.t2 VSSD.t339 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X409 a_77810_n3162# a_74632_n3162.t4 a_73342_n4422.t0 VDDD.t358 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X410 a_38890_n14314.t4 Set.t34 VSSD.t228 VSSD.t227 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X411 a_n17202_946# SAR_Asynchronous_Logic_0/D_reset_FF_1.Q.t10 VDDD.t28 VDDD.t27 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X412 a_n29890_n80.t1 CK_11.t1 VSSD.t360 VSSD.t359 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X413 VDDD.t600 Reset.t47 a_135602_n3162# VDDD.t599 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X414 VDDD.t247 SAR_Asynchronous_Logic_10/D_reset_FF_1.Q.t9 a_136062_n13054# VDDD.t246 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X415 a_n23422_n314.t2 Reset.t48 a_n23422_946# VDDD.t601 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X416 a_n28098_n82.t1 a_n28998_n80.t5 VSSD.t484 VSSD.t483 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X417 VSSD.t498 a_44034_n314# SAR_Asynchronous_Logic_1/D_reset_FF_1.Q.t5 VSSD.t497 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X418 VDDD.t464 clks.t14 a_4722_n4054.t0 VDDD.t463 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X419 SAR_Asynchronous_Logic_7/D_reset_FF_1.Q.t7 a_70704_n13054# VSSD.t504 VSSD.t503 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X420 a_140918_n14314.t3 a_134822_n13946.t4 a_140732_n13054.t2 VDDD.t329 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X421 VDDD.t58 Set.t35 a_111910_n13054# VDDD.t57 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X422 a_46134_n18422.t0 a_38822_n18190.t4 a_48898_n18422.t4 VDDD.t582 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X423 VDDD.t556 a_34012_n13060.t3 Bit_1.t3 VDDD.t555 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=1.1u
X424 a_112898_n18422.t2 Set.t36 a_112898_n17162# VDDD.t56 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X425 a_97966_n18540# a_96736_n13850.t5 SAR_Asynchronous_Logic_8/D_reset_FF_1.Q.t0 VDDD.t21 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X426 VDDD.t603 Reset.t49 a_71602_n3162# VDDD.t602 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X427 VDDD.t331 a_134822_n13946.t5 a_134822_n13192.t0 VDDD.t330 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X428 VDDD.t143 Set.t37 a_79910_n13054# VDDD.t142 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X429 a_80898_n18422.t4 Set.t38 a_80898_n17162# VDDD.t218 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X430 VSSD.t418 SAR_Asynchronous_Logic_8/D_reset_FF_1.Q.t11 SAR_Asynchronous_Logic_8/D_reset_FF_1.nQ VSSD.t417 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X431 Bit_4.t3 a_128736_n13850.t4 VCM.t2 VSSD.t584 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X432 VSSD.t253 SAR_Asynchronous_Logic_6/D_reset_FF_0.Q.t5 SAR_Asynchronous_Logic_6/D_reset_FF_0.nQ VSSD.t252 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X433 a_41050_n18422.t4 Set.t39 VSSD.t224 VSSD.t223 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X434 a_70002_n18190.t0 clks.t15 VDDD.t466 VDDD.t465 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X435 a_6002_n18190.t1 clks.t16 VSSD.t510 VSSD.t509 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X436 VSSD.t586 a_128736_n13850.t5 a_129966_n18540# VSSD.t585 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=1.1u
X437 a_38890_n14314.t1 a_38822_n13946.t5 a_38704_n13054# VSSD.t57 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X438 VSSD.t101 a_115052_n4460# Bit_6.t2 VSSD.t100 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=1.1u
X439 Bit_3.t0 a_96736_n13850.t6 VCM.t0 VSSD.t15 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X440 a_101962_n3162# Set.t40 a_100790_n4422.t3 VDDD.t398 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X441 a_47910_n13054# a_44732_n13054.t4 a_43442_n14314.t2 VDDD.t561 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X442 a_12034_n314# a_3902_n82.t4 a_6950_n314.t3 VDDD.t486 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X443 a_35002_n80.t0 a_34110_n80.t4 VDDD.t192 VDDD.t191 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X444 VSSD.t465 a_51052_n4460# Bit_8.t3 VSSD.t464 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=1.1u
X445 a_133966_n314.t3 a_132722_n82.t3 a_136578_n314.t3 VSSD.t480 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X446 VSSD.t201 SAR_Asynchronous_Logic_1/D_reset_FF_0.Q.t5 SAR_Asynchronous_Logic_1/D_reset_FF_0.nQ VSSD.t200 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X447 SAR_Asynchronous_Logic_5/D_reset_FF_1.Q.t4 Reset.t50 VSSD.t683 VSSD.t682 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X448 a_105050_n18422.t2 a_104066_n18422.t4 a_105050_n17162# VDDD.t341 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X449 SAR_Asynchronous_Logic_6/D_reset_FF_1.Q.t5 a_130110_n80.t5 a_147052_n4460# VDDD.t357 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X450 a_104062_n13054# Set.t41 a_102890_n14314.t4 VDDD.t59 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X451 VDDD.t222 Set.t42 a_77810_n3162# VDDD.t221 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X452 a_137702_n13054# a_134704_n13054# SAR_Asynchronous_Logic_10/D_reset_FF_1.Q.t4 VDDD.t105 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X453 SAR_Asynchronous_Logic_6/D_reset_FF_1.nQ SAR_Asynchronous_Logic_6/D_reset_FF_1.Q.t12 VSSD.t151 VSSD.t150 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X454 VDDD.t445 a_128736_n13096.t6 a_130012_n13060.t1 VDDD.t444 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=1.1u
X455 a_78282_n13054# Reset.t51 a_76918_n14314.t1 VDDD.t604 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X456 SAR_Asynchronous_Logic_5/D_reset_FF_1.Q.t1 a_66110_n80.t3 a_83052_n4460# VDDD.t53 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X457 a_73050_n18422.t1 a_72066_n18422.t4 a_73050_n17162# VDDD.t359 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X458 a_44918_n14314.t3 a_38822_n13192.t5 a_44732_n13054.t2 VSSD.t463 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X459 VSSD.t48 Set.t43 a_11442_n14314.t4 VSSD.t47 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X460 a_72062_n13054# Set.t44 a_70890_n14314.t4 VDDD.t297 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X461 a_132722_n82.t0 a_131902_n82.t7 VSSD.t341 VSSD.t340 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X462 a_n21182_n4422.t1 Reset.t52 VSSD.t685 VSSD.t684 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X463 VSSD.t222 Set.t45 a_16898_n18422.t2 VSSD.t221 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X464 VSSD.t687 Reset.t53 a_10678_n18422.t0 VSSD.t686 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X465 VSSD.t689 Reset.t54 SAR_Asynchronous_Logic_8/D_reset_FF_1.Q.t5 VSSD.t688 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X466 VCM.t19 a_99002_n80.t6 Bit_6.t3 VDDD.t82 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X467 a_105050_n17162# Set.t46 VDDD.t569 VDDD.t568 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X468 VSSD.t135 a_128736_n13850.t6 a_128736_n13096.t1 VSSD.t134 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X469 a_n28998_n80.t1 a_n29890_n80.t5 VSSD.t644 VSSD.t643 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X470 a_106818_n4422.t2 a_100722_n3300.t3 a_106632_n3162.t1 VSSD.t379 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X471 a_16898_n17162# SAR_Asynchronous_Logic_4/D_reset_FF_0.Q.t5 VDDD.t295 VDDD.t294 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X472 VSSD.t671 Reset.t55 SAR_Asynchronous_Logic_7/D_reset_FF_1.Q.t2 VSSD.t670 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X473 a_73050_n17162# Set.t47 VDDD.t397 VDDD.t396 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X474 a_10678_n17162# a_9050_n18422.t5 VDDD.t558 VDDD.t557 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X475 VDDD.t314 CK_4.t1 a_96736_n13850.t0 VDDD.t313 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X476 a_78798_946# SAR_Asynchronous_Logic_5/D_reset_FF_1.Q.t11 VDDD.t265 VDDD.t264 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X477 VDDD.t41 SAR_Asynchronous_Logic_9/D_reset_FF_0.Q.t3 a_101962_n3162# VDDD.t40 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X478 a_1966_n18540# a_736_n13096.t3 SAR_Asynchronous_Logic_4/D_reset_FF_1.Q.t6 VSSD.t323 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X479 a_4722_n82.t1 a_3902_n82.t5 VDDD.t488 VDDD.t487 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X480 a_50854_1076.t1 a_35002_n80.t4 VDDD.t584 VDDD.t583 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=1.1u
X481 a_134950_n314.t1 a_133966_n314.t5 a_134950_946# VDDD.t109 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X482 a_42818_n4422.t2 a_36722_n3300.t5 a_42632_n3162.t2 VSSD.t361 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X483 SAR_Asynchronous_Logic_10/D_reset_FF_0.Q.t0 Reset.t56 VSSD.t673 VSSD.t672 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X484 a_6822_n18190.t0 a_6002_n18190.t4 VSSD.t299 VSSD.t298 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X485 VDDD.t361 CK_3.t1 a_64736_n13850.t1 VDDD.t360 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X486 VSSD.t358 a_73342_n4422.t6 a_74818_n4422.t4 VSSD.t357 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X487 a_107442_n14314.t1 a_102822_n13192.t3 a_102704_n13054# VSSD.t28 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X488 a_134950_946# Set.t48 VDDD.t217 VDDD.t216 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X489 a_9342_n4422.t0 a_10632_n3162.t5 VSSD.t297 VSSD.t296 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X490 Bit_0.t1 a_736_n13850.t3 VCM.t11 VSSD.t119 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X491 SAR_Asynchronous_Logic_6/D_reset_FF_1.Q.t1 a_131002_n80.t5 a_146854_1076.t1 VSSD.t282 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X492 a_108918_n14314.t0 a_102822_n13946.t7 a_108732_n13054.t0 VDDD.t189 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X493 a_2012_n13060.t2 a_736_n13850.t4 SAR_Asynchronous_Logic_4/D_reset_FF_1.Q.t4 VDDD.t166 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X494 a_100790_n4422.t0 a_100722_n3300.t4 a_100604_n3162.t3 VDDD.t352 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X495 a_14134_n18422.t1 a_6822_n18190.t4 a_16898_n18422.t1 VDDD.t206 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X496 VSSD.t398 a_110134_n18422.t5 SAR_Asynchronous_Logic_8/D_reset_FF_0.Q.t1 VSSD.t397 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X497 a_75442_n14314.t0 a_70822_n13192.t3 a_70704_n13054# VSSD.t8 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X498 VDDD.t343 a_11442_n14314.t5 a_14282_n13054# VDDD.t342 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X499 a_140182_n3162# Reset.t57 a_138818_n4422.t0 VDDD.t590 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X500 a_76918_n14314.t4 a_70822_n13946.t7 a_76732_n13054.t2 VDDD.t205 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X501 VDDD.t567 Set.t49 a_47910_n13054# VDDD.t566 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X502 a_34110_n80.t0 CK_9.t0 VDDD.t236 VDDD.t235 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X503 a_35902_n82.t0 a_35002_n80.t5 VDDD.t586 VDDD.t585 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X504 a_108182_n3162# Reset.t58 a_106818_n4422.t4 VDDD.t591 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X505 SAR_Asynchronous_Logic_8/D_reset_FF_0.nQ SAR_Asynchronous_Logic_8/D_reset_FF_0.Q.t4 VDDD.t552 VDDD.t551 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X506 a_48898_n18422.t2 Set.t50 a_48898_n17162# VDDD.t395 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X507 a_14134_n18422.t3 a_6002_n18190.t5 a_9050_n18422.t0 VDDD.t290 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X508 a_9342_n4422.t3 a_4722_n3300.t3 a_4604_n3162.t3 VSSD.t400 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X509 VCM.t16 a_67002_n80.t4 Bit_7.t2 VDDD.t64 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X510 VDDD.t2 SAR_Asynchronous_Logic_0/D_reset_FF_0.Q.t5 SAR_Asynchronous_Logic_0/D_reset_FF_0.nQ VDDD.t1 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X511 a_42678_n18422.t0 Reset.t59 a_42678_n17162# VDDD.t592 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X512 a_44182_n3162# Reset.t60 a_42818_n4422.t0 VDDD.t593 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X513 a_110798_n314.t1 SAR_Asynchronous_Logic_9/D_reset_FF_1.Q.t11 VSSD.t502 VSSD.t501 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X514 SAR_Asynchronous_Logic_7/D_reset_FF_0.nQ SAR_Asynchronous_Logic_7/D_reset_FF_0.Q.t4 VDDD.t201 VDDD.t200 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X515 VDDD.t595 Reset.t61 a_137702_n13054# VDDD.t594 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X516 VSSD.t65 SAR_Asynchronous_Logic_2/D_reset_FF_1.Q.t10 SAR_Asynchronous_Logic_2/D_reset_FF_1.nQ VSSD.t64 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X517 a_130012_n13060.t2 a_128736_n13096.t7 SAR_Asynchronous_Logic_10/D_reset_FF_1.Q.t8 VSSD.t486 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X518 a_101966_n314.t3 a_100722_n82.t3 D_C_7.t1 VDDD.t381 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X519 a_38950_n314.t3 Set.t51 VSSD.t220 VSSD.t219 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X520 VSSD.t470 Set.t52 a_105342_n4422.t4 VSSD.t469 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X521 VSSD.t262 a_64736_n13850.t7 a_65966_n18540# VSSD.t261 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=1.1u
X522 Bit_1.t1 a_32736_n13096.t5 VCM.t9 VDDD.t114 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X523 a_77158_946# Reset.t62 VDDD.t597 VDDD.t596 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X524 a_12034_n314# a_4722_n82.t5 a_6950_n314.t0 VSSD.t247 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X525 a_69966_n314.t3 a_67902_n82.t4 D_C_8.t1 VSSD.t543 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X526 a_136066_n18422.t1 a_134002_n18190.t6 a_138678_n18422.t4 VDDD.t228 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X527 VDDD.t389 SAR_Asynchronous_Logic_8/D_reset_FF_1.Q.t12 SAR_Asynchronous_Logic_8/D_reset_FF_1.nQ VDDD.t388 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X528 VSSD.t257 Set.t53 a_9342_n4422.t4 VSSD.t256 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X529 a_107442_n14314.t4 a_108732_n13054.t5 VSSD.t594 VSSD.t593 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X530 a_n27278_n82.t1 a_n28098_n82.t5 VSSD.t335 VSSD.t334 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X531 a_n26034_n314.t0 a_n27278_n82.t4 a_n23422_n314.t3 VSSD.t218 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X532 a_139442_n14314.t2 a_134822_n13946.t6 a_134704_n13054# VDDD.t332 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X533 VDDD.t250 SAR_Asynchronous_Logic_6/D_reset_FF_0.Q.t6 SAR_Asynchronous_Logic_6/D_reset_FF_0.nQ VDDD.t249 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X534 SAR_Asynchronous_Logic_3/D_reset_FF_1.Q.t4 a_3002_n80.t4 a_19052_n4460# VSSD.t291 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X535 a_3002_n80.t0 a_2110_n80.t6 VDDD.t328 VDDD.t327 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X536 SAR_Asynchronous_Logic_0/D_reset_FF_1.nQ SAR_Asynchronous_Logic_0/D_reset_FF_1.Q.t11 VSSD.t21 VSSD.t20 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X537 a_6002_n18190.t0 clks.t17 VDDD.t468 VDDD.t467 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X538 SAR_Asynchronous_Logic_9/D_reset_FF_1.Q.t6 a_100722_n3300.t5 a_106632_n3162.t0 VDDD.t326 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X539 SAR_Asynchronous_Logic_5/D_reset_FF_1.Q.t3 a_76034_n314# a_77158_946# VDDD.t100 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X540 VDDD.t449 a_64736_n13096.t5 a_66012_n13060.t1 VDDD.t448 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=1.1u
X541 SAR_Asynchronous_Logic_10/D_reset_FF_0.Q.t1 a_142134_n18422.t4 a_143258_n17162# VDDD.t563 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X542 VSSD.t270 SAR_Asynchronous_Logic_9/D_reset_FF_0.Q.t4 SAR_Asynchronous_Logic_9/D_reset_FF_0.nQ VSSD.t269 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X543 a_140918_n14314.t2 Reset.t63 VSSD.t675 VSSD.t674 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X544 a_40578_n314.t3 a_38950_n314.t5 VSSD.t377 VSSD.t376 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X545 VSSD.t596 Reset.t64 SAR_Asynchronous_Logic_0/D_reset_FF_0.Q.t2 VSSD.t595 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X546 SAR_Asynchronous_Logic_1/D_reset_FF_1.nQ SAR_Asynchronous_Logic_1/D_reset_FF_1.Q.t12 VSSD.t121 VSSD.t120 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X547 VSSD.t203 Set.t54 a_110798_n314.t3 VSSD.t202 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X548 VDDD.t589 SAR_Asynchronous_Logic_1/D_reset_FF_0.Q.t6 SAR_Asynchronous_Logic_1/D_reset_FF_0.nQ VDDD.t588 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X549 a_40578_n314.t1 Reset.t65 a_40578_946# VDDD.t535 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X550 a_69962_n3162# Set.t55 a_68790_n4422.t4 VDDD.t185 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X551 VSSD.t159 a_n12948_n4460# Bit_10.t1 VSSD.t158 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=1.1u
X552 VDDD.t157 a_130012_n13060.t3 Bit_4.t1 VDDD.t156 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=1.1u
X553 a_131002_n80.t1 a_130110_n80.t6 VSSD.t386 VSSD.t385 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X554 SAR_Asynchronous_Logic_3/D_reset_FF_1.Q.t5 a_4722_n3300.t4 a_10632_n3162.t1 VDDD.t376 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X555 SAR_Asynchronous_Logic_6/D_reset_FF_0.Q.t0 a_132604_n3162.t5 VSSD.t79 VSSD.t78 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X556 a_36722_n82.t1 a_35902_n82.t4 VSSD.t259 VSSD.t258 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X557 VCM.t6 a_98110_n80.t5 Bit_6.t1 VSSD.t88 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X558 VSSD.t155 a_736_n13850.t5 a_736_n13096.t0 VSSD.t154 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X559 VSSD.t237 a_37966_n314.t4 a_38950_n314.t0 VSSD.t236 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X560 SAR_Asynchronous_Logic_5/D_reset_FF_0.Q.t2 a_68604_n3162.t5 VSSD.t322 VSSD.t321 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X561 a_5966_n314.t0 a_3902_n82.t6 a_8578_n314.t0 VDDD.t14 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X562 a_8578_946# a_6950_n314.t6 VDDD.t299 VDDD.t298 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X563 a_109158_946# Reset.t66 VDDD.t537 VDDD.t536 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X564 a_n19966_n314# a_n28098_n82.t6 a_n17202_n314.t2 VSSD.t332 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X565 SAR_Asynchronous_Logic_1/D_reset_FF_0.Q.t1 a_36604_n3162.t5 VSSD.t147 VSSD.t146 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X566 a_68722_n82.t0 a_67902_n82.t5 VDDD.t493 VDDD.t492 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X567 SAR_Asynchronous_Logic_0/D_reset_FF_1.Q.t4 a_n27278_n3300.t4 a_n21368_n3162.t3 VDDD.t515 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X568 a_137342_n4422.t0 a_132722_n4054.t5 a_132604_n3162.t1 VDDD.t268 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X569 a_138678_n18422.t0 a_137050_n18422.t6 VSSD.t71 VSSD.t70 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X570 Bit_6.t0 a_114854_1076.t3 VDDD.t104 VDDD.t103 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=1.1u
X571 SAR_Asynchronous_Logic_7/D_reset_FF_0.Q.t2 Reset.t67 VSSD.t598 VSSD.t597 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X572 a_134890_n14314.t1 a_134822_n13946.t7 a_134704_n13054# VSSD.t347 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X573 a_40066_n18422.t1 a_38822_n18190.t5 a_42678_n18422.t4 VSSD.t667 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X574 VDDD.t145 a_128736_n13850.t7 a_128736_n13096.t0 VDDD.t144 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X575 a_73342_n4422.t2 a_68722_n4054.t4 a_68604_n3162.t0 VDDD.t305 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X576 a_104066_n18422.t2 a_102002_n18190.t5 SAR_Asynchronous_Logic_8/D_reset_FF_1.Q.t8 VSSD.t622 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X577 a_143910_n13054# a_140732_n13054.t4 a_139442_n14314.t0 VDDD.t237 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X578 Bit_10.t3 a_n13146_1076.t3 VDDD.t550 VDDD.t549 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=1.1u
X579 a_38950_n314.t1 a_37966_n314.t5 a_38950_946# VDDD.t231 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X580 a_131902_n82.t1 a_131002_n80.t6 VSSD.t284 VSSD.t283 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X581 SAR_Asynchronous_Logic_9/D_reset_FF_1.Q.t1 a_108034_n314# a_109158_946# VDDD.t23 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X582 VSSD.t600 Reset.t68 a_40578_n314.t0 VSSD.t599 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X583 a_72066_n18422.t0 a_70002_n18190.t6 SAR_Asynchronous_Logic_7/D_reset_FF_1.Q.t4 VSSD.t27 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X584 SAR_Asynchronous_Logic_0/D_reset_FF_0.Q.t1 a_n27396_n3162.t5 VSSD.t533 VSSD.t532 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X585 VSSD.t302 a_46134_n18422.t5 SAR_Asynchronous_Logic_2/D_reset_FF_0.Q.t2 VSSD.t301 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X586 a_6890_n14314.t2 a_6822_n13192.t3 a_6704_n13054# VDDD.t177 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X587 a_38950_946# Set.t56 VDDD.t258 VDDD.t257 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X588 a_n17202_n314.t3 Set.t57 a_n17202_946# VDDD.t259 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X589 a_6822_n18190.t1 a_6002_n18190.t6 VDDD.t292 VDDD.t291 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X590 D_C_1.t1 a_6822_n13192.t4 a_12732_n13054.t1 VDDD.t178 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X591 a_73342_n4422.t1 a_74632_n3162.t5 VSSD.t390 VSSD.t389 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X592 VSSD.t164 SAR_Asynchronous_Logic_10/D_reset_FF_1.Q.t10 a_134890_n14314.t0 VSSD.t163 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X593 VSSD.t602 Reset.t69 SAR_Asynchronous_Logic_6/D_reset_FF_0.Q.t1 VSSD.t601 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X594 SAR_Asynchronous_Logic_9/D_reset_FF_1.Q.t4 a_98110_n80.t6 a_114854_1076.t0 VDDD.t77 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X595 a_140918_n14314.t4 a_134822_n13192.t4 a_140732_n13054.t0 VSSD.t634 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X596 VSSD.t646 Set.t58 a_107442_n14314.t2 VSSD.t645 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X597 VCM.t4 a_66110_n80.t4 Bit_7.t0 VSSD.t327 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X598 a_46134_n18422.t2 a_38002_n18190.t6 a_48898_n18422.t1 VSSD.t249 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X599 VSSD.t109 a_32736_n13096.t6 a_38822_n13946.t0 VSSD.t108 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X600 VSSD.t648 Set.t59 a_112898_n18422.t3 VSSD.t647 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X601 a_2110_n80.t0 CK_10.t0 VDDD.t233 VDDD.t232 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X602 a_3902_n82.t0 a_3002_n80.t5 VDDD.t284 VDDD.t283 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X603 a_97966_n18540# a_96736_n13096.t7 SAR_Asynchronous_Logic_8/D_reset_FF_1.Q.t7 VSSD.t441 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X604 VSSD.t153 CK_5.t0 a_128736_n13850.t0 VSSD.t152 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X605 a_110798_n314.t4 Set.t60 a_110798_946# VDDD.t496 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X606 a_108034_n314# a_99902_n82.t7 a_110798_n314.t0 VSSD.t311 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X607 VSSD.t19 a_12034_n314# SAR_Asynchronous_Logic_3/D_reset_FF_1.Q.t0 VSSD.t18 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X608 VSSD.t604 Reset.t70 SAR_Asynchronous_Logic_5/D_reset_FF_0.Q.t0 VSSD.t603 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X609 VDDD.t539 Reset.t71 a_9702_n13054# VDDD.t538 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X610 VSSD.t545 Set.t61 a_75442_n14314.t4 VSSD.t544 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X611 a_66012_n13060.t0 a_64736_n13096.t6 SAR_Asynchronous_Logic_7/D_reset_FF_1.Q.t1 VSSD.t490 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X612 VSSD.t547 Set.t62 a_80898_n18422.t3 VSSD.t546 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X613 a_68790_n4422.t2 a_68722_n3300.t3 a_68604_n3162.t3 VDDD.t411 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X614 VDDD.t182 SAR_Asynchronous_Logic_4/D_reset_FF_1.Q.t11 a_8062_n13054# VDDD.t181 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X615 a_112898_n17162# SAR_Asynchronous_Logic_8/D_reset_FF_0.Q.t5 VDDD.t554 VDDD.t553 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X616 a_104066_n18422.t3 a_102002_n18190.t6 a_106678_n18422.t4 VDDD.t547 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X617 Bit_7.t3 a_82854_1076.t3 VDDD.t347 VDDD.t346 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=1.1u
X618 a_n27210_n4422.t4 a_n27278_n3300.t5 a_n27396_n3162.t3 VDDD.t564 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X619 a_130110_n80.t0 CK_6.t1 VSSD.t365 VSSD.t364 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X620 a_98012_n13060.t0 a_96736_n13850.t7 SAR_Asynchronous_Logic_8/D_reset_FF_1.Q.t1 VDDD.t22 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X621 VSSD.t549 Set.t63 a_n17202_n314.t4 VSSD.t548 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X622 VDDD.t111 SAR_Asynchronous_Logic_2/D_reset_FF_1.Q.t11 SAR_Asynchronous_Logic_2/D_reset_FF_1.nQ VDDD.t110 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X623 a_100790_n4422.t4 Set.t64 VSSD.t551 VSSD.t550 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X624 Bit_2.t1 a_65966_n18540# VSSD.t83 VSSD.t82 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=1.1u
X625 a_80898_n17162# SAR_Asynchronous_Logic_7/D_reset_FF_0.Q.t5 VDDD.t317 VDDD.t316 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X626 a_72066_n18422.t1 a_70002_n18190.t7 a_74678_n18422.t2 VDDD.t35 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X627 a_43442_n14314.t1 a_44732_n13054.t5 VSSD.t637 VSSD.t636 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X628 a_136066_n18422.t3 a_134822_n18190.t4 SAR_Asynchronous_Logic_10/D_reset_FF_1.Q.t6 VDDD.t245 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X629 a_11442_n14314.t2 a_6822_n13946.t4 a_6704_n13054# VDDD.t5 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X630 VDDD.t253 a_137342_n4422.t5 a_140182_n3162# VDDD.t252 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X631 a_44034_n314# a_35902_n82.t5 a_38950_n314.t2 VDDD.t254 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X632 a_67002_n80.t0 a_66110_n80.t5 VDDD.t308 VDDD.t307 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X633 VSSD.t363 a_104066_n18422.t5 a_105050_n18422.t3 VSSD.t362 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X634 SAR_Asynchronous_Logic_10/D_reset_FF_0.nQ SAR_Asynchronous_Logic_10/D_reset_FF_0.Q.t5 VSSD.t3 VSSD.t2 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X635 VDDD.t4 SAR_Asynchronous_Logic_0/D_reset_FF_0.Q.t6 a_n26038_n3162# VDDD.t3 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X636 a_5962_n3162# Set.t65 a_4790_n4422.t4 VDDD.t497 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X637 VDDD.t349 a_105342_n4422.t6 a_108182_n3162# VDDD.t348 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X638 a_102890_n14314.t3 Set.t66 VSSD.t553 VSSD.t552 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X639 SAR_Asynchronous_Logic_6/D_reset_FF_1.Q.t0 a_131002_n80.t7 a_147052_n4460# VSSD.t285 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X640 VSSD.t157 a_736_n13850.t6 a_1966_n18540# VSSD.t156 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=1.1u
X641 VSSD.t59 a_38822_n13946.t6 a_38822_n13192.t0 VSSD.t58 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X642 a_10818_n4422.t4 a_4722_n4054.t6 a_10632_n3162.t2 VDDD.t572 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X643 VSSD.t555 Set.t67 a_73342_n4422.t4 VSSD.t554 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X644 SAR_Asynchronous_Logic_7/D_reset_FF_0.Q.t1 a_78134_n18422.t5 a_79258_n17162# VDDD.t108 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X645 SAR_Asynchronous_Logic_10/D_reset_FF_1.Q.t3 a_134704_n13054# VSSD.t99 VSSD.t98 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X646 a_110134_n18422.t2 a_102822_n18190.t4 a_112898_n18422.t1 VDDD.t447 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X647 a_76918_n14314.t2 Reset.t72 VSSD.t606 VSSD.t605 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X648 VDDD.t267 a_107442_n14314.t6 a_110282_n13054# VDDD.t266 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X649 a_101966_n314.t2 a_100722_n82.t4 a_104578_n314.t1 VSSD.t406 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X650 SAR_Asynchronous_Logic_5/D_reset_FF_1.Q.t5 a_66110_n80.t6 a_82854_1076.t0 VDDD.t309 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X651 SAR_Asynchronous_Logic_1/D_reset_FF_1.Q.t0 Reset.t73 VSSD.t608 VSSD.t607 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X652 VDDD.t517 a_41342_n4422.t6 a_44182_n3162# VDDD.t516 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X653 SAR_Asynchronous_Logic_5/D_reset_FF_1.Q.t6 a_67002_n80.t5 a_83052_n4460# VSSD.t409 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X654 VSSD.t394 a_72066_n18422.t5 a_73050_n18422.t2 VSSD.t393 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X655 a_70890_n14314.t3 Set.t68 VSSD.t557 VSSD.t556 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X656 a_78798_n314.t1 SAR_Asynchronous_Logic_5/D_reset_FF_1.Q.t12 VSSD.t625 VSSD.t624 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X657 a_76034_n314# a_67902_n82.t6 a_78798_n314.t2 VSSD.t542 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X658 VDDD.t499 Set.t69 a_143910_n13054# VDDD.t498 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X659 VDDD.t325 a_66012_n13060.t3 Bit_2.t3 VDDD.t324 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=1.1u
X660 a_110134_n18422.t1 a_102002_n18190.t7 a_105050_n18422.t1 VDDD.t548 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X661 a_78134_n18422.t2 a_70822_n18190.t4 a_80898_n18422.t1 VDDD.t99 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X662 a_144898_n18422.t3 Set.t70 a_144898_n17162# VDDD.t500 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X663 a_9702_n13054# a_6704_n13054# SAR_Asynchronous_Logic_4/D_reset_FF_1.Q.t1 VDDD.t48 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X664 VDDD.t321 a_736_n13096.t4 a_2012_n13060.t1 VDDD.t320 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=1.1u
X665 SAR_Asynchronous_Logic_0/D_reset_FF_1.Q.t8 a_n29890_n80.t6 a_n13146_1076.t2 VDDD.t565 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X666 a_35002_n80.t1 a_34110_n80.t5 VSSD.t195 VSSD.t194 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X667 VDDD.t224 SAR_Asynchronous_Logic_9/D_reset_FF_0.Q.t5 SAR_Asynchronous_Logic_9/D_reset_FF_0.nQ VDDD.t223 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X668 a_4722_n82.t0 a_3902_n82.t7 VSSD.t10 VSSD.t9 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X669 a_105050_n18422.t4 Set.t71 VSSD.t559 VSSD.t558 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X670 VSSD.t166 SAR_Asynchronous_Logic_10/D_reset_FF_1.Q.t11 SAR_Asynchronous_Logic_10/D_reset_FF_1.nQ VSSD.t165 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X671 SAR_Asynchronous_Logic_5/D_reset_FF_1.Q.t0 a_68722_n3300.t4 a_74632_n3162.t3 VDDD.t29 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X672 a_n17202_n314.t0 SAR_Asynchronous_Logic_0/D_reset_FF_1.Q.t12 VSSD.t46 VSSD.t45 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X673 a_16898_n18422.t0 SAR_Asynchronous_Logic_4/D_reset_FF_0.Q.t6 VSSD.t306 VSSD.t305 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X674 a_10678_n18422.t2 a_9050_n18422.t6 VSSD.t631 VSSD.t630 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X675 a_73050_n18422.t4 Set.t72 VSSD.t561 VSSD.t560 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X676 VSSD.t230 SAR_Asynchronous_Logic_9/D_reset_FF_0.Q.t6 a_100790_n4422.t1 VSSD.t229 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X677 VDDD.t239 a_736_n13850.t7 a_736_n13096.t1 VDDD.t238 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X678 a_147052_n4460# a_130110_n80.t7 VSSD.t388 VSSD.t387 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=1.1u
X679 a_79910_n13054# a_76732_n13054.t5 a_75442_n14314.t1 VDDD.t44 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X680 VDDD.t68 SAR_Asynchronous_Logic_3/D_reset_FF_0.Q.t6 a_5962_n3162# VDDD.t67 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X681 VSSD.t496 a_140034_n314# SAR_Asynchronous_Logic_6/D_reset_FF_1.Q.t8 VSSD.t495 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X682 a_n26038_n3162# Set.t73 a_n27210_n4422.t3 VDDD.t501 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X683 a_n26034_n314.t3 a_n27278_n82.t5 D_C_11.t0 VDDD.t345 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X684 a_83052_n4460# a_66110_n80.t7 VSSD.t329 VSSD.t328 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=1.1u
X685 a_6950_n314.t1 a_5966_n314.t4 a_6950_946# VDDD.t446 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X686 a_137050_n18422.t1 a_136066_n18422.t5 a_137050_n17162# VDDD.t383 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X687 a_35902_n82.t1 a_35002_n80.t6 VSSD.t669 VSSD.t668 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X688 a_69966_n314.t1 a_68722_n82.t4 a_72578_n314.t3 VSSD.t23 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X689 VSSD.t563 Set.t74 a_78798_n314.t4 VSSD.t562 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X690 a_108918_n14314.t1 a_102822_n13192.t4 a_108732_n13054.t2 VSSD.t29 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X691 a_136062_n13054# Set.t75 a_134890_n14314.t2 VDDD.t502 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X692 a_100790_n4422.t2 a_100722_n4054.t6 a_100604_n3162.t0 VSSD.t86 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X693 a_14134_n18422.t2 a_6002_n18190.t7 a_16898_n18422.t4 VSSD.t300 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X694 VSSD.t343 a_736_n13096.t5 a_6822_n13946.t0 VSSD.t342 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X695 VSSD.t383 a_11442_n14314.t6 a_12918_n14314.t3 VSSD.t382 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X696 a_140034_n314# a_132722_n82.t4 a_134950_n314.t3 VSSD.t481 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X697 a_138818_n4422.t1 Reset.t74 VSSD.t610 VSSD.t609 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X698 a_6950_946# Set.t76 VDDD.t504 VDDD.t503 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X699 SAR_Asynchronous_Logic_9/D_reset_FF_1.Q.t8 a_99002_n80.t7 a_114854_1076.t1 VSSD.t411 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X700 a_4790_n4422.t2 a_4722_n3300.t5 a_4604_n3162.t2 VDDD.t377 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X701 a_76918_n14314.t0 a_70822_n13192.t4 a_76732_n13054.t1 VSSD.t304 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X702 VSSD.t565 Set.t77 a_43442_n14314.t4 VSSD.t564 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X703 a_106818_n4422.t3 Reset.t75 VSSD.t612 VSSD.t611 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X704 a_67902_n82.t0 a_67002_n80.t6 VDDD.t385 VDDD.t384 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X705 a_14134_n18422.t0 a_6822_n18190.t5 a_9050_n18422.t3 VSSD.t623 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X706 VSSD.t567 Set.t78 a_48898_n18422.t3 VSSD.t566 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X707 VSSD.t118 CK_1.t0 a_736_n13850.t0 VSSD.t117 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X708 a_66110_n80.t0 CK_8.t1 VDDD.t20 VDDD.t19 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X709 VSSD.t614 Reset.t76 a_42678_n18422.t1 VSSD.t613 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X710 a_42818_n4422.t1 Reset.t77 VSSD.t616 VSSD.t615 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X711 VSSD.t618 Reset.t78 SAR_Asynchronous_Logic_10/D_reset_FF_1.Q.t5 VSSD.t617 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X712 a_137050_n17162# Set.t79 VDDD.t506 VDDD.t505 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X713 a_14798_n314.t3 Set.t80 a_14798_946# VDDD.t507 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X714 VCM.t21 a_35002_n80.t7 Bit_8.t0 VDDD.t587 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X715 a_15258_n17162# Reset.t79 VDDD.t542 VDDD.t541 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X716 a_48898_n17162# SAR_Asynchronous_Logic_2/D_reset_FF_0.Q.t6 VDDD.t282 VDDD.t281 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X717 VDDD.t116 a_32736_n13096.t7 a_38822_n13946.t1 VDDD.t115 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X718 a_133966_n314.t0 a_132722_n82.t5 D_C_6.t0 VDDD.t13 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X719 a_103602_n3162# a_100604_n3162.t5 SAR_Asynchronous_Logic_9/D_reset_FF_0.Q.t2 VDDD.t533 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X720 VDDD.t367 CK_5.t1 a_128736_n13850.t1 VDDD.t366 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X721 a_42678_n17162# a_41050_n18422.t6 VDDD.t220 VDDD.t219 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X722 a_34110_n80.t1 CK_9.t1 VSSD.t677 VSSD.t676 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X723 a_136066_n18422.t0 a_134822_n18190.t5 a_138678_n18422.t3 VSSD.t160 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X724 VSSD.t375 a_6822_n13946.t5 a_6822_n13192.t1 VSSD.t374 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X725 a_2012_n13060.t0 a_736_n13096.t6 SAR_Asynchronous_Logic_4/D_reset_FF_1.Q.t7 VSSD.t344 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X726 a_139442_n14314.t4 a_134822_n13192.t5 a_134704_n13054# VSSD.t635 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X727 VSSD.t278 a_132722_n4054.t6 a_132722_n3300.t1 VSSD.t277 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X728 a_37966_n314.t0 a_35902_n82.t6 D_C_9.t0 VSSD.t260 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X729 SAR_Asynchronous_Logic_9/D_reset_FF_1.Q.t2 a_100722_n4054.t7 a_106632_n3162.t2 VSSD.t87 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X730 SAR_Asynchronous_Logic_5/D_reset_FF_1.Q.t7 a_67002_n80.t7 a_82854_1076.t2 VSSD.t410 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X731 a_138818_n4422.t3 a_132722_n4054.t7 a_138632_n3162.t1 VDDD.t269 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X732 VSSD.t325 a_68722_n4054.t5 a_68722_n3300.t1 VSSD.t324 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X733 VSSD.t640 a_142134_n18422.t5 SAR_Asynchronous_Logic_10/D_reset_FF_0.Q.t2 VSSD.t639 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X734 a_33966_n18540# a_32736_n13850.t5 SAR_Asynchronous_Logic_2/D_reset_FF_1.Q.t0 VDDD.t122 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X735 VDDD.t413 a_43442_n14314.t6 a_46282_n13054# VDDD.t412 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X736 VSSD.t512 clks.t18 a_132722_n4054.t0 VSSD.t511 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X737 a_141810_n3162# a_138632_n3162.t5 a_137342_n4422.t3 VDDD.t234 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X738 Bit_0.t3 a_1966_n18540# VSSD.t443 VSSD.t442 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=1.1u
X739 D_C_4.t1 a_102822_n13192.t5 a_108732_n13054.t3 VDDD.t39 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X740 a_40578_946# a_38950_n314.t6 VDDD.t319 VDDD.t318 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X741 a_106678_n18422.t1 Reset.t80 a_106678_n17162# VDDD.t543 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X742 VDDD.t113 SAR_Asynchronous_Logic_2/D_reset_FF_1.Q.t12 a_40062_n13054# VDDD.t112 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X743 VSSD.t404 a_36722_n4054.t7 a_36722_n3300.t1 VSSD.t403 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X744 a_74818_n4422.t0 a_68722_n4054.t6 a_74632_n3162.t0 VDDD.t306 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X745 SAR_Asynchronous_Logic_10/D_reset_FF_0.nQ SAR_Asynchronous_Logic_10/D_reset_FF_0.Q.t6 VDDD.t11 VDDD.t10 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X746 a_109810_n3162# a_106632_n3162.t5 a_105342_n4422.t3 VDDD.t353 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X747 a_68790_n4422.t3 Set.t81 VSSD.t569 VSSD.t568 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X748 a_46134_n18422.t3 a_38002_n18190.t7 a_41050_n18422.t3 VDDD.t248 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X749 a_72578_n314.t2 Reset.t81 a_72578_946# VDDD.t544 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X750 SAR_Asynchronous_Logic_3/D_reset_FF_1.Q.t8 a_4722_n4054.t7 a_10632_n3162.t3 VSSD.t651 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X751 VSSD.t514 clks.t19 a_68722_n4054.t0 VSSD.t513 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X752 D_C_3.t0 a_70822_n13192.t5 a_76732_n13054.t0 VDDD.t119 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X753 VDDD.t72 a_38822_n13946.t7 a_38822_n13192.t1 VDDD.t71 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X754 a_74678_n18422.t1 Reset.t82 a_74678_n17162# VDDD.t525 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X755 SAR_Asynchronous_Logic_0/D_reset_FF_1.Q.t3 a_n28998_n80.t6 a_n13146_1076.t0 VSSD.t485 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X756 a_68722_n82.t1 a_67902_n82.t7 VSSD.t541 VSSD.t540 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X757 VSSD.t516 clks.t20 a_36722_n4054.t1 VSSD.t515 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X758 a_45810_n3162# a_42632_n3162.t5 a_41342_n4422.t4 VDDD.t598 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X759 VSSD.t5 SAR_Asynchronous_Logic_7/D_reset_FF_1.Q.t12 SAR_Asynchronous_Logic_7/D_reset_FF_1.nQ VSSD.t4 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X760 Bit_1.t0 a_32736_n13850.t6 VCM.t10 VSSD.t114 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X761 VDDD.t527 Reset.t83 a_103602_n3162# VDDD.t526 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X762 a_3002_n80.t1 a_2110_n80.t7 VSSD.t346 VSSD.t345 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X763 a_76034_n314# a_68722_n82.t5 a_78798_n314.t0 VDDD.t31 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X764 a_37966_n314.t1 a_35902_n82.t7 a_40578_n314.t2 VDDD.t255 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X765 VDDD.t365 a_2012_n13060.t3 Bit_0.t2 VDDD.t364 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=1.1u
X766 SAR_Asynchronous_Logic_0/D_reset_FF_1.Q.t1 a_n27278_n4054.t6 a_n21368_n3162.t1 VSSD.t355 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X767 a_137342_n4422.t1 a_132722_n3300.t5 a_132604_n3162.t3 VSSD.t199 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X768 VDDD.t529 Reset.t84 a_39602_n3162# VDDD.t528 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X769 Bit_2.t0 a_64736_n13096.t7 VCM.t3 VDDD.t450 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X770 a_18854_1076.t0 a_3002_n80.t6 VDDD.t286 VDDD.t285 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=1.1u
X771 a_73342_n4422.t3 a_68722_n3300.t5 a_68604_n3162.t2 VSSD.t198 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X772 VDDD.t168 SAR_Asynchronous_Logic_10/D_reset_FF_1.Q.t12 SAR_Asynchronous_Logic_10/D_reset_FF_1.nQ VDDD.t167 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X773 a_139442_n14314.t1 a_140732_n13054.t5 VSSD.t243 VSSD.t242 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X774 a_14282_n13054# Reset.t85 a_12918_n14314.t4 VDDD.t530 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X775 a_6950_n314.t4 Set.t82 VSSD.t571 VSSD.t570 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X776 a_n26034_n314.t1 a_n28098_n82.t7 D_C_11.t1 VSSD.t333 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X777 a_41702_n13054# a_38704_n13054# SAR_Asynchronous_Logic_2/D_reset_FF_1.Q.t2 VDDD.t12 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X778 VDDD.t509 Set.t83 a_141810_n3162# VDDD.t508 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X779 a_6890_n14314.t1 a_6822_n13946.t6 a_6704_n13054# VSSD.t373 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X780 a_3902_n82.t1 a_3002_n80.t7 VSSD.t293 VSSD.t292 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X781 a_134950_n314.t4 Set.t84 VSSD.t573 VSSD.t572 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X782 VDDD.t511 Set.t85 a_n18190_n3162# VDDD.t510 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X783 a_102002_n18190.t0 clks.t21 VSSD.t518 VSSD.t517 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X784 D_C_1.t0 a_6822_n13946.t7 a_12732_n13054.t3 VSSD.t372 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X785 a_104578_n314.t4 Reset.t86 a_104578_946# VDDD.t531 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X786 VSSD.t536 a_19052_n4460# Bit_9.t3 VSSD.t535 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=1.1u
X787 a_110798_946# SAR_Asynchronous_Logic_9/D_reset_FF_1.Q.t12 VDDD.t391 VDDD.t390 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X788 SAR_Asynchronous_Logic_9/D_reset_FF_1.Q.t3 a_98110_n80.t7 a_115052_n4460# VDDD.t74 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X789 SAR_Asynchronous_Logic_0/D_reset_FF_1.Q.t5 a_n29890_n80.t7 a_n12948_n4460# VDDD.t524 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X790 VDDD.t513 Set.t86 a_45810_n3162# VDDD.t512 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X791 VDDD.t323 a_736_n13096.t7 a_6822_n13946.t1 VDDD.t322 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X792 a_142798_n314.t4 Set.t87 a_142798_946# VDDD.t514 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X793 VSSD.t588 Reset.t87 SAR_Asynchronous_Logic_4/D_reset_FF_1.Q.t2 VSSD.t587 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X794 a_108034_n314# a_100722_n82.t5 a_110798_n314.t2 VDDD.t382 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X795 SAR_Asynchronous_Logic_1/D_reset_FF_1.Q.t2 a_34110_n80.t6 a_51052_n4460# VDDD.t193 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X796 VSSD.t116 a_32736_n13850.t7 a_32736_n13096.t1 VSSD.t115 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X797 VCM.t8 a_34110_n80.t7 Bit_8.t1 VSSD.t666 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X798 a_68790_n4422.t1 a_68722_n4054.t7 a_68604_n3162.t1 VSSD.t326 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X799 VSSD.t185 SAR_Asynchronous_Logic_4/D_reset_FF_1.Q.t12 a_6890_n14314.t0 VSSD.t184 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X800 a_104066_n18422.t1 a_102822_n18190.t5 a_106678_n18422.t0 VSSD.t489 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X801 a_112898_n18422.t4 SAR_Asynchronous_Logic_8/D_reset_FF_0.Q.t6 VSSD.t627 VSSD.t626 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X802 VDDD.t371 CK_1.t1 a_736_n13850.t1 VDDD.t370 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X803 VCM.t5 a_n28998_n80.t7 Bit_10.t0 VDDD.t73 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X804 a_n27210_n4422.t2 a_n27278_n4054.t7 a_n27396_n3162.t1 VSSD.t356 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X805 a_37966_n314.t3 a_36722_n82.t5 D_C_9.t1 VDDD.t523 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=0.28u
X806 a_72066_n18422.t3 a_70822_n18190.t5 a_74678_n18422.t4 VSSD.t93 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X807 a_80898_n18422.t0 SAR_Asynchronous_Logic_7/D_reset_FF_0.Q.t6 VSSD.t337 VSSD.t336 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X808 Bit_8.t2 a_50854_1076.t3 VDDD.t462 VDDD.t461 pfet_03v3 ad=2.535p pd=9.1u as=2.535p ps=9.1u w=3.9u l=1.1u
X809 a_136066_n18422.t2 a_134002_n18190.t7 SAR_Asynchronous_Logic_10/D_reset_FF_1.Q.t7 VSSD.t234 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X810 a_11442_n14314.t3 a_6822_n13192.t5 a_6704_n13054# VSSD.t466 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X811 a_2110_n80.t1 CK_10.t1 VSSD.t239 VSSD.t238 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X812 VSSD.t488 a_5966_n314.t5 a_6950_n314.t2 VSSD.t487 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
X813 VSSD.t255 a_137342_n4422.t6 a_138818_n4422.t2 VSSD.t254 nfet_03v3 ad=0.9516p pd=4.34u as=0.9516p ps=4.34u w=1.56u l=0.28u
R0 a_67902_n82.n2 a_67902_n82.t2 82.7757
R1 a_67902_n82.n3 a_67902_n82.t3 82.6424
R2 a_67902_n82.n1 a_67902_n82.t5 70.3153
R3 a_67902_n82.n2 a_67902_n82.t6 55.8264
R4 a_67902_n82.n4 a_67902_n82.t4 51.5658
R5 a_67902_n82.n1 a_67902_n82.t7 39.854
R6 a_67902_n82.n0 a_67902_n82.t1 6.02308
R7 a_67902_n82.n4 a_67902_n82.n3 3.9695
R8 a_67902_n82.n0 a_67902_n82.n4 3.3953
R9 a_67902_n82.n0 a_67902_n82.n1 2.70724
R10 a_67902_n82.t0 a_67902_n82.n0 2.47208
R11 a_67902_n82.n3 a_67902_n82.n2 1.3073
R12 a_70950_n314.n0 a_70950_n314.t5 74.8588
R13 a_70950_n314.n0 a_70950_n314.t6 44.2362
R14 a_70950_n314.n0 a_70950_n314.n2 14.5242
R15 a_70950_n314.n2 a_70950_n314.t0 11.0089
R16 a_70950_n314.n3 a_70950_n314.n1 5.39574
R17 a_70950_n314.t1 a_70950_n314.n3 4.91248
R18 a_70950_n314.n2 a_70950_n314.t4 4.12478
R19 a_70950_n314.n1 a_70950_n314.t3 3.7821
R20 a_70950_n314.n1 a_70950_n314.t2 3.77824
R21 a_70950_n314.n3 a_70950_n314.n0 1.83141
R22 VDDD.n1429 VDDD.n1428 13924.2
R23 VDDD.n1575 VDDD.n1574 13924.2
R24 VDDD.n1721 VDDD.n1720 13924.2
R25 VDDD.n1867 VDDD.n1866 13924.2
R26 VDDD.n2720 VDDD.n2719 13924.2
R27 VDDD.n1998 VDDD.n1995 7227.76
R28 VDDD.n2256 VDDD.n2253 7227.76
R29 VDDD.n2318 VDDD.n2315 7227.76
R30 VDDD.n2380 VDDD.n2377 7227.76
R31 VDDD.n2442 VDDD.n2439 7227.76
R32 VDDD.n2504 VDDD.n2501 7227.76
R33 VDDD.n1430 VDDD.n1429 3968.5
R34 VDDD.n1576 VDDD.n1575 3968.5
R35 VDDD.n1722 VDDD.n1721 3968.5
R36 VDDD.n1868 VDDD.n1867 3968.5
R37 VDDD.n2721 VDDD.n2720 3968.5
R38 VDDD.n1996 VDDD.n1995 1754.49
R39 VDDD.n2256 VDDD.n2255 1754.49
R40 VDDD.n2318 VDDD.n2317 1754.49
R41 VDDD.n2380 VDDD.n2379 1754.49
R42 VDDD.n2442 VDDD.n2441 1754.49
R43 VDDD.n2504 VDDD.n2503 1754.49
R44 VDDD.n242 VDDD.t126 1632.01
R45 VDDD.n395 VDDD.t122 1632.01
R46 VDDD.n548 VDDD.t434 1632.01
R47 VDDD.n701 VDDD.t21 1632.01
R48 VDDD.n851 VDDD.t165 1567.5
R49 VDDD.n1462 VDDD.t459 1567.5
R50 VDDD.n1608 VDDD.t193 1567.5
R51 VDDD.n1754 VDDD.t53 1567.5
R52 VDDD.n1900 VDDD.t74 1567.5
R53 VDDD.n2033 VDDD.t357 1567.5
R54 VDDD.n2753 VDDD.t524 1567.5
R55 VDDD.t229 VDDD.t290 984
R56 VDDD.t302 VDDD.t248 984
R57 VDDD.t35 VDDD.t34 984
R58 VDDD.t547 VDDD.t548 984
R59 VDDD.t228 VDDD.t225 984
R60 VDDD.t486 VDDD.t14 984
R61 VDDD.t87 VDDD.t572 984
R62 VDDD.t254 VDDD.t255 984
R63 VDDD.t379 VDDD.t380 984
R64 VDDD.t495 VDDD.t494 984
R65 VDDD.t305 VDDD.t306 984
R66 VDDD.t60 VDDD.t63 984
R67 VDDD.t106 VDDD.t96 984
R68 VDDD.t337 VDDD.t340 984
R69 VDDD.t268 VDDD.t269 984
R70 VDDD.t329 VDDD.t332 984
R71 VDDD.t189 VDDD.t188 984
R72 VDDD.t205 VDDD.t204 984
R73 VDDD.t70 VDDD.t69 984
R74 VDDD.t0 VDDD.t5 984
R75 VDDD.t310 VDDD.t315 984
R76 VDDD.t334 VDDD.t333 984
R77 VDDD.t416 VDDD.t229 909.333
R78 VDDD.t592 VDDD.t302 909.333
R79 VDDD.t525 VDDD.t35 909.333
R80 VDDD.t543 VDDD.t547 909.333
R81 VDDD.t149 VDDD.t228 909.333
R82 VDDD.t14 VDDD.t578 909.333
R83 VDDD.t572 VDDD.t429 909.333
R84 VDDD.t255 VDDD.t535 909.333
R85 VDDD.t380 VDDD.t593 909.333
R86 VDDD.t494 VDDD.t544 909.333
R87 VDDD.t306 VDDD.t148 909.333
R88 VDDD.t63 VDDD.t531 909.333
R89 VDDD.t96 VDDD.t591 909.333
R90 VDDD.t340 VDDD.t150 909.333
R91 VDDD.t269 VDDD.t590 909.333
R92 VDDD.t573 VDDD.t329 909.333
R93 VDDD.t401 VDDD.t189 909.333
R94 VDDD.t604 VDDD.t205 909.333
R95 VDDD.t151 VDDD.t70 909.333
R96 VDDD.t530 VDDD.t0 909.333
R97 VDDD.t315 VDDD.t601 909.333
R98 VDDD.t333 VDDD.t154 909.333
R99 VDDD.t291 VDDD.t378 842.399
R100 VDDD.t300 VDDD.t581 842.399
R101 VDDD.t32 VDDD.t394 842.399
R102 VDDD.t545 VDDD.t485 842.399
R103 VDDD.t226 VDDD.t245 825.381
R104 VDDD.t376 VDDD.t88 825.381
R105 VDDD.t400 VDDD.t54 825.381
R106 VDDD.t29 VDDD.t392 825.381
R107 VDDD.t326 VDDD.t97 825.381
R108 VDDD.t195 VDDD.t270 825.381
R109 VDDD.t515 VDDD.t335 825.381
R110 VDDD.t138 VDDD.t206 781.333
R111 VDDD.t395 VDDD.t582 781.333
R112 VDDD.t218 VDDD.t99 781.333
R113 VDDD.t56 VDDD.t447 781.333
R114 VDDD.t500 VDDD.t244 781.333
R115 VDDD.t242 VDDD.t507 781.333
R116 VDDD.t377 VDDD.t497 781.333
R117 VDDD.t562 VDDD.t171 781.333
R118 VDDD.t399 VDDD.t174 781.333
R119 VDDD.t31 VDDD.t139 781.333
R120 VDDD.t411 VDDD.t185 781.333
R121 VDDD.t382 VDDD.t496 781.333
R122 VDDD.t352 VDDD.t398 781.333
R123 VDDD.t437 VDDD.t514 781.333
R124 VDDD.t194 VDDD.t169 781.333
R125 VDDD.t502 VDDD.t560 781.333
R126 VDDD.t59 VDDD.t38 781.333
R127 VDDD.t297 VDDD.t125 781.333
R128 VDDD.t131 VDDD.t431 781.333
R129 VDDD.t170 VDDD.t177 781.333
R130 VDDD.t213 VDDD.t259 781.333
R131 VDDD.t564 VDDD.t501 781.333
R132 VDDD.t206 VDDD.n240 765.658
R133 VDDD.t582 VDDD.n393 765.658
R134 VDDD.t99 VDDD.n546 765.658
R135 VDDD.t447 VDDD.n699 765.658
R136 VDDD.n1430 VDDD.t487 761.616
R137 VDDD.n1576 VDDD.t85 761.616
R138 VDDD.n1722 VDDD.t492 761.616
R139 VDDD.n1868 VDDD.t61 761.616
R140 VDDD.n2721 VDDD.t311 761.616
R141 VDDD.t290 VDDD.t541 749.333
R142 VDDD.t248 VDDD.t404 749.333
R143 VDDD.t34 VDDD.t579 749.333
R144 VDDD.t548 VDDD.t427 749.333
R145 VDDD.t225 VDDD.t421 749.333
R146 VDDD.t402 VDDD.t486 749.333
R147 VDDD.t146 VDDD.t87 749.333
R148 VDDD.t423 VDDD.t254 749.333
R149 VDDD.t528 VDDD.t379 749.333
R150 VDDD.t596 VDDD.t495 749.333
R151 VDDD.t602 VDDD.t305 749.333
R152 VDDD.t536 VDDD.t60 749.333
R153 VDDD.t526 VDDD.t106 749.333
R154 VDDD.t152 VDDD.t337 749.333
R155 VDDD.t599 VDDD.t268 749.333
R156 VDDD.t332 VDDD.t594 749.333
R157 VDDD.t188 VDDD.t417 749.333
R158 VDDD.t204 VDDD.t419 749.333
R159 VDDD.t69 VDDD.t425 749.333
R160 VDDD.t5 VDDD.t538 749.333
R161 VDDD.t574 VDDD.t310 749.333
R162 VDDD.t576 VDDD.t334 749.333
R163 VDDD.n1998 VDDD.t338 725.254
R164 VDDD.t330 VDDD.n2253 725.254
R165 VDDD.t186 VDDD.n2315 725.254
R166 VDDD.t202 VDDD.n2377 725.254
R167 VDDD.t71 VDDD.n2439 725.254
R168 VDDD.t6 VDDD.n2501 725.254
R169 VDDD.t344 VDDD.t294 682.668
R170 VDDD.t293 VDDD.t281 682.668
R171 VDDD.t108 VDDD.t316 682.668
R172 VDDD.t375 VDDD.t553 682.668
R173 VDDD.t563 VDDD.t8 682.668
R174 VDDD.t209 VDDD.t24 682.668
R175 VDDD.t67 VDDD.t520 682.668
R176 VDDD.t127 VDDD.t454 682.668
R177 VDDD.t260 VDDD.t155 682.668
R178 VDDD.t264 VDDD.t100 682.668
R179 VDDD.t196 VDDD.t303 682.668
R180 VDDD.t390 VDDD.t23 682.668
R181 VDDD.t40 VDDD.t533 682.668
R182 VDDD.t123 VDDD.t453 682.668
R183 VDDD.t94 VDDD.t296 682.668
R184 VDDD.t105 VDDD.t246 682.668
R185 VDDD.t91 VDDD.t386 682.668
R186 VDDD.t457 VDDD.t51 682.668
R187 VDDD.t12 VDDD.t112 682.668
R188 VDDD.t48 VDDD.t181 682.668
R189 VDDD.t27 VDDD.t532 682.668
R190 VDDD.t3 VDDD.t17 682.668
R191 VDDD.n2525 VDDD.t304 680.673
R192 VDDD.n2463 VDDD.t114 680.673
R193 VDDD.n2401 VDDD.t450 680.673
R194 VDDD.n2339 VDDD.t408 680.673
R195 VDDD.n2277 VDDD.t45 680.673
R196 VDDD.n1414 VDDD.t251 680.673
R197 VDDD.n1560 VDDD.t587 680.673
R198 VDDD.n1706 VDDD.t64 680.673
R199 VDDD.n1852 VDDD.t82 680.673
R200 VDDD.n1983 VDDD.t274 680.673
R201 VDDD.n2705 VDDD.t73 680.673
R202 VDDD.t460 VDDD.t557 674.668
R203 VDDD.t374 VDDD.t219 674.668
R204 VDDD.t359 VDDD.t432 674.668
R205 VDDD.t341 VDDD.t451 674.668
R206 VDDD.t383 VDDD.t83 674.668
R207 VDDD.t298 VDDD.t446 674.668
R208 VDDD.t489 VDDD.t289 674.668
R209 VDDD.t318 VDDD.t231 674.668
R210 VDDD.t516 VDDD.t598 674.668
R211 VDDD.t101 VDDD.t90 674.668
R212 VDDD.t368 VDDD.t358 674.668
R213 VDDD.t36 VDDD.t491 674.668
R214 VDDD.t348 VDDD.t353 674.668
R215 VDDD.t350 VDDD.t109 674.668
R216 VDDD.t252 VDDD.t234 674.668
R217 VDDD.t237 VDDD.t570 674.668
R218 VDDD.t534 VDDD.t266 674.668
R219 VDDD.t44 VDDD.t183 674.668
R220 VDDD.t561 VDDD.t412 674.668
R221 VDDD.t18 VDDD.t342 674.668
R222 VDDD.t42 VDDD.t107 674.668
R223 VDDD.t92 VDDD.t230 674.668
R224 VDDD.t378 VDDD.t175 656
R225 VDDD.t581 VDDD.t132 656
R226 VDDD.t394 VDDD.t396 656
R227 VDDD.t485 VDDD.t568 656
R228 VDDD.t245 VDDD.t505 656
R229 VDDD.t503 VDDD.t243 656
R230 VDDD.t521 VDDD.t376 656
R231 VDDD.t257 VDDD.t523 656
R232 VDDD.t512 VDDD.t400 656
R233 VDDD.t134 VDDD.t30 656
R234 VDDD.t221 VDDD.t29 656
R235 VDDD.t140 VDDD.t381 656
R236 VDDD.t414 VDDD.t326 656
R237 VDDD.t216 VDDD.t13 656
R238 VDDD.t508 VDDD.t195 656
R239 VDDD.t559 VDDD.t498 656
R240 VDDD.t39 VDDD.t57 656
R241 VDDD.t119 VDDD.t142 656
R242 VDDD.t430 VDDD.t566 656
R243 VDDD.t178 VDDD.t136 656
R244 VDDD.t172 VDDD.t345 656
R245 VDDD.t510 VDDD.t515 656
R246 VDDD.t244 VDDD.n849 611.111
R247 VDDD.n1464 VDDD.t377 611.111
R248 VDDD.n1610 VDDD.t399 611.111
R249 VDDD.n1756 VDDD.t411 611.111
R250 VDDD.n1902 VDDD.t352 611.111
R251 VDDD.n2035 VDDD.t194 611.111
R252 VDDD.n2755 VDDD.t564 611.111
R253 VDDD.t166 VDDD.n2523 593.138
R254 VDDD.t162 VDDD.n2461 593.138
R255 VDDD.t256 VDDD.n2399 593.138
R256 VDDD.t22 VDDD.n2337 593.138
R257 VDDD.t540 VDDD.n2275 593.138
R258 VDDD.n1434 VDDD.t458 593.138
R259 VDDD.n1580 VDDD.t190 593.138
R260 VDDD.n1726 VDDD.t309 593.138
R261 VDDD.n1872 VDDD.t77 593.138
R262 VDDD.n2002 VDDD.t356 593.138
R263 VDDD.n2725 VDDD.t565 593.138
R264 VDDD.n2524 VDDD.t166 584.034
R265 VDDD.n2462 VDDD.t162 584.034
R266 VDDD.n2400 VDDD.t256 584.034
R267 VDDD.n2338 VDDD.t22 584.034
R268 VDDD.n2276 VDDD.t540 584.034
R269 VDDD.t458 VDDD.n1420 584.034
R270 VDDD.t190 VDDD.n1566 584.034
R271 VDDD.t309 VDDD.n1712 584.034
R272 VDDD.t77 VDDD.n1858 584.034
R273 VDDD.t356 VDDD.n1989 584.034
R274 VDDD.t565 VDDD.n2711 584.034
R275 VDDD.n159 VDDD.t320 551.26
R276 VDDD.n312 VDDD.t120 551.26
R277 VDDD.n465 VDDD.t448 551.26
R278 VDDD.n618 VDDD.t409 551.26
R279 VDDD.n771 VDDD.t444 551.26
R280 VDDD.n1435 VDDD.t285 551.26
R281 VDDD.n1581 VDDD.t583 551.26
R282 VDDD.n1727 VDDD.t372 551.26
R283 VDDD.n1873 VDDD.t78 551.26
R284 VDDD.n2003 VDDD.t272 551.26
R285 VDDD.n2726 VDDD.t438 551.26
R286 VDDD.n160 VDDD.n158 541.26
R287 VDDD.n313 VDDD.n311 541.26
R288 VDDD.n466 VDDD.n464 541.26
R289 VDDD.n619 VDDD.n617 541.26
R290 VDDD.n772 VDDD.n770 541.26
R291 VDDD.n1432 VDDD.n1424 541.26
R292 VDDD.n1578 VDDD.n1570 541.26
R293 VDDD.n1724 VDDD.n1716 541.26
R294 VDDD.n1870 VDDD.n1862 541.26
R295 VDDD.n2000 VDDD.n1993 541.26
R296 VDDD.n2723 VDDD.n2715 541.26
R297 VDDD.n1997 VDDD.t275 532.197
R298 VDDD.t442 VDDD.n2254 532.197
R299 VDDD.t406 VDDD.n2316 532.197
R300 VDDD.t207 VDDD.n2378 532.197
R301 VDDD.t115 VDDD.n2440 532.197
R302 VDDD.t322 VDDD.n2502 532.197
R303 VDDD.n1431 VDDD.t242 505.334
R304 VDDD.n1577 VDDD.t562 505.334
R305 VDDD.n1723 VDDD.t31 505.334
R306 VDDD.n1869 VDDD.t382 505.334
R307 VDDD.n1999 VDDD.t437 505.334
R308 VDDD.t560 VDDD.n2252 505.334
R309 VDDD.t38 VDDD.n2314 505.334
R310 VDDD.t125 VDDD.n2376 505.334
R311 VDDD.t431 VDDD.n2438 505.334
R312 VDDD.t177 VDDD.n2500 505.334
R313 VDDD.n2722 VDDD.t213 505.334
R314 VDDD.n1428 VDDD.t283 481.818
R315 VDDD.n1574 VDDD.t585 481.818
R316 VDDD.n1720 VDDD.t384 481.818
R317 VDDD.n1866 VDDD.t80 481.818
R318 VDDD.n2719 VDDD.t440 481.818
R319 VDDD.t179 VDDD.n158 478.115
R320 VDDD.t110 VDDD.n311 478.115
R321 VDDD.t49 VDDD.n464 478.115
R322 VDDD.t388 VDDD.n617 478.115
R323 VDDD.t167 VDDD.n770 478.115
R324 VDDD.n1432 VDDD.t211 478.115
R325 VDDD.n1578 VDDD.t129 478.115
R326 VDDD.n1724 VDDD.t262 478.115
R327 VDDD.n1870 VDDD.t455 478.115
R328 VDDD.n2000 VDDD.t163 478.115
R329 VDDD.n2723 VDDD.t25 478.115
R330 VDDD.t294 VDDD.t138 410.668
R331 VDDD.t541 VDDD.t344 410.668
R332 VDDD.t557 VDDD.t416 410.668
R333 VDDD.t175 VDDD.t460 410.668
R334 VDDD.t281 VDDD.t395 410.668
R335 VDDD.t404 VDDD.t293 410.668
R336 VDDD.t219 VDDD.t592 410.668
R337 VDDD.t132 VDDD.t374 410.668
R338 VDDD.t316 VDDD.t218 410.668
R339 VDDD.t579 VDDD.t108 410.668
R340 VDDD.t432 VDDD.t525 410.668
R341 VDDD.t396 VDDD.t359 410.668
R342 VDDD.t553 VDDD.t56 410.668
R343 VDDD.t427 VDDD.t375 410.668
R344 VDDD.t451 VDDD.t543 410.668
R345 VDDD.t568 VDDD.t341 410.668
R346 VDDD.t8 VDDD.t500 410.668
R347 VDDD.t421 VDDD.t563 410.668
R348 VDDD.t83 VDDD.t149 410.668
R349 VDDD.t505 VDDD.t383 410.668
R350 VDDD.t507 VDDD.t209 410.668
R351 VDDD.t24 VDDD.t402 410.668
R352 VDDD.t578 VDDD.t298 410.668
R353 VDDD.t446 VDDD.t503 410.668
R354 VDDD.t289 VDDD.t521 410.668
R355 VDDD.t429 VDDD.t489 410.668
R356 VDDD.t520 VDDD.t146 410.668
R357 VDDD.t497 VDDD.t67 410.668
R358 VDDD.t171 VDDD.t127 410.668
R359 VDDD.t454 VDDD.t423 410.668
R360 VDDD.t535 VDDD.t318 410.668
R361 VDDD.t231 VDDD.t257 410.668
R362 VDDD.t598 VDDD.t512 410.668
R363 VDDD.t593 VDDD.t516 410.668
R364 VDDD.t155 VDDD.t528 410.668
R365 VDDD.t174 VDDD.t260 410.668
R366 VDDD.t139 VDDD.t264 410.668
R367 VDDD.t100 VDDD.t596 410.668
R368 VDDD.t544 VDDD.t101 410.668
R369 VDDD.t90 VDDD.t134 410.668
R370 VDDD.t358 VDDD.t221 410.668
R371 VDDD.t148 VDDD.t368 410.668
R372 VDDD.t303 VDDD.t602 410.668
R373 VDDD.t185 VDDD.t196 410.668
R374 VDDD.t496 VDDD.t390 410.668
R375 VDDD.t23 VDDD.t536 410.668
R376 VDDD.t531 VDDD.t36 410.668
R377 VDDD.t491 VDDD.t140 410.668
R378 VDDD.t353 VDDD.t414 410.668
R379 VDDD.t591 VDDD.t348 410.668
R380 VDDD.t533 VDDD.t526 410.668
R381 VDDD.t398 VDDD.t40 410.668
R382 VDDD.t514 VDDD.t123 410.668
R383 VDDD.t453 VDDD.t152 410.668
R384 VDDD.t150 VDDD.t350 410.668
R385 VDDD.t109 VDDD.t216 410.668
R386 VDDD.t234 VDDD.t508 410.668
R387 VDDD.t590 VDDD.t252 410.668
R388 VDDD.t296 VDDD.t599 410.668
R389 VDDD.t169 VDDD.t94 410.668
R390 VDDD.t498 VDDD.t237 410.668
R391 VDDD.t570 VDDD.t573 410.668
R392 VDDD.t594 VDDD.t105 410.668
R393 VDDD.t246 VDDD.t502 410.668
R394 VDDD.t57 VDDD.t534 410.668
R395 VDDD.t266 VDDD.t401 410.668
R396 VDDD.t417 VDDD.t91 410.668
R397 VDDD.t386 VDDD.t59 410.668
R398 VDDD.t142 VDDD.t44 410.668
R399 VDDD.t183 VDDD.t604 410.668
R400 VDDD.t419 VDDD.t457 410.668
R401 VDDD.t51 VDDD.t297 410.668
R402 VDDD.t566 VDDD.t561 410.668
R403 VDDD.t412 VDDD.t151 410.668
R404 VDDD.t425 VDDD.t12 410.668
R405 VDDD.t112 VDDD.t131 410.668
R406 VDDD.t136 VDDD.t18 410.668
R407 VDDD.t342 VDDD.t530 410.668
R408 VDDD.t538 VDDD.t48 410.668
R409 VDDD.t181 VDDD.t170 410.668
R410 VDDD.t259 VDDD.t27 410.668
R411 VDDD.t532 VDDD.t574 410.668
R412 VDDD.t601 VDDD.t42 410.668
R413 VDDD.t107 VDDD.t172 410.668
R414 VDDD.t230 VDDD.t510 410.668
R415 VDDD.t154 VDDD.t92 410.668
R416 VDDD.t17 VDDD.t576 410.668
R417 VDDD.t501 VDDD.t3 410.668
R418 VDDD.n1426 VDDD.t232 405.372
R419 VDDD.n1572 VDDD.t235 405.372
R420 VDDD.n1718 VDDD.t19 405.372
R421 VDDD.n1864 VDDD.t287 405.372
R422 VDDD.n1994 VDDD.t362 405.372
R423 VDDD.t366 VDDD.n2257 405.372
R424 VDDD.t313 VDDD.n2319 405.372
R425 VDDD.t360 VDDD.n2381 405.372
R426 VDDD.t240 VDDD.n2443 405.372
R427 VDDD.t370 VDDD.n2505 405.372
R428 VDDD.n2717 VDDD.t214 405.372
R429 VDDD.n243 VDDD.t467 384.406
R430 VDDD.n396 VDDD.t471 384.406
R431 VDDD.n549 VDDD.t465 384.406
R432 VDDD.n702 VDDD.t469 384.406
R433 VDDD.n852 VDDD.t475 367.801
R434 VDDD.n1463 VDDD.t463 367.801
R435 VDDD.n1609 VDDD.t483 367.801
R436 VDDD.n1755 VDDD.t481 367.801
R437 VDDD.n1901 VDDD.t477 367.801
R438 VDDD.n2034 VDDD.t479 367.801
R439 VDDD.n2754 VDDD.t473 367.801
R440 VDDD.t243 VDDD.n1430 326.668
R441 VDDD.t523 VDDD.n1576 326.668
R442 VDDD.t30 VDDD.n1722 326.668
R443 VDDD.t381 VDDD.n1868 326.668
R444 VDDD.t13 VDDD.n1998 326.668
R445 VDDD.n2253 VDDD.t559 326.668
R446 VDDD.n2315 VDDD.t39 326.668
R447 VDDD.n2377 VDDD.t119 326.668
R448 VDDD.n2439 VDDD.t430 326.668
R449 VDDD.n2501 VDDD.t178 326.668
R450 VDDD.t345 VDDD.n2721 326.668
R451 VDDD.n1429 VDDD.t327 292.774
R452 VDDD.n1575 VDDD.t191 292.774
R453 VDDD.n1721 VDDD.t307 292.774
R454 VDDD.n1867 VDDD.t75 292.774
R455 VDDD.n2720 VDDD.t518 292.774
R456 VDDD.t364 VDDD.n2524 261.906
R457 VDDD.t364 VDDD.n2525 261.906
R458 VDDD.t555 VDDD.n2462 261.906
R459 VDDD.t555 VDDD.n2463 261.906
R460 VDDD.t324 VDDD.n2400 261.906
R461 VDDD.t324 VDDD.n2401 261.906
R462 VDDD.t46 VDDD.n2338 261.906
R463 VDDD.t46 VDDD.n2339 261.906
R464 VDDD.t156 VDDD.n2276 261.906
R465 VDDD.t156 VDDD.n2277 261.906
R466 VDDD.n1414 VDDD.t158 261.906
R467 VDDD.n1420 VDDD.t158 261.906
R468 VDDD.n1560 VDDD.t461 261.906
R469 VDDD.n1566 VDDD.t461 261.906
R470 VDDD.n1706 VDDD.t346 261.906
R471 VDDD.n1712 VDDD.t346 261.906
R472 VDDD.n1852 VDDD.t103 261.906
R473 VDDD.n1858 VDDD.t103 261.906
R474 VDDD.n1983 VDDD.t277 261.906
R475 VDDD.n1989 VDDD.t277 261.906
R476 VDDD.n2705 VDDD.t549 261.906
R477 VDDD.n2711 VDDD.t549 261.906
R478 VDDD.n240 VDDD.t117 260.606
R479 VDDD.n393 VDDD.t279 260.606
R480 VDDD.n546 VDDD.t200 260.606
R481 VDDD.n699 VDDD.t551 260.606
R482 VDDD.n849 VDDD.t10 260.606
R483 VDDD.n1427 VDDD.t487 260.606
R484 VDDD.t283 VDDD.n1425 260.606
R485 VDDD.n1464 VDDD.t65 260.606
R486 VDDD.n1573 VDDD.t85 260.606
R487 VDDD.t585 VDDD.n1571 260.606
R488 VDDD.n1610 VDDD.t588 260.606
R489 VDDD.n1719 VDDD.t492 260.606
R490 VDDD.t384 VDDD.n1717 260.606
R491 VDDD.n1756 VDDD.t198 260.606
R492 VDDD.n1865 VDDD.t61 260.606
R493 VDDD.t80 VDDD.n1863 260.606
R494 VDDD.n1902 VDDD.t223 260.606
R495 VDDD.n2035 VDDD.t249 260.606
R496 VDDD.n2718 VDDD.t311 260.606
R497 VDDD.t440 VDDD.n2716 260.606
R498 VDDD.n2755 VDDD.t1 260.606
R499 VDDD.t338 VDDD.n1997 244.319
R500 VDDD.t275 VDDD.n1996 244.319
R501 VDDD.n2255 VDDD.t442 244.319
R502 VDDD.n2254 VDDD.t330 244.319
R503 VDDD.n2317 VDDD.t406 244.319
R504 VDDD.n2316 VDDD.t186 244.319
R505 VDDD.n2379 VDDD.t207 244.319
R506 VDDD.n2378 VDDD.t202 244.319
R507 VDDD.n2441 VDDD.t115 244.319
R508 VDDD.n2440 VDDD.t71 244.319
R509 VDDD.n2503 VDDD.t322 244.319
R510 VDDD.n2502 VDDD.t6 244.319
R511 VDDD.n1995 VDDD.t354 189.258
R512 VDDD.t144 VDDD.n2256 189.258
R513 VDDD.t15 VDDD.n2318 189.258
R514 VDDD.t435 VDDD.n2380 189.258
R515 VDDD.t160 VDDD.n2442 189.258
R516 VDDD.t238 VDDD.n2504 189.258
R517 VDDD.n1429 VDDD.n1425 185.859
R518 VDDD.n1575 VDDD.n1571 185.859
R519 VDDD.n1721 VDDD.n1717 185.859
R520 VDDD.n1867 VDDD.n1863 185.859
R521 VDDD.n2720 VDDD.n2716 185.859
R522 VDDD.n243 VDDD.t291 176.471
R523 VDDD.t467 VDDD.n242 176.471
R524 VDDD.n396 VDDD.t300 176.471
R525 VDDD.t471 VDDD.n395 176.471
R526 VDDD.n549 VDDD.t32 176.471
R527 VDDD.t465 VDDD.n548 176.471
R528 VDDD.n702 VDDD.t545 176.471
R529 VDDD.t469 VDDD.n701 176.471
R530 VDDD.t211 VDDD.n1431 172
R531 VDDD.t129 VDDD.n1577 172
R532 VDDD.t262 VDDD.n1723 172
R533 VDDD.t455 VDDD.n1869 172
R534 VDDD.t163 VDDD.n1999 172
R535 VDDD.n2252 VDDD.t167 172
R536 VDDD.n2314 VDDD.t388 172
R537 VDDD.n2376 VDDD.t49 172
R538 VDDD.n2438 VDDD.t110 172
R539 VDDD.n2500 VDDD.t179 172
R540 VDDD.t25 VDDD.n2722 172
R541 VDDD.n852 VDDD.t226 168.849
R542 VDDD.t475 VDDD.n851 168.849
R543 VDDD.t463 VDDD.n1462 168.849
R544 VDDD.t88 VDDD.n1463 168.849
R545 VDDD.t483 VDDD.n1608 168.849
R546 VDDD.t54 VDDD.n1609 168.849
R547 VDDD.t481 VDDD.n1754 168.849
R548 VDDD.t392 VDDD.n1755 168.849
R549 VDDD.t477 VDDD.n1900 168.849
R550 VDDD.t97 VDDD.n1901 168.849
R551 VDDD.t479 VDDD.n2033 168.849
R552 VDDD.t270 VDDD.n2034 168.849
R553 VDDD.t473 VDDD.n2753 168.849
R554 VDDD.t335 VDDD.n2754 168.849
R555 VDDD.t232 VDDD.n1399 166.762
R556 VDDD.t235 VDDD.n1545 166.762
R557 VDDD.t19 VDDD.n1691 166.762
R558 VDDD.t287 VDDD.n1837 166.762
R559 VDDD.t362 VDDD.n1968 166.762
R560 VDDD.n2258 VDDD.t366 166.762
R561 VDDD.n2320 VDDD.t313 166.762
R562 VDDD.n2382 VDDD.t360 166.762
R563 VDDD.n2444 VDDD.t240 166.762
R564 VDDD.n2506 VDDD.t370 166.762
R565 VDDD.t214 VDDD.n2690 166.762
R566 VDDD.t327 VDDD.n1426 164.963
R567 VDDD.t191 VDDD.n1572 164.963
R568 VDDD.t307 VDDD.n1718 164.963
R569 VDDD.t75 VDDD.n1864 164.963
R570 VDDD.t354 VDDD.n1994 164.963
R571 VDDD.n2257 VDDD.t144 164.963
R572 VDDD.n2319 VDDD.t15 164.963
R573 VDDD.n2381 VDDD.t435 164.963
R574 VDDD.n2443 VDDD.t160 164.963
R575 VDDD.n2505 VDDD.t238 164.963
R576 VDDD.t518 VDDD.n2717 164.963
R577 VDDD.n1428 VDDD.n1427 85.8591
R578 VDDD.n1574 VDDD.n1573 85.8591
R579 VDDD.n1720 VDDD.n1719 85.8591
R580 VDDD.n1866 VDDD.n1865 85.8591
R581 VDDD.n2719 VDDD.n2718 85.8591
R582 VDDD.n2521 VDDD.n159 76.5952
R583 VDDD.n159 VDDD.n157 76.5952
R584 VDDD.n160 VDDD.n157 76.5952
R585 VDDD.n2521 VDDD.n160 76.5952
R586 VDDD.n2530 VDDD.n155 76.5952
R587 VDDD.n2530 VDDD.n156 76.5952
R588 VDDD.n2529 VDDD.n156 76.5952
R589 VDDD.n2529 VDDD.n155 76.5952
R590 VDDD.n2459 VDDD.n312 76.5952
R591 VDDD.n312 VDDD.n310 76.5952
R592 VDDD.n313 VDDD.n310 76.5952
R593 VDDD.n2459 VDDD.n313 76.5952
R594 VDDD.n2468 VDDD.n308 76.5952
R595 VDDD.n2468 VDDD.n309 76.5952
R596 VDDD.n2467 VDDD.n309 76.5952
R597 VDDD.n2467 VDDD.n308 76.5952
R598 VDDD.n2397 VDDD.n465 76.5952
R599 VDDD.n465 VDDD.n463 76.5952
R600 VDDD.n466 VDDD.n463 76.5952
R601 VDDD.n2397 VDDD.n466 76.5952
R602 VDDD.n2406 VDDD.n461 76.5952
R603 VDDD.n2406 VDDD.n462 76.5952
R604 VDDD.n2405 VDDD.n462 76.5952
R605 VDDD.n2405 VDDD.n461 76.5952
R606 VDDD.n2335 VDDD.n618 76.5952
R607 VDDD.n618 VDDD.n616 76.5952
R608 VDDD.n619 VDDD.n616 76.5952
R609 VDDD.n2335 VDDD.n619 76.5952
R610 VDDD.n2344 VDDD.n614 76.5952
R611 VDDD.n2344 VDDD.n615 76.5952
R612 VDDD.n2343 VDDD.n615 76.5952
R613 VDDD.n2343 VDDD.n614 76.5952
R614 VDDD.n2273 VDDD.n771 76.5952
R615 VDDD.n771 VDDD.n769 76.5952
R616 VDDD.n772 VDDD.n769 76.5952
R617 VDDD.n2273 VDDD.n772 76.5952
R618 VDDD.n2282 VDDD.n767 76.5952
R619 VDDD.n2282 VDDD.n768 76.5952
R620 VDDD.n2281 VDDD.n768 76.5952
R621 VDDD.n2281 VDDD.n767 76.5952
R622 VDDD.n1435 VDDD.n1406 76.5952
R623 VDDD.n1435 VDDD.n1407 76.5952
R624 VDDD.n1424 VDDD.n1407 76.5952
R625 VDDD.n1424 VDDD.n1406 76.5952
R626 VDDD.n1415 VDDD.n1408 76.5952
R627 VDDD.n1419 VDDD.n1408 76.5952
R628 VDDD.n1419 VDDD.n1409 76.5952
R629 VDDD.n1415 VDDD.n1409 76.5952
R630 VDDD.n1581 VDDD.n1552 76.5952
R631 VDDD.n1581 VDDD.n1553 76.5952
R632 VDDD.n1570 VDDD.n1553 76.5952
R633 VDDD.n1570 VDDD.n1552 76.5952
R634 VDDD.n1561 VDDD.n1554 76.5952
R635 VDDD.n1565 VDDD.n1554 76.5952
R636 VDDD.n1565 VDDD.n1555 76.5952
R637 VDDD.n1561 VDDD.n1555 76.5952
R638 VDDD.n1727 VDDD.n1698 76.5952
R639 VDDD.n1727 VDDD.n1699 76.5952
R640 VDDD.n1716 VDDD.n1699 76.5952
R641 VDDD.n1716 VDDD.n1698 76.5952
R642 VDDD.n1707 VDDD.n1700 76.5952
R643 VDDD.n1711 VDDD.n1700 76.5952
R644 VDDD.n1711 VDDD.n1701 76.5952
R645 VDDD.n1707 VDDD.n1701 76.5952
R646 VDDD.n1873 VDDD.n1844 76.5952
R647 VDDD.n1873 VDDD.n1845 76.5952
R648 VDDD.n1862 VDDD.n1845 76.5952
R649 VDDD.n1862 VDDD.n1844 76.5952
R650 VDDD.n1853 VDDD.n1846 76.5952
R651 VDDD.n1857 VDDD.n1846 76.5952
R652 VDDD.n1857 VDDD.n1847 76.5952
R653 VDDD.n1853 VDDD.n1847 76.5952
R654 VDDD.n2003 VDDD.n1975 76.5952
R655 VDDD.n2003 VDDD.n1976 76.5952
R656 VDDD.n1993 VDDD.n1976 76.5952
R657 VDDD.n1993 VDDD.n1975 76.5952
R658 VDDD.n1984 VDDD.n1977 76.5952
R659 VDDD.n1988 VDDD.n1977 76.5952
R660 VDDD.n1988 VDDD.n1978 76.5952
R661 VDDD.n1984 VDDD.n1978 76.5952
R662 VDDD.n2726 VDDD.n2697 76.5952
R663 VDDD.n2726 VDDD.n2698 76.5952
R664 VDDD.n2715 VDDD.n2698 76.5952
R665 VDDD.n2715 VDDD.n2697 76.5952
R666 VDDD.n2706 VDDD.n2699 76.5952
R667 VDDD.n2710 VDDD.n2699 76.5952
R668 VDDD.n2710 VDDD.n2700 76.5952
R669 VDDD.n2706 VDDD.n2700 76.5952
R670 VDDD.n2522 VDDD.n158 48.0005
R671 VDDD.n2460 VDDD.n311 48.0005
R672 VDDD.n2398 VDDD.n464 48.0005
R673 VDDD.n2336 VDDD.n617 48.0005
R674 VDDD.n2274 VDDD.n770 48.0005
R675 VDDD.n1433 VDDD.n1432 48.0005
R676 VDDD.n1579 VDDD.n1578 48.0005
R677 VDDD.n1725 VDDD.n1724 48.0005
R678 VDDD.n1871 VDDD.n1870 48.0005
R679 VDDD.n2001 VDDD.n2000 48.0005
R680 VDDD.n2724 VDDD.n2723 48.0005
R681 VDDD.n2523 VDDD.t320 36.0005
R682 VDDD.n2461 VDDD.t120 36.0005
R683 VDDD.n2399 VDDD.t448 36.0005
R684 VDDD.n2337 VDDD.t409 36.0005
R685 VDDD.n2275 VDDD.t444 36.0005
R686 VDDD.t285 VDDD.n1434 36.0005
R687 VDDD.t583 VDDD.n1580 36.0005
R688 VDDD.t372 VDDD.n1726 36.0005
R689 VDDD.t78 VDDD.n1872 36.0005
R690 VDDD.t272 VDDD.n2002 36.0005
R691 VDDD.t438 VDDD.n2725 36.0005
R692 VDDD.n1443 VDDD.n1402 25.3376
R693 VDDD.n1589 VDDD.n1548 25.3376
R694 VDDD.n1735 VDDD.n1694 25.3376
R695 VDDD.n1881 VDDD.n1840 25.3376
R696 VDDD.n2011 VDDD.n1971 25.3376
R697 VDDD.n2734 VDDD.n2693 25.3376
R698 VDDD.n2261 VDDD.n775 25.3376
R699 VDDD.n2323 VDDD.n622 25.3376
R700 VDDD.n2385 VDDD.n469 25.3376
R701 VDDD.n2447 VDDD.n316 25.3376
R702 VDDD.n2509 VDDD.n163 25.3376
R703 VDDD.n1443 VDDD.n1401 12.3776
R704 VDDD.n1589 VDDD.n1547 12.3776
R705 VDDD.n1735 VDDD.n1693 12.3776
R706 VDDD.n1881 VDDD.n1839 12.3776
R707 VDDD.n2011 VDDD.n1970 12.3776
R708 VDDD.n2261 VDDD.n776 12.3776
R709 VDDD.n2323 VDDD.n623 12.3776
R710 VDDD.n2385 VDDD.n470 12.3776
R711 VDDD.n2447 VDDD.n317 12.3776
R712 VDDD.n2509 VDDD.n164 12.3776
R713 VDDD.n2734 VDDD.n2692 12.3776
R714 VDDD.n142 VDDD.n140 4.5005
R715 VDDD.n2547 VDDD.n139 4.5005
R716 VDDD.n144 VDDD.n138 4.5005
R717 VDDD.n2541 VDDD.n143 4.5005
R718 VDDD.n2540 VDDD.n2539 4.5005
R719 VDDD.n2538 VDDD.n146 4.5005
R720 VDDD.n126 VDDD.n121 4.5005
R721 VDDD.n2550 VDDD.n121 4.5005
R722 VDDD.n152 VDDD.n120 4.5005
R723 VDDD.n2550 VDDD.n120 4.5005
R724 VDDD.n152 VDDD.n123 4.5005
R725 VDDD.n132 VDDD.n123 4.5005
R726 VDDD.n128 VDDD.n123 4.5005
R727 VDDD.n135 VDDD.n123 4.5005
R728 VDDD.n127 VDDD.n123 4.5005
R729 VDDD.n2548 VDDD.n123 4.5005
R730 VDDD.n126 VDDD.n123 4.5005
R731 VDDD.n2550 VDDD.n123 4.5005
R732 VDDD.n152 VDDD.n119 4.5005
R733 VDDD.n132 VDDD.n119 4.5005
R734 VDDD.n128 VDDD.n119 4.5005
R735 VDDD.n135 VDDD.n119 4.5005
R736 VDDD.n127 VDDD.n119 4.5005
R737 VDDD.n2548 VDDD.n119 4.5005
R738 VDDD.n2550 VDDD.n119 4.5005
R739 VDDD.n2549 VDDD.n132 4.5005
R740 VDDD.n2549 VDDD.n128 4.5005
R741 VDDD.n2549 VDDD.n135 4.5005
R742 VDDD.n2549 VDDD.n127 4.5005
R743 VDDD.n2549 VDDD.n2548 4.5005
R744 VDDD.n2549 VDDD.n126 4.5005
R745 VDDD.n2550 VDDD.n2549 4.5005
R746 VDDD.n209 VDDD.n195 4.5005
R747 VDDD.n209 VDDD.n196 4.5005
R748 VDDD.n209 VDDD.n197 4.5005
R749 VDDD.n216 VDDD.n209 4.5005
R750 VDDD.n209 VDDD.n200 4.5005
R751 VDDD.n209 VDDD.n201 4.5005
R752 VDDD.n210 VDDD.n209 4.5005
R753 VDDD.n209 VDDD.n204 4.5005
R754 VDDD.n195 VDDD.n130 4.5005
R755 VDDD.n196 VDDD.n130 4.5005
R756 VDDD.n197 VDDD.n130 4.5005
R757 VDDD.n216 VDDD.n130 4.5005
R758 VDDD.n200 VDDD.n130 4.5005
R759 VDDD.n201 VDDD.n130 4.5005
R760 VDDD.n210 VDDD.n130 4.5005
R761 VDDD.n206 VDDD.n196 4.5005
R762 VDDD.n206 VDDD.n197 4.5005
R763 VDDD.n216 VDDD.n206 4.5005
R764 VDDD.n206 VDDD.n200 4.5005
R765 VDDD.n206 VDDD.n201 4.5005
R766 VDDD.n206 VDDD.n202 4.5005
R767 VDDD.n210 VDDD.n206 4.5005
R768 VDDD.n224 VDDD.n206 4.5005
R769 VDDD.n206 VDDD.n204 4.5005
R770 VDDD.n261 VDDD.n260 4.5005
R771 VDDD.n191 VDDD.n183 4.5005
R772 VDDD.n260 VDDD.n183 4.5005
R773 VDDD.n191 VDDD.n186 4.5005
R774 VDDD.n190 VDDD.n186 4.5005
R775 VDDD.n254 VDDD.n186 4.5005
R776 VDDD.n189 VDDD.n186 4.5005
R777 VDDD.n256 VDDD.n186 4.5005
R778 VDDD.n188 VDDD.n186 4.5005
R779 VDDD.n258 VDDD.n186 4.5005
R780 VDDD.n260 VDDD.n186 4.5005
R781 VDDD.n191 VDDD.n182 4.5005
R782 VDDD.n190 VDDD.n182 4.5005
R783 VDDD.n254 VDDD.n182 4.5005
R784 VDDD.n189 VDDD.n182 4.5005
R785 VDDD.n256 VDDD.n182 4.5005
R786 VDDD.n188 VDDD.n182 4.5005
R787 VDDD.n258 VDDD.n182 4.5005
R788 VDDD.n260 VDDD.n182 4.5005
R789 VDDD.n259 VDDD.n190 4.5005
R790 VDDD.n259 VDDD.n254 4.5005
R791 VDDD.n259 VDDD.n189 4.5005
R792 VDDD.n259 VDDD.n256 4.5005
R793 VDDD.n259 VDDD.n188 4.5005
R794 VDDD.n259 VDDD.n258 4.5005
R795 VDDD.n260 VDDD.n259 4.5005
R796 VDDD.n295 VDDD.n293 4.5005
R797 VDDD.n2485 VDDD.n292 4.5005
R798 VDDD.n297 VDDD.n291 4.5005
R799 VDDD.n2479 VDDD.n296 4.5005
R800 VDDD.n2478 VDDD.n2477 4.5005
R801 VDDD.n2476 VDDD.n299 4.5005
R802 VDDD.n279 VDDD.n274 4.5005
R803 VDDD.n2488 VDDD.n274 4.5005
R804 VDDD.n305 VDDD.n273 4.5005
R805 VDDD.n2488 VDDD.n273 4.5005
R806 VDDD.n305 VDDD.n276 4.5005
R807 VDDD.n285 VDDD.n276 4.5005
R808 VDDD.n281 VDDD.n276 4.5005
R809 VDDD.n288 VDDD.n276 4.5005
R810 VDDD.n280 VDDD.n276 4.5005
R811 VDDD.n2486 VDDD.n276 4.5005
R812 VDDD.n279 VDDD.n276 4.5005
R813 VDDD.n2488 VDDD.n276 4.5005
R814 VDDD.n305 VDDD.n272 4.5005
R815 VDDD.n285 VDDD.n272 4.5005
R816 VDDD.n281 VDDD.n272 4.5005
R817 VDDD.n288 VDDD.n272 4.5005
R818 VDDD.n280 VDDD.n272 4.5005
R819 VDDD.n2486 VDDD.n272 4.5005
R820 VDDD.n2488 VDDD.n272 4.5005
R821 VDDD.n2487 VDDD.n285 4.5005
R822 VDDD.n2487 VDDD.n281 4.5005
R823 VDDD.n2487 VDDD.n288 4.5005
R824 VDDD.n2487 VDDD.n280 4.5005
R825 VDDD.n2487 VDDD.n2486 4.5005
R826 VDDD.n2487 VDDD.n279 4.5005
R827 VDDD.n2488 VDDD.n2487 4.5005
R828 VDDD.n362 VDDD.n348 4.5005
R829 VDDD.n362 VDDD.n349 4.5005
R830 VDDD.n362 VDDD.n350 4.5005
R831 VDDD.n369 VDDD.n362 4.5005
R832 VDDD.n362 VDDD.n353 4.5005
R833 VDDD.n362 VDDD.n354 4.5005
R834 VDDD.n363 VDDD.n362 4.5005
R835 VDDD.n362 VDDD.n357 4.5005
R836 VDDD.n348 VDDD.n283 4.5005
R837 VDDD.n349 VDDD.n283 4.5005
R838 VDDD.n350 VDDD.n283 4.5005
R839 VDDD.n369 VDDD.n283 4.5005
R840 VDDD.n353 VDDD.n283 4.5005
R841 VDDD.n354 VDDD.n283 4.5005
R842 VDDD.n363 VDDD.n283 4.5005
R843 VDDD.n359 VDDD.n349 4.5005
R844 VDDD.n359 VDDD.n350 4.5005
R845 VDDD.n369 VDDD.n359 4.5005
R846 VDDD.n359 VDDD.n353 4.5005
R847 VDDD.n359 VDDD.n354 4.5005
R848 VDDD.n359 VDDD.n355 4.5005
R849 VDDD.n363 VDDD.n359 4.5005
R850 VDDD.n377 VDDD.n359 4.5005
R851 VDDD.n359 VDDD.n357 4.5005
R852 VDDD.n414 VDDD.n413 4.5005
R853 VDDD.n344 VDDD.n336 4.5005
R854 VDDD.n413 VDDD.n336 4.5005
R855 VDDD.n344 VDDD.n339 4.5005
R856 VDDD.n343 VDDD.n339 4.5005
R857 VDDD.n407 VDDD.n339 4.5005
R858 VDDD.n342 VDDD.n339 4.5005
R859 VDDD.n409 VDDD.n339 4.5005
R860 VDDD.n341 VDDD.n339 4.5005
R861 VDDD.n411 VDDD.n339 4.5005
R862 VDDD.n413 VDDD.n339 4.5005
R863 VDDD.n344 VDDD.n335 4.5005
R864 VDDD.n343 VDDD.n335 4.5005
R865 VDDD.n407 VDDD.n335 4.5005
R866 VDDD.n342 VDDD.n335 4.5005
R867 VDDD.n409 VDDD.n335 4.5005
R868 VDDD.n341 VDDD.n335 4.5005
R869 VDDD.n411 VDDD.n335 4.5005
R870 VDDD.n413 VDDD.n335 4.5005
R871 VDDD.n412 VDDD.n343 4.5005
R872 VDDD.n412 VDDD.n407 4.5005
R873 VDDD.n412 VDDD.n342 4.5005
R874 VDDD.n412 VDDD.n409 4.5005
R875 VDDD.n412 VDDD.n341 4.5005
R876 VDDD.n412 VDDD.n411 4.5005
R877 VDDD.n413 VDDD.n412 4.5005
R878 VDDD.n448 VDDD.n446 4.5005
R879 VDDD.n2423 VDDD.n445 4.5005
R880 VDDD.n450 VDDD.n444 4.5005
R881 VDDD.n2417 VDDD.n449 4.5005
R882 VDDD.n2416 VDDD.n2415 4.5005
R883 VDDD.n2414 VDDD.n452 4.5005
R884 VDDD.n432 VDDD.n427 4.5005
R885 VDDD.n2426 VDDD.n427 4.5005
R886 VDDD.n458 VDDD.n426 4.5005
R887 VDDD.n2426 VDDD.n426 4.5005
R888 VDDD.n458 VDDD.n429 4.5005
R889 VDDD.n438 VDDD.n429 4.5005
R890 VDDD.n434 VDDD.n429 4.5005
R891 VDDD.n441 VDDD.n429 4.5005
R892 VDDD.n433 VDDD.n429 4.5005
R893 VDDD.n2424 VDDD.n429 4.5005
R894 VDDD.n432 VDDD.n429 4.5005
R895 VDDD.n2426 VDDD.n429 4.5005
R896 VDDD.n458 VDDD.n425 4.5005
R897 VDDD.n438 VDDD.n425 4.5005
R898 VDDD.n434 VDDD.n425 4.5005
R899 VDDD.n441 VDDD.n425 4.5005
R900 VDDD.n433 VDDD.n425 4.5005
R901 VDDD.n2424 VDDD.n425 4.5005
R902 VDDD.n2426 VDDD.n425 4.5005
R903 VDDD.n2425 VDDD.n438 4.5005
R904 VDDD.n2425 VDDD.n434 4.5005
R905 VDDD.n2425 VDDD.n441 4.5005
R906 VDDD.n2425 VDDD.n433 4.5005
R907 VDDD.n2425 VDDD.n2424 4.5005
R908 VDDD.n2425 VDDD.n432 4.5005
R909 VDDD.n2426 VDDD.n2425 4.5005
R910 VDDD.n515 VDDD.n501 4.5005
R911 VDDD.n515 VDDD.n502 4.5005
R912 VDDD.n515 VDDD.n503 4.5005
R913 VDDD.n522 VDDD.n515 4.5005
R914 VDDD.n515 VDDD.n506 4.5005
R915 VDDD.n515 VDDD.n507 4.5005
R916 VDDD.n516 VDDD.n515 4.5005
R917 VDDD.n515 VDDD.n510 4.5005
R918 VDDD.n501 VDDD.n436 4.5005
R919 VDDD.n502 VDDD.n436 4.5005
R920 VDDD.n503 VDDD.n436 4.5005
R921 VDDD.n522 VDDD.n436 4.5005
R922 VDDD.n506 VDDD.n436 4.5005
R923 VDDD.n507 VDDD.n436 4.5005
R924 VDDD.n516 VDDD.n436 4.5005
R925 VDDD.n512 VDDD.n502 4.5005
R926 VDDD.n512 VDDD.n503 4.5005
R927 VDDD.n522 VDDD.n512 4.5005
R928 VDDD.n512 VDDD.n506 4.5005
R929 VDDD.n512 VDDD.n507 4.5005
R930 VDDD.n512 VDDD.n508 4.5005
R931 VDDD.n516 VDDD.n512 4.5005
R932 VDDD.n530 VDDD.n512 4.5005
R933 VDDD.n512 VDDD.n510 4.5005
R934 VDDD.n567 VDDD.n566 4.5005
R935 VDDD.n497 VDDD.n489 4.5005
R936 VDDD.n566 VDDD.n489 4.5005
R937 VDDD.n497 VDDD.n492 4.5005
R938 VDDD.n496 VDDD.n492 4.5005
R939 VDDD.n560 VDDD.n492 4.5005
R940 VDDD.n495 VDDD.n492 4.5005
R941 VDDD.n562 VDDD.n492 4.5005
R942 VDDD.n494 VDDD.n492 4.5005
R943 VDDD.n564 VDDD.n492 4.5005
R944 VDDD.n566 VDDD.n492 4.5005
R945 VDDD.n497 VDDD.n488 4.5005
R946 VDDD.n496 VDDD.n488 4.5005
R947 VDDD.n560 VDDD.n488 4.5005
R948 VDDD.n495 VDDD.n488 4.5005
R949 VDDD.n562 VDDD.n488 4.5005
R950 VDDD.n494 VDDD.n488 4.5005
R951 VDDD.n564 VDDD.n488 4.5005
R952 VDDD.n566 VDDD.n488 4.5005
R953 VDDD.n565 VDDD.n496 4.5005
R954 VDDD.n565 VDDD.n560 4.5005
R955 VDDD.n565 VDDD.n495 4.5005
R956 VDDD.n565 VDDD.n562 4.5005
R957 VDDD.n565 VDDD.n494 4.5005
R958 VDDD.n565 VDDD.n564 4.5005
R959 VDDD.n566 VDDD.n565 4.5005
R960 VDDD.n601 VDDD.n599 4.5005
R961 VDDD.n2361 VDDD.n598 4.5005
R962 VDDD.n603 VDDD.n597 4.5005
R963 VDDD.n2355 VDDD.n602 4.5005
R964 VDDD.n2354 VDDD.n2353 4.5005
R965 VDDD.n2352 VDDD.n605 4.5005
R966 VDDD.n585 VDDD.n580 4.5005
R967 VDDD.n2364 VDDD.n580 4.5005
R968 VDDD.n611 VDDD.n579 4.5005
R969 VDDD.n2364 VDDD.n579 4.5005
R970 VDDD.n611 VDDD.n582 4.5005
R971 VDDD.n591 VDDD.n582 4.5005
R972 VDDD.n587 VDDD.n582 4.5005
R973 VDDD.n594 VDDD.n582 4.5005
R974 VDDD.n586 VDDD.n582 4.5005
R975 VDDD.n2362 VDDD.n582 4.5005
R976 VDDD.n585 VDDD.n582 4.5005
R977 VDDD.n2364 VDDD.n582 4.5005
R978 VDDD.n611 VDDD.n578 4.5005
R979 VDDD.n591 VDDD.n578 4.5005
R980 VDDD.n587 VDDD.n578 4.5005
R981 VDDD.n594 VDDD.n578 4.5005
R982 VDDD.n586 VDDD.n578 4.5005
R983 VDDD.n2362 VDDD.n578 4.5005
R984 VDDD.n2364 VDDD.n578 4.5005
R985 VDDD.n2363 VDDD.n591 4.5005
R986 VDDD.n2363 VDDD.n587 4.5005
R987 VDDD.n2363 VDDD.n594 4.5005
R988 VDDD.n2363 VDDD.n586 4.5005
R989 VDDD.n2363 VDDD.n2362 4.5005
R990 VDDD.n2363 VDDD.n585 4.5005
R991 VDDD.n2364 VDDD.n2363 4.5005
R992 VDDD.n668 VDDD.n654 4.5005
R993 VDDD.n668 VDDD.n655 4.5005
R994 VDDD.n668 VDDD.n656 4.5005
R995 VDDD.n675 VDDD.n668 4.5005
R996 VDDD.n668 VDDD.n659 4.5005
R997 VDDD.n668 VDDD.n660 4.5005
R998 VDDD.n669 VDDD.n668 4.5005
R999 VDDD.n668 VDDD.n663 4.5005
R1000 VDDD.n654 VDDD.n589 4.5005
R1001 VDDD.n655 VDDD.n589 4.5005
R1002 VDDD.n656 VDDD.n589 4.5005
R1003 VDDD.n675 VDDD.n589 4.5005
R1004 VDDD.n659 VDDD.n589 4.5005
R1005 VDDD.n660 VDDD.n589 4.5005
R1006 VDDD.n669 VDDD.n589 4.5005
R1007 VDDD.n665 VDDD.n655 4.5005
R1008 VDDD.n665 VDDD.n656 4.5005
R1009 VDDD.n675 VDDD.n665 4.5005
R1010 VDDD.n665 VDDD.n659 4.5005
R1011 VDDD.n665 VDDD.n660 4.5005
R1012 VDDD.n665 VDDD.n661 4.5005
R1013 VDDD.n669 VDDD.n665 4.5005
R1014 VDDD.n683 VDDD.n665 4.5005
R1015 VDDD.n665 VDDD.n663 4.5005
R1016 VDDD.n720 VDDD.n719 4.5005
R1017 VDDD.n650 VDDD.n642 4.5005
R1018 VDDD.n719 VDDD.n642 4.5005
R1019 VDDD.n650 VDDD.n645 4.5005
R1020 VDDD.n649 VDDD.n645 4.5005
R1021 VDDD.n713 VDDD.n645 4.5005
R1022 VDDD.n648 VDDD.n645 4.5005
R1023 VDDD.n715 VDDD.n645 4.5005
R1024 VDDD.n647 VDDD.n645 4.5005
R1025 VDDD.n717 VDDD.n645 4.5005
R1026 VDDD.n719 VDDD.n645 4.5005
R1027 VDDD.n650 VDDD.n641 4.5005
R1028 VDDD.n649 VDDD.n641 4.5005
R1029 VDDD.n713 VDDD.n641 4.5005
R1030 VDDD.n648 VDDD.n641 4.5005
R1031 VDDD.n715 VDDD.n641 4.5005
R1032 VDDD.n647 VDDD.n641 4.5005
R1033 VDDD.n717 VDDD.n641 4.5005
R1034 VDDD.n719 VDDD.n641 4.5005
R1035 VDDD.n718 VDDD.n649 4.5005
R1036 VDDD.n718 VDDD.n713 4.5005
R1037 VDDD.n718 VDDD.n648 4.5005
R1038 VDDD.n718 VDDD.n715 4.5005
R1039 VDDD.n718 VDDD.n647 4.5005
R1040 VDDD.n718 VDDD.n717 4.5005
R1041 VDDD.n719 VDDD.n718 4.5005
R1042 VDDD.n754 VDDD.n752 4.5005
R1043 VDDD.n2299 VDDD.n751 4.5005
R1044 VDDD.n756 VDDD.n750 4.5005
R1045 VDDD.n2293 VDDD.n755 4.5005
R1046 VDDD.n2292 VDDD.n2291 4.5005
R1047 VDDD.n2290 VDDD.n758 4.5005
R1048 VDDD.n738 VDDD.n733 4.5005
R1049 VDDD.n2302 VDDD.n733 4.5005
R1050 VDDD.n764 VDDD.n732 4.5005
R1051 VDDD.n2302 VDDD.n732 4.5005
R1052 VDDD.n764 VDDD.n735 4.5005
R1053 VDDD.n744 VDDD.n735 4.5005
R1054 VDDD.n740 VDDD.n735 4.5005
R1055 VDDD.n747 VDDD.n735 4.5005
R1056 VDDD.n739 VDDD.n735 4.5005
R1057 VDDD.n2300 VDDD.n735 4.5005
R1058 VDDD.n738 VDDD.n735 4.5005
R1059 VDDD.n2302 VDDD.n735 4.5005
R1060 VDDD.n764 VDDD.n731 4.5005
R1061 VDDD.n744 VDDD.n731 4.5005
R1062 VDDD.n740 VDDD.n731 4.5005
R1063 VDDD.n747 VDDD.n731 4.5005
R1064 VDDD.n739 VDDD.n731 4.5005
R1065 VDDD.n2300 VDDD.n731 4.5005
R1066 VDDD.n2302 VDDD.n731 4.5005
R1067 VDDD.n2301 VDDD.n744 4.5005
R1068 VDDD.n2301 VDDD.n740 4.5005
R1069 VDDD.n2301 VDDD.n747 4.5005
R1070 VDDD.n2301 VDDD.n739 4.5005
R1071 VDDD.n2301 VDDD.n2300 4.5005
R1072 VDDD.n2301 VDDD.n738 4.5005
R1073 VDDD.n2302 VDDD.n2301 4.5005
R1074 VDDD.n818 VDDD.n804 4.5005
R1075 VDDD.n818 VDDD.n805 4.5005
R1076 VDDD.n818 VDDD.n806 4.5005
R1077 VDDD.n825 VDDD.n818 4.5005
R1078 VDDD.n818 VDDD.n809 4.5005
R1079 VDDD.n818 VDDD.n810 4.5005
R1080 VDDD.n819 VDDD.n818 4.5005
R1081 VDDD.n818 VDDD.n813 4.5005
R1082 VDDD.n804 VDDD.n742 4.5005
R1083 VDDD.n805 VDDD.n742 4.5005
R1084 VDDD.n806 VDDD.n742 4.5005
R1085 VDDD.n825 VDDD.n742 4.5005
R1086 VDDD.n809 VDDD.n742 4.5005
R1087 VDDD.n810 VDDD.n742 4.5005
R1088 VDDD.n819 VDDD.n742 4.5005
R1089 VDDD.n815 VDDD.n805 4.5005
R1090 VDDD.n815 VDDD.n806 4.5005
R1091 VDDD.n825 VDDD.n815 4.5005
R1092 VDDD.n815 VDDD.n809 4.5005
R1093 VDDD.n815 VDDD.n810 4.5005
R1094 VDDD.n815 VDDD.n811 4.5005
R1095 VDDD.n819 VDDD.n815 4.5005
R1096 VDDD.n833 VDDD.n815 4.5005
R1097 VDDD.n815 VDDD.n813 4.5005
R1098 VDDD.n870 VDDD.n869 4.5005
R1099 VDDD.n800 VDDD.n792 4.5005
R1100 VDDD.n869 VDDD.n792 4.5005
R1101 VDDD.n800 VDDD.n795 4.5005
R1102 VDDD.n799 VDDD.n795 4.5005
R1103 VDDD.n863 VDDD.n795 4.5005
R1104 VDDD.n798 VDDD.n795 4.5005
R1105 VDDD.n865 VDDD.n795 4.5005
R1106 VDDD.n797 VDDD.n795 4.5005
R1107 VDDD.n867 VDDD.n795 4.5005
R1108 VDDD.n869 VDDD.n795 4.5005
R1109 VDDD.n800 VDDD.n791 4.5005
R1110 VDDD.n799 VDDD.n791 4.5005
R1111 VDDD.n863 VDDD.n791 4.5005
R1112 VDDD.n798 VDDD.n791 4.5005
R1113 VDDD.n865 VDDD.n791 4.5005
R1114 VDDD.n797 VDDD.n791 4.5005
R1115 VDDD.n867 VDDD.n791 4.5005
R1116 VDDD.n869 VDDD.n791 4.5005
R1117 VDDD.n868 VDDD.n799 4.5005
R1118 VDDD.n868 VDDD.n863 4.5005
R1119 VDDD.n868 VDDD.n798 4.5005
R1120 VDDD.n868 VDDD.n865 4.5005
R1121 VDDD.n868 VDDD.n797 4.5005
R1122 VDDD.n868 VDDD.n867 4.5005
R1123 VDDD.n869 VDDD.n868 4.5005
R1124 VDDD.n1452 VDDD.n1451 4.5005
R1125 VDDD.n1451 VDDD.n1383 4.5005
R1126 VDDD.n1451 VDDD.n1450 4.5005
R1127 VDDD.n1451 VDDD.n0 4.5005
R1128 VDDD.n1395 VDDD.n1382 4.5005
R1129 VDDD.n1395 VDDD.n1386 4.5005
R1130 VDDD.n1450 VDDD.n1395 4.5005
R1131 VDDD.n1395 VDDD.n0 4.5005
R1132 VDDD.n1448 VDDD.n1381 4.5005
R1133 VDDD.n1448 VDDD.n1397 4.5005
R1134 VDDD.n1448 VDDD.n0 4.5005
R1135 VDDD.n1389 VDDD.n1381 4.5005
R1136 VDDD.n1452 VDDD.n1389 4.5005
R1137 VDDD.n1389 VDDD.n1382 4.5005
R1138 VDDD.n1389 VDDD.n1386 4.5005
R1139 VDDD.n1389 VDDD.n1383 4.5005
R1140 VDDD.n1450 VDDD.n1389 4.5005
R1141 VDDD.n1453 VDDD.n0 4.5005
R1142 VDDD.n1453 VDDD.n1385 4.5005
R1143 VDDD.n1453 VDDD.n1383 4.5005
R1144 VDDD.n1453 VDDD.n1386 4.5005
R1145 VDDD.n1453 VDDD.n1382 4.5005
R1146 VDDD.n1453 VDDD.n1452 4.5005
R1147 VDDD.n1453 VDDD.n1381 4.5005
R1148 VDDD.n1457 VDDD.n1370 4.5005
R1149 VDDD.n1370 VDDD.n1362 4.5005
R1150 VDDD.n1369 VDDD.n1362 4.5005
R1151 VDDD.n1459 VDDD.n1362 4.5005
R1152 VDDD.n1461 VDDD.n1362 4.5005
R1153 VDDD.n1370 VDDD.n1364 4.5005
R1154 VDDD.n1375 VDDD.n1364 4.5005
R1155 VDDD.n1368 VDDD.n1364 4.5005
R1156 VDDD.n1377 VDDD.n1364 4.5005
R1157 VDDD.n1459 VDDD.n1364 4.5005
R1158 VDDD.n1461 VDDD.n1364 4.5005
R1159 VDDD.n1369 VDDD.n1361 4.5005
R1160 VDDD.n1375 VDDD.n1361 4.5005
R1161 VDDD.n1368 VDDD.n1361 4.5005
R1162 VDDD.n1377 VDDD.n1361 4.5005
R1163 VDDD.n1459 VDDD.n1361 4.5005
R1164 VDDD.n1461 VDDD.n1361 4.5005
R1165 VDDD.n1460 VDDD.n1370 4.5005
R1166 VDDD.n1460 VDDD.n1373 4.5005
R1167 VDDD.n1460 VDDD.n1369 4.5005
R1168 VDDD.n1460 VDDD.n1375 4.5005
R1169 VDDD.n1460 VDDD.n1368 4.5005
R1170 VDDD.n1460 VDDD.n1377 4.5005
R1171 VDDD.n1460 VDDD.n1367 4.5005
R1172 VDDD.n1460 VDDD.n1459 4.5005
R1173 VDDD.n1461 VDDD.n1460 4.5005
R1174 VDDD.n1351 VDDD.n1346 4.5005
R1175 VDDD.n1487 VDDD.n1346 4.5005
R1176 VDDD.n1341 VDDD.n1335 4.5005
R1177 VDDD.n1487 VDDD.n1341 4.5005
R1178 VDDD.n1348 VDDD.n1335 4.5005
R1179 VDDD.n1348 VDDD.n1333 4.5005
R1180 VDDD.n1348 VDDD.n1336 4.5005
R1181 VDDD.n1348 VDDD.n1332 4.5005
R1182 VDDD.n1348 VDDD.n1337 4.5005
R1183 VDDD.n1348 VDDD.n1331 4.5005
R1184 VDDD.n1351 VDDD.n1348 4.5005
R1185 VDDD.n1487 VDDD.n1348 4.5005
R1186 VDDD.n1488 VDDD.n1335 4.5005
R1187 VDDD.n1488 VDDD.n1333 4.5005
R1188 VDDD.n1488 VDDD.n1336 4.5005
R1189 VDDD.n1488 VDDD.n1332 4.5005
R1190 VDDD.n1488 VDDD.n1337 4.5005
R1191 VDDD.n1488 VDDD.n1331 4.5005
R1192 VDDD.n1488 VDDD.n1487 4.5005
R1193 VDDD.n1486 VDDD.n1333 4.5005
R1194 VDDD.n1486 VDDD.n1336 4.5005
R1195 VDDD.n1486 VDDD.n1332 4.5005
R1196 VDDD.n1486 VDDD.n1337 4.5005
R1197 VDDD.n1486 VDDD.n1331 4.5005
R1198 VDDD.n1486 VDDD.n1351 4.5005
R1199 VDDD.n1487 VDDD.n1486 4.5005
R1200 VDDD.n1490 VDDD.n1315 4.5005
R1201 VDDD.n1494 VDDD.n1490 4.5005
R1202 VDDD.n1490 VDDD.n1318 4.5005
R1203 VDDD.n1508 VDDD.n1490 4.5005
R1204 VDDD.n1490 VDDD.n1321 4.5005
R1205 VDDD.n1490 VDDD.n1322 4.5005
R1206 VDDD.n1490 VDDD.n1326 4.5005
R1207 VDDD.n1511 VDDD.n1490 4.5005
R1208 VDDD.n1509 VDDD.n1315 4.5005
R1209 VDDD.n1509 VDDD.n1494 4.5005
R1210 VDDD.n1509 VDDD.n1318 4.5005
R1211 VDDD.n1509 VDDD.n1508 4.5005
R1212 VDDD.n1509 VDDD.n1321 4.5005
R1213 VDDD.n1509 VDDD.n1322 4.5005
R1214 VDDD.n1509 VDDD.n1326 4.5005
R1215 VDDD.n1494 VDDD.n1489 4.5005
R1216 VDDD.n1489 VDDD.n1318 4.5005
R1217 VDDD.n1508 VDDD.n1489 4.5005
R1218 VDDD.n1489 VDDD.n1321 4.5005
R1219 VDDD.n1489 VDDD.n1322 4.5005
R1220 VDDD.n1502 VDDD.n1489 4.5005
R1221 VDDD.n1489 VDDD.n1326 4.5005
R1222 VDDD.n1492 VDDD.n1489 4.5005
R1223 VDDD.n1511 VDDD.n1489 4.5005
R1224 VDDD.n1515 VDDD.n1514 4.5005
R1225 VDDD.n1328 VDDD.n1323 4.5005
R1226 VDDD.n1519 VDDD.n1324 4.5005
R1227 VDDD.n1521 VDDD.n1520 4.5005
R1228 VDDD.n1319 VDDD.n1317 4.5005
R1229 VDDD.n1526 VDDD.n1525 4.5005
R1230 VDDD.n1598 VDDD.n1597 4.5005
R1231 VDDD.n1597 VDDD.n1312 4.5005
R1232 VDDD.n1597 VDDD.n1596 4.5005
R1233 VDDD.n1597 VDDD.n1530 4.5005
R1234 VDDD.n1541 VDDD.n1311 4.5005
R1235 VDDD.n1541 VDDD.n1532 4.5005
R1236 VDDD.n1596 VDDD.n1541 4.5005
R1237 VDDD.n1541 VDDD.n1530 4.5005
R1238 VDDD.n1594 VDDD.n1310 4.5005
R1239 VDDD.n1594 VDDD.n1543 4.5005
R1240 VDDD.n1594 VDDD.n1530 4.5005
R1241 VDDD.n1535 VDDD.n1310 4.5005
R1242 VDDD.n1598 VDDD.n1535 4.5005
R1243 VDDD.n1535 VDDD.n1311 4.5005
R1244 VDDD.n1535 VDDD.n1532 4.5005
R1245 VDDD.n1535 VDDD.n1312 4.5005
R1246 VDDD.n1596 VDDD.n1535 4.5005
R1247 VDDD.n1599 VDDD.n1530 4.5005
R1248 VDDD.n1599 VDDD.n1531 4.5005
R1249 VDDD.n1599 VDDD.n1312 4.5005
R1250 VDDD.n1599 VDDD.n1532 4.5005
R1251 VDDD.n1599 VDDD.n1311 4.5005
R1252 VDDD.n1599 VDDD.n1598 4.5005
R1253 VDDD.n1599 VDDD.n1310 4.5005
R1254 VDDD.n1603 VDDD.n1299 4.5005
R1255 VDDD.n1299 VDDD.n1291 4.5005
R1256 VDDD.n1298 VDDD.n1291 4.5005
R1257 VDDD.n1605 VDDD.n1291 4.5005
R1258 VDDD.n1607 VDDD.n1291 4.5005
R1259 VDDD.n1299 VDDD.n1293 4.5005
R1260 VDDD.n1304 VDDD.n1293 4.5005
R1261 VDDD.n1297 VDDD.n1293 4.5005
R1262 VDDD.n1306 VDDD.n1293 4.5005
R1263 VDDD.n1605 VDDD.n1293 4.5005
R1264 VDDD.n1607 VDDD.n1293 4.5005
R1265 VDDD.n1298 VDDD.n1290 4.5005
R1266 VDDD.n1304 VDDD.n1290 4.5005
R1267 VDDD.n1297 VDDD.n1290 4.5005
R1268 VDDD.n1306 VDDD.n1290 4.5005
R1269 VDDD.n1605 VDDD.n1290 4.5005
R1270 VDDD.n1607 VDDD.n1290 4.5005
R1271 VDDD.n1606 VDDD.n1299 4.5005
R1272 VDDD.n1606 VDDD.n1302 4.5005
R1273 VDDD.n1606 VDDD.n1298 4.5005
R1274 VDDD.n1606 VDDD.n1304 4.5005
R1275 VDDD.n1606 VDDD.n1297 4.5005
R1276 VDDD.n1606 VDDD.n1306 4.5005
R1277 VDDD.n1606 VDDD.n1296 4.5005
R1278 VDDD.n1606 VDDD.n1605 4.5005
R1279 VDDD.n1607 VDDD.n1606 4.5005
R1280 VDDD.n1280 VDDD.n1275 4.5005
R1281 VDDD.n1633 VDDD.n1275 4.5005
R1282 VDDD.n1270 VDDD.n1264 4.5005
R1283 VDDD.n1633 VDDD.n1270 4.5005
R1284 VDDD.n1277 VDDD.n1264 4.5005
R1285 VDDD.n1277 VDDD.n1262 4.5005
R1286 VDDD.n1277 VDDD.n1265 4.5005
R1287 VDDD.n1277 VDDD.n1261 4.5005
R1288 VDDD.n1277 VDDD.n1266 4.5005
R1289 VDDD.n1277 VDDD.n1260 4.5005
R1290 VDDD.n1280 VDDD.n1277 4.5005
R1291 VDDD.n1633 VDDD.n1277 4.5005
R1292 VDDD.n1634 VDDD.n1264 4.5005
R1293 VDDD.n1634 VDDD.n1262 4.5005
R1294 VDDD.n1634 VDDD.n1265 4.5005
R1295 VDDD.n1634 VDDD.n1261 4.5005
R1296 VDDD.n1634 VDDD.n1266 4.5005
R1297 VDDD.n1634 VDDD.n1260 4.5005
R1298 VDDD.n1634 VDDD.n1633 4.5005
R1299 VDDD.n1632 VDDD.n1262 4.5005
R1300 VDDD.n1632 VDDD.n1265 4.5005
R1301 VDDD.n1632 VDDD.n1261 4.5005
R1302 VDDD.n1632 VDDD.n1266 4.5005
R1303 VDDD.n1632 VDDD.n1260 4.5005
R1304 VDDD.n1632 VDDD.n1280 4.5005
R1305 VDDD.n1633 VDDD.n1632 4.5005
R1306 VDDD.n1636 VDDD.n1244 4.5005
R1307 VDDD.n1640 VDDD.n1636 4.5005
R1308 VDDD.n1636 VDDD.n1247 4.5005
R1309 VDDD.n1654 VDDD.n1636 4.5005
R1310 VDDD.n1636 VDDD.n1250 4.5005
R1311 VDDD.n1636 VDDD.n1251 4.5005
R1312 VDDD.n1636 VDDD.n1255 4.5005
R1313 VDDD.n1657 VDDD.n1636 4.5005
R1314 VDDD.n1655 VDDD.n1244 4.5005
R1315 VDDD.n1655 VDDD.n1640 4.5005
R1316 VDDD.n1655 VDDD.n1247 4.5005
R1317 VDDD.n1655 VDDD.n1654 4.5005
R1318 VDDD.n1655 VDDD.n1250 4.5005
R1319 VDDD.n1655 VDDD.n1251 4.5005
R1320 VDDD.n1655 VDDD.n1255 4.5005
R1321 VDDD.n1640 VDDD.n1635 4.5005
R1322 VDDD.n1635 VDDD.n1247 4.5005
R1323 VDDD.n1654 VDDD.n1635 4.5005
R1324 VDDD.n1635 VDDD.n1250 4.5005
R1325 VDDD.n1635 VDDD.n1251 4.5005
R1326 VDDD.n1648 VDDD.n1635 4.5005
R1327 VDDD.n1635 VDDD.n1255 4.5005
R1328 VDDD.n1638 VDDD.n1635 4.5005
R1329 VDDD.n1657 VDDD.n1635 4.5005
R1330 VDDD.n1661 VDDD.n1660 4.5005
R1331 VDDD.n1257 VDDD.n1252 4.5005
R1332 VDDD.n1665 VDDD.n1253 4.5005
R1333 VDDD.n1667 VDDD.n1666 4.5005
R1334 VDDD.n1248 VDDD.n1246 4.5005
R1335 VDDD.n1672 VDDD.n1671 4.5005
R1336 VDDD.n1744 VDDD.n1743 4.5005
R1337 VDDD.n1743 VDDD.n1241 4.5005
R1338 VDDD.n1743 VDDD.n1742 4.5005
R1339 VDDD.n1743 VDDD.n1676 4.5005
R1340 VDDD.n1687 VDDD.n1240 4.5005
R1341 VDDD.n1687 VDDD.n1678 4.5005
R1342 VDDD.n1742 VDDD.n1687 4.5005
R1343 VDDD.n1687 VDDD.n1676 4.5005
R1344 VDDD.n1740 VDDD.n1239 4.5005
R1345 VDDD.n1740 VDDD.n1689 4.5005
R1346 VDDD.n1740 VDDD.n1676 4.5005
R1347 VDDD.n1681 VDDD.n1239 4.5005
R1348 VDDD.n1744 VDDD.n1681 4.5005
R1349 VDDD.n1681 VDDD.n1240 4.5005
R1350 VDDD.n1681 VDDD.n1678 4.5005
R1351 VDDD.n1681 VDDD.n1241 4.5005
R1352 VDDD.n1742 VDDD.n1681 4.5005
R1353 VDDD.n1745 VDDD.n1676 4.5005
R1354 VDDD.n1745 VDDD.n1677 4.5005
R1355 VDDD.n1745 VDDD.n1241 4.5005
R1356 VDDD.n1745 VDDD.n1678 4.5005
R1357 VDDD.n1745 VDDD.n1240 4.5005
R1358 VDDD.n1745 VDDD.n1744 4.5005
R1359 VDDD.n1745 VDDD.n1239 4.5005
R1360 VDDD.n1749 VDDD.n1228 4.5005
R1361 VDDD.n1228 VDDD.n1220 4.5005
R1362 VDDD.n1227 VDDD.n1220 4.5005
R1363 VDDD.n1751 VDDD.n1220 4.5005
R1364 VDDD.n1753 VDDD.n1220 4.5005
R1365 VDDD.n1228 VDDD.n1222 4.5005
R1366 VDDD.n1233 VDDD.n1222 4.5005
R1367 VDDD.n1226 VDDD.n1222 4.5005
R1368 VDDD.n1235 VDDD.n1222 4.5005
R1369 VDDD.n1751 VDDD.n1222 4.5005
R1370 VDDD.n1753 VDDD.n1222 4.5005
R1371 VDDD.n1227 VDDD.n1219 4.5005
R1372 VDDD.n1233 VDDD.n1219 4.5005
R1373 VDDD.n1226 VDDD.n1219 4.5005
R1374 VDDD.n1235 VDDD.n1219 4.5005
R1375 VDDD.n1751 VDDD.n1219 4.5005
R1376 VDDD.n1753 VDDD.n1219 4.5005
R1377 VDDD.n1752 VDDD.n1228 4.5005
R1378 VDDD.n1752 VDDD.n1231 4.5005
R1379 VDDD.n1752 VDDD.n1227 4.5005
R1380 VDDD.n1752 VDDD.n1233 4.5005
R1381 VDDD.n1752 VDDD.n1226 4.5005
R1382 VDDD.n1752 VDDD.n1235 4.5005
R1383 VDDD.n1752 VDDD.n1225 4.5005
R1384 VDDD.n1752 VDDD.n1751 4.5005
R1385 VDDD.n1753 VDDD.n1752 4.5005
R1386 VDDD.n1209 VDDD.n1204 4.5005
R1387 VDDD.n1779 VDDD.n1204 4.5005
R1388 VDDD.n1199 VDDD.n1193 4.5005
R1389 VDDD.n1779 VDDD.n1199 4.5005
R1390 VDDD.n1206 VDDD.n1193 4.5005
R1391 VDDD.n1206 VDDD.n1191 4.5005
R1392 VDDD.n1206 VDDD.n1194 4.5005
R1393 VDDD.n1206 VDDD.n1190 4.5005
R1394 VDDD.n1206 VDDD.n1195 4.5005
R1395 VDDD.n1206 VDDD.n1189 4.5005
R1396 VDDD.n1209 VDDD.n1206 4.5005
R1397 VDDD.n1779 VDDD.n1206 4.5005
R1398 VDDD.n1780 VDDD.n1193 4.5005
R1399 VDDD.n1780 VDDD.n1191 4.5005
R1400 VDDD.n1780 VDDD.n1194 4.5005
R1401 VDDD.n1780 VDDD.n1190 4.5005
R1402 VDDD.n1780 VDDD.n1195 4.5005
R1403 VDDD.n1780 VDDD.n1189 4.5005
R1404 VDDD.n1780 VDDD.n1779 4.5005
R1405 VDDD.n1778 VDDD.n1191 4.5005
R1406 VDDD.n1778 VDDD.n1194 4.5005
R1407 VDDD.n1778 VDDD.n1190 4.5005
R1408 VDDD.n1778 VDDD.n1195 4.5005
R1409 VDDD.n1778 VDDD.n1189 4.5005
R1410 VDDD.n1778 VDDD.n1209 4.5005
R1411 VDDD.n1779 VDDD.n1778 4.5005
R1412 VDDD.n1782 VDDD.n1173 4.5005
R1413 VDDD.n1786 VDDD.n1782 4.5005
R1414 VDDD.n1782 VDDD.n1176 4.5005
R1415 VDDD.n1800 VDDD.n1782 4.5005
R1416 VDDD.n1782 VDDD.n1179 4.5005
R1417 VDDD.n1782 VDDD.n1180 4.5005
R1418 VDDD.n1782 VDDD.n1184 4.5005
R1419 VDDD.n1803 VDDD.n1782 4.5005
R1420 VDDD.n1801 VDDD.n1173 4.5005
R1421 VDDD.n1801 VDDD.n1786 4.5005
R1422 VDDD.n1801 VDDD.n1176 4.5005
R1423 VDDD.n1801 VDDD.n1800 4.5005
R1424 VDDD.n1801 VDDD.n1179 4.5005
R1425 VDDD.n1801 VDDD.n1180 4.5005
R1426 VDDD.n1801 VDDD.n1184 4.5005
R1427 VDDD.n1786 VDDD.n1781 4.5005
R1428 VDDD.n1781 VDDD.n1176 4.5005
R1429 VDDD.n1800 VDDD.n1781 4.5005
R1430 VDDD.n1781 VDDD.n1179 4.5005
R1431 VDDD.n1781 VDDD.n1180 4.5005
R1432 VDDD.n1794 VDDD.n1781 4.5005
R1433 VDDD.n1781 VDDD.n1184 4.5005
R1434 VDDD.n1784 VDDD.n1781 4.5005
R1435 VDDD.n1803 VDDD.n1781 4.5005
R1436 VDDD.n1807 VDDD.n1806 4.5005
R1437 VDDD.n1186 VDDD.n1181 4.5005
R1438 VDDD.n1811 VDDD.n1182 4.5005
R1439 VDDD.n1813 VDDD.n1812 4.5005
R1440 VDDD.n1177 VDDD.n1175 4.5005
R1441 VDDD.n1818 VDDD.n1817 4.5005
R1442 VDDD.n1890 VDDD.n1889 4.5005
R1443 VDDD.n1889 VDDD.n1170 4.5005
R1444 VDDD.n1889 VDDD.n1888 4.5005
R1445 VDDD.n1889 VDDD.n1822 4.5005
R1446 VDDD.n1833 VDDD.n1169 4.5005
R1447 VDDD.n1833 VDDD.n1824 4.5005
R1448 VDDD.n1888 VDDD.n1833 4.5005
R1449 VDDD.n1833 VDDD.n1822 4.5005
R1450 VDDD.n1886 VDDD.n1168 4.5005
R1451 VDDD.n1886 VDDD.n1835 4.5005
R1452 VDDD.n1886 VDDD.n1822 4.5005
R1453 VDDD.n1827 VDDD.n1168 4.5005
R1454 VDDD.n1890 VDDD.n1827 4.5005
R1455 VDDD.n1827 VDDD.n1169 4.5005
R1456 VDDD.n1827 VDDD.n1824 4.5005
R1457 VDDD.n1827 VDDD.n1170 4.5005
R1458 VDDD.n1888 VDDD.n1827 4.5005
R1459 VDDD.n1891 VDDD.n1822 4.5005
R1460 VDDD.n1891 VDDD.n1823 4.5005
R1461 VDDD.n1891 VDDD.n1170 4.5005
R1462 VDDD.n1891 VDDD.n1824 4.5005
R1463 VDDD.n1891 VDDD.n1169 4.5005
R1464 VDDD.n1891 VDDD.n1890 4.5005
R1465 VDDD.n1891 VDDD.n1168 4.5005
R1466 VDDD.n1895 VDDD.n1157 4.5005
R1467 VDDD.n1157 VDDD.n1149 4.5005
R1468 VDDD.n1156 VDDD.n1149 4.5005
R1469 VDDD.n1897 VDDD.n1149 4.5005
R1470 VDDD.n1899 VDDD.n1149 4.5005
R1471 VDDD.n1157 VDDD.n1151 4.5005
R1472 VDDD.n1162 VDDD.n1151 4.5005
R1473 VDDD.n1155 VDDD.n1151 4.5005
R1474 VDDD.n1164 VDDD.n1151 4.5005
R1475 VDDD.n1897 VDDD.n1151 4.5005
R1476 VDDD.n1899 VDDD.n1151 4.5005
R1477 VDDD.n1156 VDDD.n1148 4.5005
R1478 VDDD.n1162 VDDD.n1148 4.5005
R1479 VDDD.n1155 VDDD.n1148 4.5005
R1480 VDDD.n1164 VDDD.n1148 4.5005
R1481 VDDD.n1897 VDDD.n1148 4.5005
R1482 VDDD.n1899 VDDD.n1148 4.5005
R1483 VDDD.n1898 VDDD.n1157 4.5005
R1484 VDDD.n1898 VDDD.n1160 4.5005
R1485 VDDD.n1898 VDDD.n1156 4.5005
R1486 VDDD.n1898 VDDD.n1162 4.5005
R1487 VDDD.n1898 VDDD.n1155 4.5005
R1488 VDDD.n1898 VDDD.n1164 4.5005
R1489 VDDD.n1898 VDDD.n1154 4.5005
R1490 VDDD.n1898 VDDD.n1897 4.5005
R1491 VDDD.n1899 VDDD.n1898 4.5005
R1492 VDDD.n1138 VDDD.n1133 4.5005
R1493 VDDD.n1925 VDDD.n1133 4.5005
R1494 VDDD.n1128 VDDD.n1122 4.5005
R1495 VDDD.n1925 VDDD.n1128 4.5005
R1496 VDDD.n1135 VDDD.n1122 4.5005
R1497 VDDD.n1135 VDDD.n1120 4.5005
R1498 VDDD.n1135 VDDD.n1123 4.5005
R1499 VDDD.n1135 VDDD.n1119 4.5005
R1500 VDDD.n1135 VDDD.n1124 4.5005
R1501 VDDD.n1135 VDDD.n1118 4.5005
R1502 VDDD.n1138 VDDD.n1135 4.5005
R1503 VDDD.n1925 VDDD.n1135 4.5005
R1504 VDDD.n1926 VDDD.n1122 4.5005
R1505 VDDD.n1926 VDDD.n1120 4.5005
R1506 VDDD.n1926 VDDD.n1123 4.5005
R1507 VDDD.n1926 VDDD.n1119 4.5005
R1508 VDDD.n1926 VDDD.n1124 4.5005
R1509 VDDD.n1926 VDDD.n1118 4.5005
R1510 VDDD.n1926 VDDD.n1925 4.5005
R1511 VDDD.n1924 VDDD.n1120 4.5005
R1512 VDDD.n1924 VDDD.n1123 4.5005
R1513 VDDD.n1924 VDDD.n1119 4.5005
R1514 VDDD.n1924 VDDD.n1124 4.5005
R1515 VDDD.n1924 VDDD.n1118 4.5005
R1516 VDDD.n1924 VDDD.n1138 4.5005
R1517 VDDD.n1925 VDDD.n1924 4.5005
R1518 VDDD.n1928 VDDD.n1102 4.5005
R1519 VDDD.n1932 VDDD.n1928 4.5005
R1520 VDDD.n1928 VDDD.n1105 4.5005
R1521 VDDD.n1946 VDDD.n1928 4.5005
R1522 VDDD.n1928 VDDD.n1108 4.5005
R1523 VDDD.n1928 VDDD.n1109 4.5005
R1524 VDDD.n1928 VDDD.n1113 4.5005
R1525 VDDD.n1949 VDDD.n1928 4.5005
R1526 VDDD.n1947 VDDD.n1102 4.5005
R1527 VDDD.n1947 VDDD.n1932 4.5005
R1528 VDDD.n1947 VDDD.n1105 4.5005
R1529 VDDD.n1947 VDDD.n1946 4.5005
R1530 VDDD.n1947 VDDD.n1108 4.5005
R1531 VDDD.n1947 VDDD.n1109 4.5005
R1532 VDDD.n1947 VDDD.n1113 4.5005
R1533 VDDD.n1932 VDDD.n1927 4.5005
R1534 VDDD.n1927 VDDD.n1105 4.5005
R1535 VDDD.n1946 VDDD.n1927 4.5005
R1536 VDDD.n1927 VDDD.n1108 4.5005
R1537 VDDD.n1927 VDDD.n1109 4.5005
R1538 VDDD.n1940 VDDD.n1927 4.5005
R1539 VDDD.n1927 VDDD.n1113 4.5005
R1540 VDDD.n1930 VDDD.n1927 4.5005
R1541 VDDD.n1949 VDDD.n1927 4.5005
R1542 VDDD.n1953 VDDD.n1952 4.5005
R1543 VDDD.n1115 VDDD.n1110 4.5005
R1544 VDDD.n1957 VDDD.n1111 4.5005
R1545 VDDD.n1959 VDDD.n1958 4.5005
R1546 VDDD.n1106 VDDD.n1104 4.5005
R1547 VDDD.n1964 VDDD.n1963 4.5005
R1548 VDDD.n2020 VDDD.n1089 4.5005
R1549 VDDD.n2021 VDDD.n2020 4.5005
R1550 VDDD.n1100 VDDD.n1086 4.5005
R1551 VDDD.n2021 VDDD.n1100 4.5005
R1552 VDDD.n2023 VDDD.n2022 4.5005
R1553 VDDD.n2022 VDDD.n1087 4.5005
R1554 VDDD.n2022 VDDD.n1092 4.5005
R1555 VDDD.n2022 VDDD.n1088 4.5005
R1556 VDDD.n2022 VDDD.n1091 4.5005
R1557 VDDD.n2022 VDDD.n1089 4.5005
R1558 VDDD.n2022 VDDD.n2021 4.5005
R1559 VDDD.n1094 VDDD.n1086 4.5005
R1560 VDDD.n2023 VDDD.n1094 4.5005
R1561 VDDD.n1094 VDDD.n1087 4.5005
R1562 VDDD.n1094 VDDD.n1092 4.5005
R1563 VDDD.n1094 VDDD.n1088 4.5005
R1564 VDDD.n1094 VDDD.n1091 4.5005
R1565 VDDD.n1094 VDDD.n1089 4.5005
R1566 VDDD.n2021 VDDD.n1094 4.5005
R1567 VDDD.n2024 VDDD.n1089 4.5005
R1568 VDDD.n2024 VDDD.n1091 4.5005
R1569 VDDD.n2024 VDDD.n1088 4.5005
R1570 VDDD.n2024 VDDD.n1092 4.5005
R1571 VDDD.n2024 VDDD.n1087 4.5005
R1572 VDDD.n2024 VDDD.n2023 4.5005
R1573 VDDD.n2024 VDDD.n1086 4.5005
R1574 VDDD.n2028 VDDD.n1075 4.5005
R1575 VDDD.n1075 VDDD.n1067 4.5005
R1576 VDDD.n1074 VDDD.n1067 4.5005
R1577 VDDD.n2030 VDDD.n1067 4.5005
R1578 VDDD.n2032 VDDD.n1067 4.5005
R1579 VDDD.n1075 VDDD.n1069 4.5005
R1580 VDDD.n1080 VDDD.n1069 4.5005
R1581 VDDD.n1073 VDDD.n1069 4.5005
R1582 VDDD.n1082 VDDD.n1069 4.5005
R1583 VDDD.n2030 VDDD.n1069 4.5005
R1584 VDDD.n2032 VDDD.n1069 4.5005
R1585 VDDD.n1074 VDDD.n1066 4.5005
R1586 VDDD.n1080 VDDD.n1066 4.5005
R1587 VDDD.n1073 VDDD.n1066 4.5005
R1588 VDDD.n1082 VDDD.n1066 4.5005
R1589 VDDD.n2030 VDDD.n1066 4.5005
R1590 VDDD.n2032 VDDD.n1066 4.5005
R1591 VDDD.n2031 VDDD.n1075 4.5005
R1592 VDDD.n2031 VDDD.n1078 4.5005
R1593 VDDD.n2031 VDDD.n1074 4.5005
R1594 VDDD.n2031 VDDD.n1080 4.5005
R1595 VDDD.n2031 VDDD.n1073 4.5005
R1596 VDDD.n2031 VDDD.n1082 4.5005
R1597 VDDD.n2031 VDDD.n1072 4.5005
R1598 VDDD.n2031 VDDD.n2030 4.5005
R1599 VDDD.n2032 VDDD.n2031 4.5005
R1600 VDDD.n1056 VDDD.n1051 4.5005
R1601 VDDD.n2058 VDDD.n1051 4.5005
R1602 VDDD.n1046 VDDD.n1040 4.5005
R1603 VDDD.n2058 VDDD.n1046 4.5005
R1604 VDDD.n1053 VDDD.n1040 4.5005
R1605 VDDD.n1053 VDDD.n1038 4.5005
R1606 VDDD.n1053 VDDD.n1041 4.5005
R1607 VDDD.n1053 VDDD.n1037 4.5005
R1608 VDDD.n1053 VDDD.n1042 4.5005
R1609 VDDD.n1053 VDDD.n1036 4.5005
R1610 VDDD.n1056 VDDD.n1053 4.5005
R1611 VDDD.n2058 VDDD.n1053 4.5005
R1612 VDDD.n2059 VDDD.n1040 4.5005
R1613 VDDD.n2059 VDDD.n1038 4.5005
R1614 VDDD.n2059 VDDD.n1041 4.5005
R1615 VDDD.n2059 VDDD.n1037 4.5005
R1616 VDDD.n2059 VDDD.n1042 4.5005
R1617 VDDD.n2059 VDDD.n1036 4.5005
R1618 VDDD.n2059 VDDD.n2058 4.5005
R1619 VDDD.n2057 VDDD.n1038 4.5005
R1620 VDDD.n2057 VDDD.n1041 4.5005
R1621 VDDD.n2057 VDDD.n1037 4.5005
R1622 VDDD.n2057 VDDD.n1042 4.5005
R1623 VDDD.n2057 VDDD.n1036 4.5005
R1624 VDDD.n2057 VDDD.n1056 4.5005
R1625 VDDD.n2058 VDDD.n2057 4.5005
R1626 VDDD.n2061 VDDD.n1020 4.5005
R1627 VDDD.n2065 VDDD.n2061 4.5005
R1628 VDDD.n2061 VDDD.n1023 4.5005
R1629 VDDD.n2079 VDDD.n2061 4.5005
R1630 VDDD.n2061 VDDD.n1026 4.5005
R1631 VDDD.n2061 VDDD.n1027 4.5005
R1632 VDDD.n2061 VDDD.n1031 4.5005
R1633 VDDD.n2082 VDDD.n2061 4.5005
R1634 VDDD.n2080 VDDD.n1020 4.5005
R1635 VDDD.n2080 VDDD.n2065 4.5005
R1636 VDDD.n2080 VDDD.n1023 4.5005
R1637 VDDD.n2080 VDDD.n2079 4.5005
R1638 VDDD.n2080 VDDD.n1026 4.5005
R1639 VDDD.n2080 VDDD.n1027 4.5005
R1640 VDDD.n2080 VDDD.n1031 4.5005
R1641 VDDD.n2065 VDDD.n2060 4.5005
R1642 VDDD.n2060 VDDD.n1023 4.5005
R1643 VDDD.n2079 VDDD.n2060 4.5005
R1644 VDDD.n2060 VDDD.n1026 4.5005
R1645 VDDD.n2060 VDDD.n1027 4.5005
R1646 VDDD.n2073 VDDD.n2060 4.5005
R1647 VDDD.n2060 VDDD.n1031 4.5005
R1648 VDDD.n2063 VDDD.n2060 4.5005
R1649 VDDD.n2082 VDDD.n2060 4.5005
R1650 VDDD.n2086 VDDD.n2085 4.5005
R1651 VDDD.n1033 VDDD.n1028 4.5005
R1652 VDDD.n2090 VDDD.n1029 4.5005
R1653 VDDD.n2092 VDDD.n2091 4.5005
R1654 VDDD.n1024 VDDD.n1022 4.5005
R1655 VDDD.n2097 VDDD.n2096 4.5005
R1656 VDDD.n1012 VDDD.n1011 4.5005
R1657 VDDD.n1011 VDDD.n934 4.5005
R1658 VDDD.n1011 VDDD.n887 4.5005
R1659 VDDD.n1011 VDDD.n886 4.5005
R1660 VDDD.n1011 VDDD.n911 4.5005
R1661 VDDD.n952 VDDD.n910 4.5005
R1662 VDDD.n952 VDDD.n886 4.5005
R1663 VDDD.n952 VDDD.n911 4.5005
R1664 VDDD.n940 VDDD.n934 4.5005
R1665 VDDD.n940 VDDD.n898 4.5005
R1666 VDDD.n940 VDDD.n900 4.5005
R1667 VDDD.n940 VDDD.n897 4.5005
R1668 VDDD.n940 VDDD.n901 4.5005
R1669 VDDD.n940 VDDD.n896 4.5005
R1670 VDDD.n940 VDDD.n902 4.5005
R1671 VDDD.n940 VDDD.n895 4.5005
R1672 VDDD.n940 VDDD.n903 4.5005
R1673 VDDD.n940 VDDD.n894 4.5005
R1674 VDDD.n940 VDDD.n904 4.5005
R1675 VDDD.n940 VDDD.n893 4.5005
R1676 VDDD.n940 VDDD.n905 4.5005
R1677 VDDD.n940 VDDD.n892 4.5005
R1678 VDDD.n940 VDDD.n906 4.5005
R1679 VDDD.n940 VDDD.n891 4.5005
R1680 VDDD.n940 VDDD.n907 4.5005
R1681 VDDD.n940 VDDD.n890 4.5005
R1682 VDDD.n940 VDDD.n908 4.5005
R1683 VDDD.n940 VDDD.n889 4.5005
R1684 VDDD.n940 VDDD.n909 4.5005
R1685 VDDD.n940 VDDD.n888 4.5005
R1686 VDDD.n940 VDDD.n911 4.5005
R1687 VDDD.n934 VDDD.n930 4.5005
R1688 VDDD.n930 VDDD.n898 4.5005
R1689 VDDD.n930 VDDD.n900 4.5005
R1690 VDDD.n930 VDDD.n897 4.5005
R1691 VDDD.n930 VDDD.n901 4.5005
R1692 VDDD.n930 VDDD.n896 4.5005
R1693 VDDD.n930 VDDD.n902 4.5005
R1694 VDDD.n930 VDDD.n895 4.5005
R1695 VDDD.n930 VDDD.n903 4.5005
R1696 VDDD.n930 VDDD.n894 4.5005
R1697 VDDD.n930 VDDD.n904 4.5005
R1698 VDDD.n930 VDDD.n893 4.5005
R1699 VDDD.n930 VDDD.n905 4.5005
R1700 VDDD.n930 VDDD.n892 4.5005
R1701 VDDD.n930 VDDD.n906 4.5005
R1702 VDDD.n930 VDDD.n891 4.5005
R1703 VDDD.n930 VDDD.n907 4.5005
R1704 VDDD.n930 VDDD.n890 4.5005
R1705 VDDD.n930 VDDD.n908 4.5005
R1706 VDDD.n930 VDDD.n889 4.5005
R1707 VDDD.n930 VDDD.n909 4.5005
R1708 VDDD.n930 VDDD.n888 4.5005
R1709 VDDD.n930 VDDD.n910 4.5005
R1710 VDDD.n930 VDDD.n887 4.5005
R1711 VDDD.n1015 VDDD.n930 4.5005
R1712 VDDD.n930 VDDD.n886 4.5005
R1713 VDDD.n930 VDDD.n911 4.5005
R1714 VDDD.n934 VDDD.n928 4.5005
R1715 VDDD.n928 VDDD.n898 4.5005
R1716 VDDD.n928 VDDD.n900 4.5005
R1717 VDDD.n928 VDDD.n897 4.5005
R1718 VDDD.n928 VDDD.n901 4.5005
R1719 VDDD.n928 VDDD.n896 4.5005
R1720 VDDD.n928 VDDD.n902 4.5005
R1721 VDDD.n928 VDDD.n895 4.5005
R1722 VDDD.n928 VDDD.n903 4.5005
R1723 VDDD.n928 VDDD.n894 4.5005
R1724 VDDD.n928 VDDD.n904 4.5005
R1725 VDDD.n928 VDDD.n893 4.5005
R1726 VDDD.n928 VDDD.n905 4.5005
R1727 VDDD.n928 VDDD.n892 4.5005
R1728 VDDD.n928 VDDD.n906 4.5005
R1729 VDDD.n928 VDDD.n891 4.5005
R1730 VDDD.n928 VDDD.n907 4.5005
R1731 VDDD.n928 VDDD.n890 4.5005
R1732 VDDD.n928 VDDD.n908 4.5005
R1733 VDDD.n928 VDDD.n889 4.5005
R1734 VDDD.n928 VDDD.n909 4.5005
R1735 VDDD.n928 VDDD.n888 4.5005
R1736 VDDD.n928 VDDD.n910 4.5005
R1737 VDDD.n928 VDDD.n887 4.5005
R1738 VDDD.n1015 VDDD.n928 4.5005
R1739 VDDD.n928 VDDD.n886 4.5005
R1740 VDDD.n928 VDDD.n911 4.5005
R1741 VDDD.n934 VDDD.n931 4.5005
R1742 VDDD.n931 VDDD.n898 4.5005
R1743 VDDD.n931 VDDD.n900 4.5005
R1744 VDDD.n931 VDDD.n897 4.5005
R1745 VDDD.n931 VDDD.n901 4.5005
R1746 VDDD.n931 VDDD.n896 4.5005
R1747 VDDD.n931 VDDD.n902 4.5005
R1748 VDDD.n931 VDDD.n895 4.5005
R1749 VDDD.n931 VDDD.n903 4.5005
R1750 VDDD.n931 VDDD.n894 4.5005
R1751 VDDD.n931 VDDD.n904 4.5005
R1752 VDDD.n931 VDDD.n893 4.5005
R1753 VDDD.n931 VDDD.n905 4.5005
R1754 VDDD.n931 VDDD.n892 4.5005
R1755 VDDD.n931 VDDD.n906 4.5005
R1756 VDDD.n931 VDDD.n891 4.5005
R1757 VDDD.n931 VDDD.n907 4.5005
R1758 VDDD.n931 VDDD.n890 4.5005
R1759 VDDD.n931 VDDD.n908 4.5005
R1760 VDDD.n931 VDDD.n889 4.5005
R1761 VDDD.n931 VDDD.n909 4.5005
R1762 VDDD.n931 VDDD.n888 4.5005
R1763 VDDD.n931 VDDD.n910 4.5005
R1764 VDDD.n931 VDDD.n887 4.5005
R1765 VDDD.n1015 VDDD.n931 4.5005
R1766 VDDD.n931 VDDD.n886 4.5005
R1767 VDDD.n931 VDDD.n911 4.5005
R1768 VDDD.n934 VDDD.n927 4.5005
R1769 VDDD.n927 VDDD.n898 4.5005
R1770 VDDD.n927 VDDD.n900 4.5005
R1771 VDDD.n927 VDDD.n897 4.5005
R1772 VDDD.n927 VDDD.n901 4.5005
R1773 VDDD.n927 VDDD.n896 4.5005
R1774 VDDD.n927 VDDD.n902 4.5005
R1775 VDDD.n927 VDDD.n895 4.5005
R1776 VDDD.n927 VDDD.n903 4.5005
R1777 VDDD.n927 VDDD.n894 4.5005
R1778 VDDD.n927 VDDD.n904 4.5005
R1779 VDDD.n927 VDDD.n893 4.5005
R1780 VDDD.n927 VDDD.n905 4.5005
R1781 VDDD.n927 VDDD.n892 4.5005
R1782 VDDD.n927 VDDD.n906 4.5005
R1783 VDDD.n927 VDDD.n891 4.5005
R1784 VDDD.n927 VDDD.n907 4.5005
R1785 VDDD.n927 VDDD.n890 4.5005
R1786 VDDD.n927 VDDD.n908 4.5005
R1787 VDDD.n927 VDDD.n889 4.5005
R1788 VDDD.n927 VDDD.n909 4.5005
R1789 VDDD.n927 VDDD.n888 4.5005
R1790 VDDD.n927 VDDD.n910 4.5005
R1791 VDDD.n927 VDDD.n887 4.5005
R1792 VDDD.n1015 VDDD.n927 4.5005
R1793 VDDD.n927 VDDD.n886 4.5005
R1794 VDDD.n927 VDDD.n911 4.5005
R1795 VDDD.n934 VDDD.n932 4.5005
R1796 VDDD.n932 VDDD.n898 4.5005
R1797 VDDD.n932 VDDD.n900 4.5005
R1798 VDDD.n932 VDDD.n897 4.5005
R1799 VDDD.n932 VDDD.n901 4.5005
R1800 VDDD.n932 VDDD.n896 4.5005
R1801 VDDD.n932 VDDD.n902 4.5005
R1802 VDDD.n932 VDDD.n895 4.5005
R1803 VDDD.n932 VDDD.n903 4.5005
R1804 VDDD.n932 VDDD.n894 4.5005
R1805 VDDD.n932 VDDD.n904 4.5005
R1806 VDDD.n932 VDDD.n893 4.5005
R1807 VDDD.n932 VDDD.n905 4.5005
R1808 VDDD.n932 VDDD.n892 4.5005
R1809 VDDD.n932 VDDD.n906 4.5005
R1810 VDDD.n932 VDDD.n891 4.5005
R1811 VDDD.n932 VDDD.n907 4.5005
R1812 VDDD.n932 VDDD.n890 4.5005
R1813 VDDD.n932 VDDD.n908 4.5005
R1814 VDDD.n932 VDDD.n889 4.5005
R1815 VDDD.n932 VDDD.n909 4.5005
R1816 VDDD.n932 VDDD.n888 4.5005
R1817 VDDD.n932 VDDD.n910 4.5005
R1818 VDDD.n932 VDDD.n887 4.5005
R1819 VDDD.n1015 VDDD.n932 4.5005
R1820 VDDD.n932 VDDD.n886 4.5005
R1821 VDDD.n932 VDDD.n911 4.5005
R1822 VDDD.n934 VDDD.n926 4.5005
R1823 VDDD.n926 VDDD.n898 4.5005
R1824 VDDD.n926 VDDD.n900 4.5005
R1825 VDDD.n926 VDDD.n897 4.5005
R1826 VDDD.n926 VDDD.n901 4.5005
R1827 VDDD.n926 VDDD.n896 4.5005
R1828 VDDD.n926 VDDD.n902 4.5005
R1829 VDDD.n926 VDDD.n895 4.5005
R1830 VDDD.n926 VDDD.n903 4.5005
R1831 VDDD.n926 VDDD.n894 4.5005
R1832 VDDD.n926 VDDD.n904 4.5005
R1833 VDDD.n926 VDDD.n893 4.5005
R1834 VDDD.n926 VDDD.n905 4.5005
R1835 VDDD.n926 VDDD.n892 4.5005
R1836 VDDD.n926 VDDD.n906 4.5005
R1837 VDDD.n926 VDDD.n891 4.5005
R1838 VDDD.n926 VDDD.n907 4.5005
R1839 VDDD.n926 VDDD.n890 4.5005
R1840 VDDD.n926 VDDD.n908 4.5005
R1841 VDDD.n926 VDDD.n889 4.5005
R1842 VDDD.n926 VDDD.n909 4.5005
R1843 VDDD.n926 VDDD.n888 4.5005
R1844 VDDD.n926 VDDD.n910 4.5005
R1845 VDDD.n926 VDDD.n887 4.5005
R1846 VDDD.n1015 VDDD.n926 4.5005
R1847 VDDD.n926 VDDD.n886 4.5005
R1848 VDDD.n926 VDDD.n911 4.5005
R1849 VDDD.n934 VDDD.n933 4.5005
R1850 VDDD.n933 VDDD.n898 4.5005
R1851 VDDD.n933 VDDD.n900 4.5005
R1852 VDDD.n933 VDDD.n897 4.5005
R1853 VDDD.n933 VDDD.n901 4.5005
R1854 VDDD.n933 VDDD.n896 4.5005
R1855 VDDD.n933 VDDD.n902 4.5005
R1856 VDDD.n933 VDDD.n895 4.5005
R1857 VDDD.n933 VDDD.n903 4.5005
R1858 VDDD.n933 VDDD.n894 4.5005
R1859 VDDD.n933 VDDD.n904 4.5005
R1860 VDDD.n933 VDDD.n893 4.5005
R1861 VDDD.n933 VDDD.n905 4.5005
R1862 VDDD.n933 VDDD.n892 4.5005
R1863 VDDD.n933 VDDD.n906 4.5005
R1864 VDDD.n933 VDDD.n891 4.5005
R1865 VDDD.n933 VDDD.n907 4.5005
R1866 VDDD.n933 VDDD.n890 4.5005
R1867 VDDD.n933 VDDD.n908 4.5005
R1868 VDDD.n933 VDDD.n889 4.5005
R1869 VDDD.n933 VDDD.n909 4.5005
R1870 VDDD.n933 VDDD.n888 4.5005
R1871 VDDD.n933 VDDD.n910 4.5005
R1872 VDDD.n933 VDDD.n887 4.5005
R1873 VDDD.n1015 VDDD.n933 4.5005
R1874 VDDD.n933 VDDD.n886 4.5005
R1875 VDDD.n933 VDDD.n911 4.5005
R1876 VDDD.n934 VDDD.n925 4.5005
R1877 VDDD.n925 VDDD.n898 4.5005
R1878 VDDD.n925 VDDD.n900 4.5005
R1879 VDDD.n925 VDDD.n897 4.5005
R1880 VDDD.n925 VDDD.n901 4.5005
R1881 VDDD.n925 VDDD.n896 4.5005
R1882 VDDD.n925 VDDD.n902 4.5005
R1883 VDDD.n925 VDDD.n895 4.5005
R1884 VDDD.n925 VDDD.n903 4.5005
R1885 VDDD.n925 VDDD.n894 4.5005
R1886 VDDD.n925 VDDD.n904 4.5005
R1887 VDDD.n925 VDDD.n893 4.5005
R1888 VDDD.n925 VDDD.n905 4.5005
R1889 VDDD.n925 VDDD.n892 4.5005
R1890 VDDD.n925 VDDD.n906 4.5005
R1891 VDDD.n925 VDDD.n891 4.5005
R1892 VDDD.n925 VDDD.n907 4.5005
R1893 VDDD.n925 VDDD.n890 4.5005
R1894 VDDD.n925 VDDD.n908 4.5005
R1895 VDDD.n925 VDDD.n889 4.5005
R1896 VDDD.n925 VDDD.n909 4.5005
R1897 VDDD.n925 VDDD.n888 4.5005
R1898 VDDD.n925 VDDD.n910 4.5005
R1899 VDDD.n925 VDDD.n887 4.5005
R1900 VDDD.n1015 VDDD.n925 4.5005
R1901 VDDD.n925 VDDD.n886 4.5005
R1902 VDDD.n925 VDDD.n911 4.5005
R1903 VDDD.n1014 VDDD.n934 4.5005
R1904 VDDD.n1014 VDDD.n898 4.5005
R1905 VDDD.n1014 VDDD.n900 4.5005
R1906 VDDD.n1014 VDDD.n897 4.5005
R1907 VDDD.n1014 VDDD.n901 4.5005
R1908 VDDD.n1014 VDDD.n896 4.5005
R1909 VDDD.n1014 VDDD.n902 4.5005
R1910 VDDD.n1014 VDDD.n895 4.5005
R1911 VDDD.n1014 VDDD.n903 4.5005
R1912 VDDD.n1014 VDDD.n894 4.5005
R1913 VDDD.n1014 VDDD.n904 4.5005
R1914 VDDD.n1014 VDDD.n893 4.5005
R1915 VDDD.n1014 VDDD.n905 4.5005
R1916 VDDD.n1014 VDDD.n892 4.5005
R1917 VDDD.n1014 VDDD.n906 4.5005
R1918 VDDD.n1014 VDDD.n891 4.5005
R1919 VDDD.n1014 VDDD.n907 4.5005
R1920 VDDD.n1014 VDDD.n890 4.5005
R1921 VDDD.n1014 VDDD.n908 4.5005
R1922 VDDD.n1014 VDDD.n889 4.5005
R1923 VDDD.n1014 VDDD.n909 4.5005
R1924 VDDD.n1014 VDDD.n888 4.5005
R1925 VDDD.n1014 VDDD.n910 4.5005
R1926 VDDD.n1014 VDDD.n887 4.5005
R1927 VDDD.n1015 VDDD.n1014 4.5005
R1928 VDDD.n1014 VDDD.n886 4.5005
R1929 VDDD.n1014 VDDD.n911 4.5005
R1930 VDDD.n934 VDDD.n924 4.5005
R1931 VDDD.n924 VDDD.n898 4.5005
R1932 VDDD.n924 VDDD.n900 4.5005
R1933 VDDD.n924 VDDD.n897 4.5005
R1934 VDDD.n924 VDDD.n901 4.5005
R1935 VDDD.n924 VDDD.n896 4.5005
R1936 VDDD.n924 VDDD.n902 4.5005
R1937 VDDD.n924 VDDD.n895 4.5005
R1938 VDDD.n924 VDDD.n903 4.5005
R1939 VDDD.n924 VDDD.n894 4.5005
R1940 VDDD.n924 VDDD.n904 4.5005
R1941 VDDD.n924 VDDD.n893 4.5005
R1942 VDDD.n924 VDDD.n905 4.5005
R1943 VDDD.n924 VDDD.n892 4.5005
R1944 VDDD.n924 VDDD.n906 4.5005
R1945 VDDD.n924 VDDD.n891 4.5005
R1946 VDDD.n924 VDDD.n907 4.5005
R1947 VDDD.n924 VDDD.n890 4.5005
R1948 VDDD.n924 VDDD.n908 4.5005
R1949 VDDD.n924 VDDD.n889 4.5005
R1950 VDDD.n924 VDDD.n909 4.5005
R1951 VDDD.n924 VDDD.n888 4.5005
R1952 VDDD.n924 VDDD.n910 4.5005
R1953 VDDD.n924 VDDD.n887 4.5005
R1954 VDDD.n1015 VDDD.n924 4.5005
R1955 VDDD.n924 VDDD.n911 4.5005
R1956 VDDD.n2106 VDDD.n898 4.5005
R1957 VDDD.n2106 VDDD.n900 4.5005
R1958 VDDD.n2106 VDDD.n897 4.5005
R1959 VDDD.n2106 VDDD.n901 4.5005
R1960 VDDD.n2106 VDDD.n896 4.5005
R1961 VDDD.n2106 VDDD.n902 4.5005
R1962 VDDD.n2106 VDDD.n895 4.5005
R1963 VDDD.n2106 VDDD.n903 4.5005
R1964 VDDD.n2106 VDDD.n894 4.5005
R1965 VDDD.n2106 VDDD.n904 4.5005
R1966 VDDD.n2106 VDDD.n893 4.5005
R1967 VDDD.n2106 VDDD.n905 4.5005
R1968 VDDD.n2106 VDDD.n892 4.5005
R1969 VDDD.n2106 VDDD.n906 4.5005
R1970 VDDD.n2106 VDDD.n891 4.5005
R1971 VDDD.n2106 VDDD.n907 4.5005
R1972 VDDD.n2106 VDDD.n890 4.5005
R1973 VDDD.n2106 VDDD.n908 4.5005
R1974 VDDD.n2106 VDDD.n889 4.5005
R1975 VDDD.n2106 VDDD.n909 4.5005
R1976 VDDD.n2106 VDDD.n888 4.5005
R1977 VDDD.n2106 VDDD.n910 4.5005
R1978 VDDD.n2106 VDDD.n887 4.5005
R1979 VDDD.n2106 VDDD.n886 4.5005
R1980 VDDD.n2180 VDDD.n2132 4.5005
R1981 VDDD.n2165 VDDD.n2134 4.5005
R1982 VDDD.n2132 VDDD.n2112 4.5005
R1983 VDDD.n2130 VDDD.n2112 4.5005
R1984 VDDD.n2135 VDDD.n2112 4.5005
R1985 VDDD.n2129 VDDD.n2112 4.5005
R1986 VDDD.n2136 VDDD.n2112 4.5005
R1987 VDDD.n2128 VDDD.n2112 4.5005
R1988 VDDD.n2137 VDDD.n2112 4.5005
R1989 VDDD.n2127 VDDD.n2112 4.5005
R1990 VDDD.n2138 VDDD.n2112 4.5005
R1991 VDDD.n2126 VDDD.n2112 4.5005
R1992 VDDD.n2139 VDDD.n2112 4.5005
R1993 VDDD.n2125 VDDD.n2112 4.5005
R1994 VDDD.n2140 VDDD.n2112 4.5005
R1995 VDDD.n2124 VDDD.n2112 4.5005
R1996 VDDD.n2141 VDDD.n2112 4.5005
R1997 VDDD.n2123 VDDD.n2112 4.5005
R1998 VDDD.n2142 VDDD.n2112 4.5005
R1999 VDDD.n2122 VDDD.n2112 4.5005
R2000 VDDD.n2143 VDDD.n2112 4.5005
R2001 VDDD.n2121 VDDD.n2112 4.5005
R2002 VDDD.n2144 VDDD.n2112 4.5005
R2003 VDDD.n2120 VDDD.n2112 4.5005
R2004 VDDD.n2145 VDDD.n2112 4.5005
R2005 VDDD.n2239 VDDD.n2112 4.5005
R2006 VDDD.n2241 VDDD.n2112 4.5005
R2007 VDDD.n2132 VDDD.n2114 4.5005
R2008 VDDD.n2131 VDDD.n2114 4.5005
R2009 VDDD.n2134 VDDD.n2114 4.5005
R2010 VDDD.n2130 VDDD.n2114 4.5005
R2011 VDDD.n2135 VDDD.n2114 4.5005
R2012 VDDD.n2129 VDDD.n2114 4.5005
R2013 VDDD.n2136 VDDD.n2114 4.5005
R2014 VDDD.n2128 VDDD.n2114 4.5005
R2015 VDDD.n2137 VDDD.n2114 4.5005
R2016 VDDD.n2127 VDDD.n2114 4.5005
R2017 VDDD.n2138 VDDD.n2114 4.5005
R2018 VDDD.n2126 VDDD.n2114 4.5005
R2019 VDDD.n2139 VDDD.n2114 4.5005
R2020 VDDD.n2125 VDDD.n2114 4.5005
R2021 VDDD.n2140 VDDD.n2114 4.5005
R2022 VDDD.n2124 VDDD.n2114 4.5005
R2023 VDDD.n2141 VDDD.n2114 4.5005
R2024 VDDD.n2123 VDDD.n2114 4.5005
R2025 VDDD.n2142 VDDD.n2114 4.5005
R2026 VDDD.n2122 VDDD.n2114 4.5005
R2027 VDDD.n2143 VDDD.n2114 4.5005
R2028 VDDD.n2121 VDDD.n2114 4.5005
R2029 VDDD.n2144 VDDD.n2114 4.5005
R2030 VDDD.n2120 VDDD.n2114 4.5005
R2031 VDDD.n2145 VDDD.n2114 4.5005
R2032 VDDD.n2239 VDDD.n2114 4.5005
R2033 VDDD.n2241 VDDD.n2114 4.5005
R2034 VDDD.n2132 VDDD.n2111 4.5005
R2035 VDDD.n2131 VDDD.n2111 4.5005
R2036 VDDD.n2134 VDDD.n2111 4.5005
R2037 VDDD.n2130 VDDD.n2111 4.5005
R2038 VDDD.n2135 VDDD.n2111 4.5005
R2039 VDDD.n2129 VDDD.n2111 4.5005
R2040 VDDD.n2136 VDDD.n2111 4.5005
R2041 VDDD.n2128 VDDD.n2111 4.5005
R2042 VDDD.n2137 VDDD.n2111 4.5005
R2043 VDDD.n2127 VDDD.n2111 4.5005
R2044 VDDD.n2138 VDDD.n2111 4.5005
R2045 VDDD.n2126 VDDD.n2111 4.5005
R2046 VDDD.n2139 VDDD.n2111 4.5005
R2047 VDDD.n2125 VDDD.n2111 4.5005
R2048 VDDD.n2140 VDDD.n2111 4.5005
R2049 VDDD.n2124 VDDD.n2111 4.5005
R2050 VDDD.n2141 VDDD.n2111 4.5005
R2051 VDDD.n2123 VDDD.n2111 4.5005
R2052 VDDD.n2142 VDDD.n2111 4.5005
R2053 VDDD.n2122 VDDD.n2111 4.5005
R2054 VDDD.n2143 VDDD.n2111 4.5005
R2055 VDDD.n2121 VDDD.n2111 4.5005
R2056 VDDD.n2144 VDDD.n2111 4.5005
R2057 VDDD.n2120 VDDD.n2111 4.5005
R2058 VDDD.n2145 VDDD.n2111 4.5005
R2059 VDDD.n2239 VDDD.n2111 4.5005
R2060 VDDD.n2241 VDDD.n2111 4.5005
R2061 VDDD.n2132 VDDD.n2115 4.5005
R2062 VDDD.n2131 VDDD.n2115 4.5005
R2063 VDDD.n2134 VDDD.n2115 4.5005
R2064 VDDD.n2130 VDDD.n2115 4.5005
R2065 VDDD.n2135 VDDD.n2115 4.5005
R2066 VDDD.n2129 VDDD.n2115 4.5005
R2067 VDDD.n2136 VDDD.n2115 4.5005
R2068 VDDD.n2128 VDDD.n2115 4.5005
R2069 VDDD.n2137 VDDD.n2115 4.5005
R2070 VDDD.n2127 VDDD.n2115 4.5005
R2071 VDDD.n2138 VDDD.n2115 4.5005
R2072 VDDD.n2126 VDDD.n2115 4.5005
R2073 VDDD.n2139 VDDD.n2115 4.5005
R2074 VDDD.n2125 VDDD.n2115 4.5005
R2075 VDDD.n2140 VDDD.n2115 4.5005
R2076 VDDD.n2124 VDDD.n2115 4.5005
R2077 VDDD.n2141 VDDD.n2115 4.5005
R2078 VDDD.n2123 VDDD.n2115 4.5005
R2079 VDDD.n2142 VDDD.n2115 4.5005
R2080 VDDD.n2122 VDDD.n2115 4.5005
R2081 VDDD.n2143 VDDD.n2115 4.5005
R2082 VDDD.n2121 VDDD.n2115 4.5005
R2083 VDDD.n2144 VDDD.n2115 4.5005
R2084 VDDD.n2120 VDDD.n2115 4.5005
R2085 VDDD.n2145 VDDD.n2115 4.5005
R2086 VDDD.n2239 VDDD.n2115 4.5005
R2087 VDDD.n2241 VDDD.n2115 4.5005
R2088 VDDD.n2132 VDDD.n2110 4.5005
R2089 VDDD.n2131 VDDD.n2110 4.5005
R2090 VDDD.n2134 VDDD.n2110 4.5005
R2091 VDDD.n2130 VDDD.n2110 4.5005
R2092 VDDD.n2135 VDDD.n2110 4.5005
R2093 VDDD.n2129 VDDD.n2110 4.5005
R2094 VDDD.n2136 VDDD.n2110 4.5005
R2095 VDDD.n2128 VDDD.n2110 4.5005
R2096 VDDD.n2137 VDDD.n2110 4.5005
R2097 VDDD.n2127 VDDD.n2110 4.5005
R2098 VDDD.n2138 VDDD.n2110 4.5005
R2099 VDDD.n2126 VDDD.n2110 4.5005
R2100 VDDD.n2139 VDDD.n2110 4.5005
R2101 VDDD.n2125 VDDD.n2110 4.5005
R2102 VDDD.n2140 VDDD.n2110 4.5005
R2103 VDDD.n2124 VDDD.n2110 4.5005
R2104 VDDD.n2141 VDDD.n2110 4.5005
R2105 VDDD.n2123 VDDD.n2110 4.5005
R2106 VDDD.n2142 VDDD.n2110 4.5005
R2107 VDDD.n2122 VDDD.n2110 4.5005
R2108 VDDD.n2143 VDDD.n2110 4.5005
R2109 VDDD.n2121 VDDD.n2110 4.5005
R2110 VDDD.n2144 VDDD.n2110 4.5005
R2111 VDDD.n2120 VDDD.n2110 4.5005
R2112 VDDD.n2145 VDDD.n2110 4.5005
R2113 VDDD.n2239 VDDD.n2110 4.5005
R2114 VDDD.n2241 VDDD.n2110 4.5005
R2115 VDDD.n2132 VDDD.n2116 4.5005
R2116 VDDD.n2131 VDDD.n2116 4.5005
R2117 VDDD.n2134 VDDD.n2116 4.5005
R2118 VDDD.n2130 VDDD.n2116 4.5005
R2119 VDDD.n2135 VDDD.n2116 4.5005
R2120 VDDD.n2129 VDDD.n2116 4.5005
R2121 VDDD.n2136 VDDD.n2116 4.5005
R2122 VDDD.n2128 VDDD.n2116 4.5005
R2123 VDDD.n2137 VDDD.n2116 4.5005
R2124 VDDD.n2127 VDDD.n2116 4.5005
R2125 VDDD.n2138 VDDD.n2116 4.5005
R2126 VDDD.n2126 VDDD.n2116 4.5005
R2127 VDDD.n2139 VDDD.n2116 4.5005
R2128 VDDD.n2125 VDDD.n2116 4.5005
R2129 VDDD.n2140 VDDD.n2116 4.5005
R2130 VDDD.n2124 VDDD.n2116 4.5005
R2131 VDDD.n2141 VDDD.n2116 4.5005
R2132 VDDD.n2123 VDDD.n2116 4.5005
R2133 VDDD.n2142 VDDD.n2116 4.5005
R2134 VDDD.n2122 VDDD.n2116 4.5005
R2135 VDDD.n2143 VDDD.n2116 4.5005
R2136 VDDD.n2121 VDDD.n2116 4.5005
R2137 VDDD.n2144 VDDD.n2116 4.5005
R2138 VDDD.n2120 VDDD.n2116 4.5005
R2139 VDDD.n2145 VDDD.n2116 4.5005
R2140 VDDD.n2239 VDDD.n2116 4.5005
R2141 VDDD.n2241 VDDD.n2116 4.5005
R2142 VDDD.n2132 VDDD.n2109 4.5005
R2143 VDDD.n2131 VDDD.n2109 4.5005
R2144 VDDD.n2134 VDDD.n2109 4.5005
R2145 VDDD.n2130 VDDD.n2109 4.5005
R2146 VDDD.n2135 VDDD.n2109 4.5005
R2147 VDDD.n2129 VDDD.n2109 4.5005
R2148 VDDD.n2136 VDDD.n2109 4.5005
R2149 VDDD.n2128 VDDD.n2109 4.5005
R2150 VDDD.n2137 VDDD.n2109 4.5005
R2151 VDDD.n2127 VDDD.n2109 4.5005
R2152 VDDD.n2138 VDDD.n2109 4.5005
R2153 VDDD.n2126 VDDD.n2109 4.5005
R2154 VDDD.n2139 VDDD.n2109 4.5005
R2155 VDDD.n2125 VDDD.n2109 4.5005
R2156 VDDD.n2140 VDDD.n2109 4.5005
R2157 VDDD.n2124 VDDD.n2109 4.5005
R2158 VDDD.n2141 VDDD.n2109 4.5005
R2159 VDDD.n2123 VDDD.n2109 4.5005
R2160 VDDD.n2142 VDDD.n2109 4.5005
R2161 VDDD.n2122 VDDD.n2109 4.5005
R2162 VDDD.n2143 VDDD.n2109 4.5005
R2163 VDDD.n2121 VDDD.n2109 4.5005
R2164 VDDD.n2144 VDDD.n2109 4.5005
R2165 VDDD.n2120 VDDD.n2109 4.5005
R2166 VDDD.n2145 VDDD.n2109 4.5005
R2167 VDDD.n2239 VDDD.n2109 4.5005
R2168 VDDD.n2241 VDDD.n2109 4.5005
R2169 VDDD.n2132 VDDD.n2117 4.5005
R2170 VDDD.n2131 VDDD.n2117 4.5005
R2171 VDDD.n2134 VDDD.n2117 4.5005
R2172 VDDD.n2130 VDDD.n2117 4.5005
R2173 VDDD.n2135 VDDD.n2117 4.5005
R2174 VDDD.n2129 VDDD.n2117 4.5005
R2175 VDDD.n2136 VDDD.n2117 4.5005
R2176 VDDD.n2128 VDDD.n2117 4.5005
R2177 VDDD.n2137 VDDD.n2117 4.5005
R2178 VDDD.n2127 VDDD.n2117 4.5005
R2179 VDDD.n2138 VDDD.n2117 4.5005
R2180 VDDD.n2126 VDDD.n2117 4.5005
R2181 VDDD.n2139 VDDD.n2117 4.5005
R2182 VDDD.n2125 VDDD.n2117 4.5005
R2183 VDDD.n2140 VDDD.n2117 4.5005
R2184 VDDD.n2124 VDDD.n2117 4.5005
R2185 VDDD.n2141 VDDD.n2117 4.5005
R2186 VDDD.n2123 VDDD.n2117 4.5005
R2187 VDDD.n2142 VDDD.n2117 4.5005
R2188 VDDD.n2122 VDDD.n2117 4.5005
R2189 VDDD.n2143 VDDD.n2117 4.5005
R2190 VDDD.n2121 VDDD.n2117 4.5005
R2191 VDDD.n2144 VDDD.n2117 4.5005
R2192 VDDD.n2120 VDDD.n2117 4.5005
R2193 VDDD.n2145 VDDD.n2117 4.5005
R2194 VDDD.n2239 VDDD.n2117 4.5005
R2195 VDDD.n2241 VDDD.n2117 4.5005
R2196 VDDD.n2132 VDDD.n2108 4.5005
R2197 VDDD.n2131 VDDD.n2108 4.5005
R2198 VDDD.n2134 VDDD.n2108 4.5005
R2199 VDDD.n2130 VDDD.n2108 4.5005
R2200 VDDD.n2135 VDDD.n2108 4.5005
R2201 VDDD.n2129 VDDD.n2108 4.5005
R2202 VDDD.n2136 VDDD.n2108 4.5005
R2203 VDDD.n2128 VDDD.n2108 4.5005
R2204 VDDD.n2137 VDDD.n2108 4.5005
R2205 VDDD.n2127 VDDD.n2108 4.5005
R2206 VDDD.n2138 VDDD.n2108 4.5005
R2207 VDDD.n2126 VDDD.n2108 4.5005
R2208 VDDD.n2139 VDDD.n2108 4.5005
R2209 VDDD.n2125 VDDD.n2108 4.5005
R2210 VDDD.n2140 VDDD.n2108 4.5005
R2211 VDDD.n2124 VDDD.n2108 4.5005
R2212 VDDD.n2141 VDDD.n2108 4.5005
R2213 VDDD.n2123 VDDD.n2108 4.5005
R2214 VDDD.n2142 VDDD.n2108 4.5005
R2215 VDDD.n2122 VDDD.n2108 4.5005
R2216 VDDD.n2143 VDDD.n2108 4.5005
R2217 VDDD.n2121 VDDD.n2108 4.5005
R2218 VDDD.n2144 VDDD.n2108 4.5005
R2219 VDDD.n2120 VDDD.n2108 4.5005
R2220 VDDD.n2145 VDDD.n2108 4.5005
R2221 VDDD.n2239 VDDD.n2108 4.5005
R2222 VDDD.n2241 VDDD.n2108 4.5005
R2223 VDDD.n2240 VDDD.n2132 4.5005
R2224 VDDD.n2240 VDDD.n2131 4.5005
R2225 VDDD.n2240 VDDD.n2134 4.5005
R2226 VDDD.n2240 VDDD.n2130 4.5005
R2227 VDDD.n2240 VDDD.n2135 4.5005
R2228 VDDD.n2240 VDDD.n2129 4.5005
R2229 VDDD.n2240 VDDD.n2136 4.5005
R2230 VDDD.n2240 VDDD.n2128 4.5005
R2231 VDDD.n2240 VDDD.n2137 4.5005
R2232 VDDD.n2240 VDDD.n2127 4.5005
R2233 VDDD.n2240 VDDD.n2138 4.5005
R2234 VDDD.n2240 VDDD.n2126 4.5005
R2235 VDDD.n2240 VDDD.n2139 4.5005
R2236 VDDD.n2240 VDDD.n2125 4.5005
R2237 VDDD.n2240 VDDD.n2140 4.5005
R2238 VDDD.n2240 VDDD.n2124 4.5005
R2239 VDDD.n2240 VDDD.n2141 4.5005
R2240 VDDD.n2240 VDDD.n2123 4.5005
R2241 VDDD.n2240 VDDD.n2142 4.5005
R2242 VDDD.n2240 VDDD.n2122 4.5005
R2243 VDDD.n2240 VDDD.n2143 4.5005
R2244 VDDD.n2240 VDDD.n2121 4.5005
R2245 VDDD.n2240 VDDD.n2144 4.5005
R2246 VDDD.n2240 VDDD.n2120 4.5005
R2247 VDDD.n2240 VDDD.n2145 4.5005
R2248 VDDD.n2240 VDDD.n2239 4.5005
R2249 VDDD.n2241 VDDD.n2240 4.5005
R2250 VDDD.n2132 VDDD.n2107 4.5005
R2251 VDDD.n2131 VDDD.n2107 4.5005
R2252 VDDD.n2134 VDDD.n2107 4.5005
R2253 VDDD.n2130 VDDD.n2107 4.5005
R2254 VDDD.n2135 VDDD.n2107 4.5005
R2255 VDDD.n2129 VDDD.n2107 4.5005
R2256 VDDD.n2136 VDDD.n2107 4.5005
R2257 VDDD.n2128 VDDD.n2107 4.5005
R2258 VDDD.n2137 VDDD.n2107 4.5005
R2259 VDDD.n2127 VDDD.n2107 4.5005
R2260 VDDD.n2138 VDDD.n2107 4.5005
R2261 VDDD.n2126 VDDD.n2107 4.5005
R2262 VDDD.n2139 VDDD.n2107 4.5005
R2263 VDDD.n2125 VDDD.n2107 4.5005
R2264 VDDD.n2140 VDDD.n2107 4.5005
R2265 VDDD.n2124 VDDD.n2107 4.5005
R2266 VDDD.n2141 VDDD.n2107 4.5005
R2267 VDDD.n2123 VDDD.n2107 4.5005
R2268 VDDD.n2142 VDDD.n2107 4.5005
R2269 VDDD.n2122 VDDD.n2107 4.5005
R2270 VDDD.n2143 VDDD.n2107 4.5005
R2271 VDDD.n2121 VDDD.n2107 4.5005
R2272 VDDD.n2144 VDDD.n2107 4.5005
R2273 VDDD.n2120 VDDD.n2107 4.5005
R2274 VDDD.n2145 VDDD.n2107 4.5005
R2275 VDDD.n2186 VDDD.n2107 4.5005
R2276 VDDD.n2239 VDDD.n2107 4.5005
R2277 VDDD.n2241 VDDD.n2107 4.5005
R2278 VDDD.n2167 VDDD.n2134 4.5005
R2279 VDDD.n2167 VDDD.n2130 4.5005
R2280 VDDD.n2167 VDDD.n2135 4.5005
R2281 VDDD.n2167 VDDD.n2129 4.5005
R2282 VDDD.n2167 VDDD.n2136 4.5005
R2283 VDDD.n2167 VDDD.n2128 4.5005
R2284 VDDD.n2167 VDDD.n2137 4.5005
R2285 VDDD.n2167 VDDD.n2127 4.5005
R2286 VDDD.n2167 VDDD.n2138 4.5005
R2287 VDDD.n2167 VDDD.n2126 4.5005
R2288 VDDD.n2167 VDDD.n2139 4.5005
R2289 VDDD.n2167 VDDD.n2125 4.5005
R2290 VDDD.n2167 VDDD.n2140 4.5005
R2291 VDDD.n2167 VDDD.n2124 4.5005
R2292 VDDD.n2167 VDDD.n2141 4.5005
R2293 VDDD.n2167 VDDD.n2123 4.5005
R2294 VDDD.n2167 VDDD.n2142 4.5005
R2295 VDDD.n2167 VDDD.n2122 4.5005
R2296 VDDD.n2167 VDDD.n2143 4.5005
R2297 VDDD.n2167 VDDD.n2121 4.5005
R2298 VDDD.n2167 VDDD.n2144 4.5005
R2299 VDDD.n2167 VDDD.n2120 4.5005
R2300 VDDD.n2167 VDDD.n2145 4.5005
R2301 VDDD.n2186 VDDD.n2167 4.5005
R2302 VDDD.n2239 VDDD.n2167 4.5005
R2303 VDDD.n2167 VDDD.n2132 4.5005
R2304 VDDD.n2251 VDDD.n780 4.5005
R2305 VDDD.n2251 VDDD.n779 4.5005
R2306 VDDD.n785 VDDD.n779 4.5005
R2307 VDDD.n881 VDDD.n779 4.5005
R2308 VDDD.n2249 VDDD.n779 4.5005
R2309 VDDD.n2251 VDDD.n781 4.5005
R2310 VDDD.n876 VDDD.n781 4.5005
R2311 VDDD.n784 VDDD.n781 4.5005
R2312 VDDD.n879 VDDD.n781 4.5005
R2313 VDDD.n881 VDDD.n781 4.5005
R2314 VDDD.n2249 VDDD.n781 4.5005
R2315 VDDD.n2245 VDDD.n785 4.5005
R2316 VDDD.n2245 VDDD.n876 4.5005
R2317 VDDD.n2245 VDDD.n784 4.5005
R2318 VDDD.n2245 VDDD.n879 4.5005
R2319 VDDD.n2245 VDDD.n881 4.5005
R2320 VDDD.n2249 VDDD.n2245 4.5005
R2321 VDDD.n2251 VDDD.n2250 4.5005
R2322 VDDD.n2250 VDDD.n873 4.5005
R2323 VDDD.n2250 VDDD.n785 4.5005
R2324 VDDD.n2250 VDDD.n876 4.5005
R2325 VDDD.n2250 VDDD.n784 4.5005
R2326 VDDD.n2250 VDDD.n879 4.5005
R2327 VDDD.n2250 VDDD.n783 4.5005
R2328 VDDD.n2250 VDDD.n881 4.5005
R2329 VDDD.n2250 VDDD.n2249 4.5005
R2330 VDDD.n2311 VDDD.n2310 4.5005
R2331 VDDD.n2311 VDDD.n627 4.5005
R2332 VDDD.n727 VDDD.n627 4.5005
R2333 VDDD.n635 VDDD.n627 4.5005
R2334 VDDD.n2313 VDDD.n627 4.5005
R2335 VDDD.n2311 VDDD.n628 4.5005
R2336 VDDD.n631 VDDD.n628 4.5005
R2337 VDDD.n725 VDDD.n628 4.5005
R2338 VDDD.n632 VDDD.n628 4.5005
R2339 VDDD.n635 VDDD.n628 4.5005
R2340 VDDD.n2313 VDDD.n628 4.5005
R2341 VDDD.n727 VDDD.n626 4.5005
R2342 VDDD.n631 VDDD.n626 4.5005
R2343 VDDD.n725 VDDD.n626 4.5005
R2344 VDDD.n632 VDDD.n626 4.5005
R2345 VDDD.n635 VDDD.n626 4.5005
R2346 VDDD.n2313 VDDD.n626 4.5005
R2347 VDDD.n2313 VDDD.n2312 4.5005
R2348 VDDD.n2312 VDDD.n635 4.5005
R2349 VDDD.n2312 VDDD.n723 4.5005
R2350 VDDD.n2312 VDDD.n632 4.5005
R2351 VDDD.n2312 VDDD.n725 4.5005
R2352 VDDD.n2312 VDDD.n631 4.5005
R2353 VDDD.n2312 VDDD.n727 4.5005
R2354 VDDD.n2312 VDDD.n630 4.5005
R2355 VDDD.n2312 VDDD.n2311 4.5005
R2356 VDDD.n2373 VDDD.n2372 4.5005
R2357 VDDD.n2373 VDDD.n474 4.5005
R2358 VDDD.n574 VDDD.n474 4.5005
R2359 VDDD.n482 VDDD.n474 4.5005
R2360 VDDD.n2375 VDDD.n474 4.5005
R2361 VDDD.n2373 VDDD.n475 4.5005
R2362 VDDD.n478 VDDD.n475 4.5005
R2363 VDDD.n572 VDDD.n475 4.5005
R2364 VDDD.n479 VDDD.n475 4.5005
R2365 VDDD.n482 VDDD.n475 4.5005
R2366 VDDD.n2375 VDDD.n475 4.5005
R2367 VDDD.n574 VDDD.n473 4.5005
R2368 VDDD.n478 VDDD.n473 4.5005
R2369 VDDD.n572 VDDD.n473 4.5005
R2370 VDDD.n479 VDDD.n473 4.5005
R2371 VDDD.n482 VDDD.n473 4.5005
R2372 VDDD.n2375 VDDD.n473 4.5005
R2373 VDDD.n2375 VDDD.n2374 4.5005
R2374 VDDD.n2374 VDDD.n482 4.5005
R2375 VDDD.n2374 VDDD.n570 4.5005
R2376 VDDD.n2374 VDDD.n479 4.5005
R2377 VDDD.n2374 VDDD.n572 4.5005
R2378 VDDD.n2374 VDDD.n478 4.5005
R2379 VDDD.n2374 VDDD.n574 4.5005
R2380 VDDD.n2374 VDDD.n477 4.5005
R2381 VDDD.n2374 VDDD.n2373 4.5005
R2382 VDDD.n2435 VDDD.n2434 4.5005
R2383 VDDD.n2435 VDDD.n321 4.5005
R2384 VDDD.n421 VDDD.n321 4.5005
R2385 VDDD.n329 VDDD.n321 4.5005
R2386 VDDD.n2437 VDDD.n321 4.5005
R2387 VDDD.n2435 VDDD.n322 4.5005
R2388 VDDD.n325 VDDD.n322 4.5005
R2389 VDDD.n419 VDDD.n322 4.5005
R2390 VDDD.n326 VDDD.n322 4.5005
R2391 VDDD.n329 VDDD.n322 4.5005
R2392 VDDD.n2437 VDDD.n322 4.5005
R2393 VDDD.n421 VDDD.n320 4.5005
R2394 VDDD.n325 VDDD.n320 4.5005
R2395 VDDD.n419 VDDD.n320 4.5005
R2396 VDDD.n326 VDDD.n320 4.5005
R2397 VDDD.n329 VDDD.n320 4.5005
R2398 VDDD.n2437 VDDD.n320 4.5005
R2399 VDDD.n2437 VDDD.n2436 4.5005
R2400 VDDD.n2436 VDDD.n329 4.5005
R2401 VDDD.n2436 VDDD.n417 4.5005
R2402 VDDD.n2436 VDDD.n326 4.5005
R2403 VDDD.n2436 VDDD.n419 4.5005
R2404 VDDD.n2436 VDDD.n325 4.5005
R2405 VDDD.n2436 VDDD.n421 4.5005
R2406 VDDD.n2436 VDDD.n324 4.5005
R2407 VDDD.n2436 VDDD.n2435 4.5005
R2408 VDDD.n2497 VDDD.n2496 4.5005
R2409 VDDD.n2497 VDDD.n168 4.5005
R2410 VDDD.n268 VDDD.n168 4.5005
R2411 VDDD.n176 VDDD.n168 4.5005
R2412 VDDD.n2499 VDDD.n168 4.5005
R2413 VDDD.n2497 VDDD.n169 4.5005
R2414 VDDD.n172 VDDD.n169 4.5005
R2415 VDDD.n266 VDDD.n169 4.5005
R2416 VDDD.n173 VDDD.n169 4.5005
R2417 VDDD.n176 VDDD.n169 4.5005
R2418 VDDD.n2499 VDDD.n169 4.5005
R2419 VDDD.n268 VDDD.n167 4.5005
R2420 VDDD.n172 VDDD.n167 4.5005
R2421 VDDD.n266 VDDD.n167 4.5005
R2422 VDDD.n173 VDDD.n167 4.5005
R2423 VDDD.n176 VDDD.n167 4.5005
R2424 VDDD.n2499 VDDD.n167 4.5005
R2425 VDDD.n2499 VDDD.n2498 4.5005
R2426 VDDD.n2498 VDDD.n176 4.5005
R2427 VDDD.n2498 VDDD.n264 4.5005
R2428 VDDD.n2498 VDDD.n173 4.5005
R2429 VDDD.n2498 VDDD.n266 4.5005
R2430 VDDD.n2498 VDDD.n172 4.5005
R2431 VDDD.n2498 VDDD.n268 4.5005
R2432 VDDD.n2498 VDDD.n171 4.5005
R2433 VDDD.n2498 VDDD.n2497 4.5005
R2434 VDDD.n2618 VDDD.n114 4.5005
R2435 VDDD.n2618 VDDD.n113 4.5005
R2436 VDDD.n2618 VDDD.n115 4.5005
R2437 VDDD.n2618 VDDD.n2617 4.5005
R2438 VDDD.n2617 VDDD.n2561 4.5005
R2439 VDDD.n2558 VDDD.n113 4.5005
R2440 VDDD.n2593 VDDD.n2558 4.5005
R2441 VDDD.n2590 VDDD.n2558 4.5005
R2442 VDDD.n2595 VDDD.n2558 4.5005
R2443 VDDD.n2589 VDDD.n2558 4.5005
R2444 VDDD.n2597 VDDD.n2558 4.5005
R2445 VDDD.n2588 VDDD.n2558 4.5005
R2446 VDDD.n2599 VDDD.n2558 4.5005
R2447 VDDD.n2587 VDDD.n2558 4.5005
R2448 VDDD.n2601 VDDD.n2558 4.5005
R2449 VDDD.n2586 VDDD.n2558 4.5005
R2450 VDDD.n2603 VDDD.n2558 4.5005
R2451 VDDD.n2585 VDDD.n2558 4.5005
R2452 VDDD.n2605 VDDD.n2558 4.5005
R2453 VDDD.n2584 VDDD.n2558 4.5005
R2454 VDDD.n2607 VDDD.n2558 4.5005
R2455 VDDD.n2583 VDDD.n2558 4.5005
R2456 VDDD.n2609 VDDD.n2558 4.5005
R2457 VDDD.n2582 VDDD.n2558 4.5005
R2458 VDDD.n2611 VDDD.n2558 4.5005
R2459 VDDD.n2581 VDDD.n2558 4.5005
R2460 VDDD.n2613 VDDD.n2558 4.5005
R2461 VDDD.n2580 VDDD.n2558 4.5005
R2462 VDDD.n2615 VDDD.n2558 4.5005
R2463 VDDD.n2579 VDDD.n2558 4.5005
R2464 VDDD.n2558 VDDD.n115 4.5005
R2465 VDDD.n2617 VDDD.n2558 4.5005
R2466 VDDD.n2564 VDDD.n113 4.5005
R2467 VDDD.n2593 VDDD.n2564 4.5005
R2468 VDDD.n2590 VDDD.n2564 4.5005
R2469 VDDD.n2595 VDDD.n2564 4.5005
R2470 VDDD.n2589 VDDD.n2564 4.5005
R2471 VDDD.n2597 VDDD.n2564 4.5005
R2472 VDDD.n2588 VDDD.n2564 4.5005
R2473 VDDD.n2599 VDDD.n2564 4.5005
R2474 VDDD.n2587 VDDD.n2564 4.5005
R2475 VDDD.n2601 VDDD.n2564 4.5005
R2476 VDDD.n2586 VDDD.n2564 4.5005
R2477 VDDD.n2603 VDDD.n2564 4.5005
R2478 VDDD.n2585 VDDD.n2564 4.5005
R2479 VDDD.n2605 VDDD.n2564 4.5005
R2480 VDDD.n2584 VDDD.n2564 4.5005
R2481 VDDD.n2607 VDDD.n2564 4.5005
R2482 VDDD.n2583 VDDD.n2564 4.5005
R2483 VDDD.n2609 VDDD.n2564 4.5005
R2484 VDDD.n2582 VDDD.n2564 4.5005
R2485 VDDD.n2611 VDDD.n2564 4.5005
R2486 VDDD.n2581 VDDD.n2564 4.5005
R2487 VDDD.n2613 VDDD.n2564 4.5005
R2488 VDDD.n2580 VDDD.n2564 4.5005
R2489 VDDD.n2615 VDDD.n2564 4.5005
R2490 VDDD.n2579 VDDD.n2564 4.5005
R2491 VDDD.n2564 VDDD.n115 4.5005
R2492 VDDD.n2617 VDDD.n2564 4.5005
R2493 VDDD.n2557 VDDD.n113 4.5005
R2494 VDDD.n2593 VDDD.n2557 4.5005
R2495 VDDD.n2590 VDDD.n2557 4.5005
R2496 VDDD.n2595 VDDD.n2557 4.5005
R2497 VDDD.n2589 VDDD.n2557 4.5005
R2498 VDDD.n2597 VDDD.n2557 4.5005
R2499 VDDD.n2588 VDDD.n2557 4.5005
R2500 VDDD.n2599 VDDD.n2557 4.5005
R2501 VDDD.n2587 VDDD.n2557 4.5005
R2502 VDDD.n2601 VDDD.n2557 4.5005
R2503 VDDD.n2586 VDDD.n2557 4.5005
R2504 VDDD.n2603 VDDD.n2557 4.5005
R2505 VDDD.n2585 VDDD.n2557 4.5005
R2506 VDDD.n2605 VDDD.n2557 4.5005
R2507 VDDD.n2584 VDDD.n2557 4.5005
R2508 VDDD.n2607 VDDD.n2557 4.5005
R2509 VDDD.n2583 VDDD.n2557 4.5005
R2510 VDDD.n2609 VDDD.n2557 4.5005
R2511 VDDD.n2582 VDDD.n2557 4.5005
R2512 VDDD.n2611 VDDD.n2557 4.5005
R2513 VDDD.n2581 VDDD.n2557 4.5005
R2514 VDDD.n2613 VDDD.n2557 4.5005
R2515 VDDD.n2580 VDDD.n2557 4.5005
R2516 VDDD.n2615 VDDD.n2557 4.5005
R2517 VDDD.n2579 VDDD.n2557 4.5005
R2518 VDDD.n2557 VDDD.n115 4.5005
R2519 VDDD.n2617 VDDD.n2557 4.5005
R2520 VDDD.n2567 VDDD.n113 4.5005
R2521 VDDD.n2593 VDDD.n2567 4.5005
R2522 VDDD.n2590 VDDD.n2567 4.5005
R2523 VDDD.n2595 VDDD.n2567 4.5005
R2524 VDDD.n2589 VDDD.n2567 4.5005
R2525 VDDD.n2597 VDDD.n2567 4.5005
R2526 VDDD.n2588 VDDD.n2567 4.5005
R2527 VDDD.n2599 VDDD.n2567 4.5005
R2528 VDDD.n2587 VDDD.n2567 4.5005
R2529 VDDD.n2601 VDDD.n2567 4.5005
R2530 VDDD.n2586 VDDD.n2567 4.5005
R2531 VDDD.n2603 VDDD.n2567 4.5005
R2532 VDDD.n2585 VDDD.n2567 4.5005
R2533 VDDD.n2605 VDDD.n2567 4.5005
R2534 VDDD.n2584 VDDD.n2567 4.5005
R2535 VDDD.n2607 VDDD.n2567 4.5005
R2536 VDDD.n2583 VDDD.n2567 4.5005
R2537 VDDD.n2609 VDDD.n2567 4.5005
R2538 VDDD.n2582 VDDD.n2567 4.5005
R2539 VDDD.n2611 VDDD.n2567 4.5005
R2540 VDDD.n2581 VDDD.n2567 4.5005
R2541 VDDD.n2613 VDDD.n2567 4.5005
R2542 VDDD.n2580 VDDD.n2567 4.5005
R2543 VDDD.n2615 VDDD.n2567 4.5005
R2544 VDDD.n2579 VDDD.n2567 4.5005
R2545 VDDD.n2567 VDDD.n115 4.5005
R2546 VDDD.n2617 VDDD.n2567 4.5005
R2547 VDDD.n2556 VDDD.n113 4.5005
R2548 VDDD.n2593 VDDD.n2556 4.5005
R2549 VDDD.n2590 VDDD.n2556 4.5005
R2550 VDDD.n2595 VDDD.n2556 4.5005
R2551 VDDD.n2589 VDDD.n2556 4.5005
R2552 VDDD.n2597 VDDD.n2556 4.5005
R2553 VDDD.n2588 VDDD.n2556 4.5005
R2554 VDDD.n2599 VDDD.n2556 4.5005
R2555 VDDD.n2587 VDDD.n2556 4.5005
R2556 VDDD.n2601 VDDD.n2556 4.5005
R2557 VDDD.n2586 VDDD.n2556 4.5005
R2558 VDDD.n2603 VDDD.n2556 4.5005
R2559 VDDD.n2585 VDDD.n2556 4.5005
R2560 VDDD.n2605 VDDD.n2556 4.5005
R2561 VDDD.n2584 VDDD.n2556 4.5005
R2562 VDDD.n2607 VDDD.n2556 4.5005
R2563 VDDD.n2583 VDDD.n2556 4.5005
R2564 VDDD.n2609 VDDD.n2556 4.5005
R2565 VDDD.n2582 VDDD.n2556 4.5005
R2566 VDDD.n2611 VDDD.n2556 4.5005
R2567 VDDD.n2581 VDDD.n2556 4.5005
R2568 VDDD.n2613 VDDD.n2556 4.5005
R2569 VDDD.n2580 VDDD.n2556 4.5005
R2570 VDDD.n2615 VDDD.n2556 4.5005
R2571 VDDD.n2579 VDDD.n2556 4.5005
R2572 VDDD.n2556 VDDD.n115 4.5005
R2573 VDDD.n2617 VDDD.n2556 4.5005
R2574 VDDD.n2570 VDDD.n113 4.5005
R2575 VDDD.n2593 VDDD.n2570 4.5005
R2576 VDDD.n2590 VDDD.n2570 4.5005
R2577 VDDD.n2595 VDDD.n2570 4.5005
R2578 VDDD.n2589 VDDD.n2570 4.5005
R2579 VDDD.n2597 VDDD.n2570 4.5005
R2580 VDDD.n2588 VDDD.n2570 4.5005
R2581 VDDD.n2599 VDDD.n2570 4.5005
R2582 VDDD.n2587 VDDD.n2570 4.5005
R2583 VDDD.n2601 VDDD.n2570 4.5005
R2584 VDDD.n2586 VDDD.n2570 4.5005
R2585 VDDD.n2603 VDDD.n2570 4.5005
R2586 VDDD.n2585 VDDD.n2570 4.5005
R2587 VDDD.n2605 VDDD.n2570 4.5005
R2588 VDDD.n2584 VDDD.n2570 4.5005
R2589 VDDD.n2607 VDDD.n2570 4.5005
R2590 VDDD.n2583 VDDD.n2570 4.5005
R2591 VDDD.n2609 VDDD.n2570 4.5005
R2592 VDDD.n2582 VDDD.n2570 4.5005
R2593 VDDD.n2611 VDDD.n2570 4.5005
R2594 VDDD.n2581 VDDD.n2570 4.5005
R2595 VDDD.n2613 VDDD.n2570 4.5005
R2596 VDDD.n2580 VDDD.n2570 4.5005
R2597 VDDD.n2615 VDDD.n2570 4.5005
R2598 VDDD.n2579 VDDD.n2570 4.5005
R2599 VDDD.n2570 VDDD.n115 4.5005
R2600 VDDD.n2617 VDDD.n2570 4.5005
R2601 VDDD.n2555 VDDD.n113 4.5005
R2602 VDDD.n2593 VDDD.n2555 4.5005
R2603 VDDD.n2590 VDDD.n2555 4.5005
R2604 VDDD.n2595 VDDD.n2555 4.5005
R2605 VDDD.n2589 VDDD.n2555 4.5005
R2606 VDDD.n2597 VDDD.n2555 4.5005
R2607 VDDD.n2588 VDDD.n2555 4.5005
R2608 VDDD.n2599 VDDD.n2555 4.5005
R2609 VDDD.n2587 VDDD.n2555 4.5005
R2610 VDDD.n2601 VDDD.n2555 4.5005
R2611 VDDD.n2586 VDDD.n2555 4.5005
R2612 VDDD.n2603 VDDD.n2555 4.5005
R2613 VDDD.n2585 VDDD.n2555 4.5005
R2614 VDDD.n2605 VDDD.n2555 4.5005
R2615 VDDD.n2584 VDDD.n2555 4.5005
R2616 VDDD.n2607 VDDD.n2555 4.5005
R2617 VDDD.n2583 VDDD.n2555 4.5005
R2618 VDDD.n2609 VDDD.n2555 4.5005
R2619 VDDD.n2582 VDDD.n2555 4.5005
R2620 VDDD.n2611 VDDD.n2555 4.5005
R2621 VDDD.n2581 VDDD.n2555 4.5005
R2622 VDDD.n2613 VDDD.n2555 4.5005
R2623 VDDD.n2580 VDDD.n2555 4.5005
R2624 VDDD.n2615 VDDD.n2555 4.5005
R2625 VDDD.n2579 VDDD.n2555 4.5005
R2626 VDDD.n2555 VDDD.n115 4.5005
R2627 VDDD.n2617 VDDD.n2555 4.5005
R2628 VDDD.n2573 VDDD.n113 4.5005
R2629 VDDD.n2593 VDDD.n2573 4.5005
R2630 VDDD.n2590 VDDD.n2573 4.5005
R2631 VDDD.n2595 VDDD.n2573 4.5005
R2632 VDDD.n2589 VDDD.n2573 4.5005
R2633 VDDD.n2597 VDDD.n2573 4.5005
R2634 VDDD.n2588 VDDD.n2573 4.5005
R2635 VDDD.n2599 VDDD.n2573 4.5005
R2636 VDDD.n2587 VDDD.n2573 4.5005
R2637 VDDD.n2601 VDDD.n2573 4.5005
R2638 VDDD.n2586 VDDD.n2573 4.5005
R2639 VDDD.n2603 VDDD.n2573 4.5005
R2640 VDDD.n2585 VDDD.n2573 4.5005
R2641 VDDD.n2605 VDDD.n2573 4.5005
R2642 VDDD.n2584 VDDD.n2573 4.5005
R2643 VDDD.n2607 VDDD.n2573 4.5005
R2644 VDDD.n2583 VDDD.n2573 4.5005
R2645 VDDD.n2609 VDDD.n2573 4.5005
R2646 VDDD.n2582 VDDD.n2573 4.5005
R2647 VDDD.n2611 VDDD.n2573 4.5005
R2648 VDDD.n2581 VDDD.n2573 4.5005
R2649 VDDD.n2613 VDDD.n2573 4.5005
R2650 VDDD.n2580 VDDD.n2573 4.5005
R2651 VDDD.n2615 VDDD.n2573 4.5005
R2652 VDDD.n2579 VDDD.n2573 4.5005
R2653 VDDD.n2573 VDDD.n115 4.5005
R2654 VDDD.n2617 VDDD.n2573 4.5005
R2655 VDDD.n2554 VDDD.n113 4.5005
R2656 VDDD.n2593 VDDD.n2554 4.5005
R2657 VDDD.n2590 VDDD.n2554 4.5005
R2658 VDDD.n2595 VDDD.n2554 4.5005
R2659 VDDD.n2589 VDDD.n2554 4.5005
R2660 VDDD.n2597 VDDD.n2554 4.5005
R2661 VDDD.n2588 VDDD.n2554 4.5005
R2662 VDDD.n2599 VDDD.n2554 4.5005
R2663 VDDD.n2587 VDDD.n2554 4.5005
R2664 VDDD.n2601 VDDD.n2554 4.5005
R2665 VDDD.n2586 VDDD.n2554 4.5005
R2666 VDDD.n2603 VDDD.n2554 4.5005
R2667 VDDD.n2585 VDDD.n2554 4.5005
R2668 VDDD.n2605 VDDD.n2554 4.5005
R2669 VDDD.n2584 VDDD.n2554 4.5005
R2670 VDDD.n2607 VDDD.n2554 4.5005
R2671 VDDD.n2583 VDDD.n2554 4.5005
R2672 VDDD.n2609 VDDD.n2554 4.5005
R2673 VDDD.n2582 VDDD.n2554 4.5005
R2674 VDDD.n2611 VDDD.n2554 4.5005
R2675 VDDD.n2581 VDDD.n2554 4.5005
R2676 VDDD.n2613 VDDD.n2554 4.5005
R2677 VDDD.n2580 VDDD.n2554 4.5005
R2678 VDDD.n2615 VDDD.n2554 4.5005
R2679 VDDD.n2579 VDDD.n2554 4.5005
R2680 VDDD.n2554 VDDD.n115 4.5005
R2681 VDDD.n2617 VDDD.n2554 4.5005
R2682 VDDD.n2576 VDDD.n113 4.5005
R2683 VDDD.n2593 VDDD.n2576 4.5005
R2684 VDDD.n2590 VDDD.n2576 4.5005
R2685 VDDD.n2595 VDDD.n2576 4.5005
R2686 VDDD.n2589 VDDD.n2576 4.5005
R2687 VDDD.n2597 VDDD.n2576 4.5005
R2688 VDDD.n2588 VDDD.n2576 4.5005
R2689 VDDD.n2599 VDDD.n2576 4.5005
R2690 VDDD.n2587 VDDD.n2576 4.5005
R2691 VDDD.n2601 VDDD.n2576 4.5005
R2692 VDDD.n2586 VDDD.n2576 4.5005
R2693 VDDD.n2603 VDDD.n2576 4.5005
R2694 VDDD.n2585 VDDD.n2576 4.5005
R2695 VDDD.n2605 VDDD.n2576 4.5005
R2696 VDDD.n2584 VDDD.n2576 4.5005
R2697 VDDD.n2607 VDDD.n2576 4.5005
R2698 VDDD.n2583 VDDD.n2576 4.5005
R2699 VDDD.n2609 VDDD.n2576 4.5005
R2700 VDDD.n2582 VDDD.n2576 4.5005
R2701 VDDD.n2611 VDDD.n2576 4.5005
R2702 VDDD.n2581 VDDD.n2576 4.5005
R2703 VDDD.n2613 VDDD.n2576 4.5005
R2704 VDDD.n2580 VDDD.n2576 4.5005
R2705 VDDD.n2615 VDDD.n2576 4.5005
R2706 VDDD.n2579 VDDD.n2576 4.5005
R2707 VDDD.n2576 VDDD.n115 4.5005
R2708 VDDD.n2617 VDDD.n2576 4.5005
R2709 VDDD.n2553 VDDD.n113 4.5005
R2710 VDDD.n2593 VDDD.n2553 4.5005
R2711 VDDD.n2590 VDDD.n2553 4.5005
R2712 VDDD.n2595 VDDD.n2553 4.5005
R2713 VDDD.n2589 VDDD.n2553 4.5005
R2714 VDDD.n2597 VDDD.n2553 4.5005
R2715 VDDD.n2588 VDDD.n2553 4.5005
R2716 VDDD.n2599 VDDD.n2553 4.5005
R2717 VDDD.n2587 VDDD.n2553 4.5005
R2718 VDDD.n2601 VDDD.n2553 4.5005
R2719 VDDD.n2586 VDDD.n2553 4.5005
R2720 VDDD.n2603 VDDD.n2553 4.5005
R2721 VDDD.n2585 VDDD.n2553 4.5005
R2722 VDDD.n2605 VDDD.n2553 4.5005
R2723 VDDD.n2584 VDDD.n2553 4.5005
R2724 VDDD.n2607 VDDD.n2553 4.5005
R2725 VDDD.n2583 VDDD.n2553 4.5005
R2726 VDDD.n2609 VDDD.n2553 4.5005
R2727 VDDD.n2582 VDDD.n2553 4.5005
R2728 VDDD.n2611 VDDD.n2553 4.5005
R2729 VDDD.n2581 VDDD.n2553 4.5005
R2730 VDDD.n2613 VDDD.n2553 4.5005
R2731 VDDD.n2580 VDDD.n2553 4.5005
R2732 VDDD.n2615 VDDD.n2553 4.5005
R2733 VDDD.n2579 VDDD.n2553 4.5005
R2734 VDDD.n2553 VDDD.n115 4.5005
R2735 VDDD.n2617 VDDD.n2553 4.5005
R2736 VDDD.n2616 VDDD.n2593 4.5005
R2737 VDDD.n2616 VDDD.n2590 4.5005
R2738 VDDD.n2616 VDDD.n2595 4.5005
R2739 VDDD.n2616 VDDD.n2589 4.5005
R2740 VDDD.n2616 VDDD.n2597 4.5005
R2741 VDDD.n2616 VDDD.n2588 4.5005
R2742 VDDD.n2616 VDDD.n2599 4.5005
R2743 VDDD.n2616 VDDD.n2587 4.5005
R2744 VDDD.n2616 VDDD.n2601 4.5005
R2745 VDDD.n2616 VDDD.n2586 4.5005
R2746 VDDD.n2616 VDDD.n2603 4.5005
R2747 VDDD.n2616 VDDD.n2585 4.5005
R2748 VDDD.n2616 VDDD.n2605 4.5005
R2749 VDDD.n2616 VDDD.n2584 4.5005
R2750 VDDD.n2616 VDDD.n2607 4.5005
R2751 VDDD.n2616 VDDD.n2583 4.5005
R2752 VDDD.n2616 VDDD.n2609 4.5005
R2753 VDDD.n2616 VDDD.n2582 4.5005
R2754 VDDD.n2616 VDDD.n2611 4.5005
R2755 VDDD.n2616 VDDD.n2581 4.5005
R2756 VDDD.n2616 VDDD.n2613 4.5005
R2757 VDDD.n2616 VDDD.n2580 4.5005
R2758 VDDD.n2616 VDDD.n2615 4.5005
R2759 VDDD.n2616 VDDD.n2579 4.5005
R2760 VDDD.n2616 VDDD.n115 4.5005
R2761 VDDD.n2617 VDDD.n2616 4.5005
R2762 VDDD.n2662 VDDD.n99 4.5005
R2763 VDDD.n2662 VDDD.n2631 4.5005
R2764 VDDD.n2672 VDDD.n2662 4.5005
R2765 VDDD.n2649 VDDD.n2619 4.5005
R2766 VDDD.n2649 VDDD.n98 4.5005
R2767 VDDD.n2649 VDDD.n2620 4.5005
R2768 VDDD.n2649 VDDD.n97 4.5005
R2769 VDDD.n2649 VDDD.n2621 4.5005
R2770 VDDD.n2649 VDDD.n96 4.5005
R2771 VDDD.n2649 VDDD.n2622 4.5005
R2772 VDDD.n2649 VDDD.n95 4.5005
R2773 VDDD.n2649 VDDD.n2623 4.5005
R2774 VDDD.n2649 VDDD.n94 4.5005
R2775 VDDD.n2649 VDDD.n2624 4.5005
R2776 VDDD.n2649 VDDD.n93 4.5005
R2777 VDDD.n2649 VDDD.n2625 4.5005
R2778 VDDD.n2649 VDDD.n92 4.5005
R2779 VDDD.n2649 VDDD.n2626 4.5005
R2780 VDDD.n2649 VDDD.n91 4.5005
R2781 VDDD.n2649 VDDD.n2627 4.5005
R2782 VDDD.n2649 VDDD.n90 4.5005
R2783 VDDD.n2649 VDDD.n2628 4.5005
R2784 VDDD.n2649 VDDD.n89 4.5005
R2785 VDDD.n2649 VDDD.n2629 4.5005
R2786 VDDD.n2649 VDDD.n88 4.5005
R2787 VDDD.n2649 VDDD.n2630 4.5005
R2788 VDDD.n2649 VDDD.n2631 4.5005
R2789 VDDD.n2672 VDDD.n2649 4.5005
R2790 VDDD.n2674 VDDD.n79 4.5005
R2791 VDDD.n99 VDDD.n79 4.5005
R2792 VDDD.n2619 VDDD.n79 4.5005
R2793 VDDD.n98 VDDD.n79 4.5005
R2794 VDDD.n2620 VDDD.n79 4.5005
R2795 VDDD.n97 VDDD.n79 4.5005
R2796 VDDD.n2621 VDDD.n79 4.5005
R2797 VDDD.n96 VDDD.n79 4.5005
R2798 VDDD.n2622 VDDD.n79 4.5005
R2799 VDDD.n95 VDDD.n79 4.5005
R2800 VDDD.n2623 VDDD.n79 4.5005
R2801 VDDD.n94 VDDD.n79 4.5005
R2802 VDDD.n2624 VDDD.n79 4.5005
R2803 VDDD.n93 VDDD.n79 4.5005
R2804 VDDD.n2625 VDDD.n79 4.5005
R2805 VDDD.n92 VDDD.n79 4.5005
R2806 VDDD.n2626 VDDD.n79 4.5005
R2807 VDDD.n91 VDDD.n79 4.5005
R2808 VDDD.n2627 VDDD.n79 4.5005
R2809 VDDD.n90 VDDD.n79 4.5005
R2810 VDDD.n2628 VDDD.n79 4.5005
R2811 VDDD.n89 VDDD.n79 4.5005
R2812 VDDD.n2629 VDDD.n79 4.5005
R2813 VDDD.n88 VDDD.n79 4.5005
R2814 VDDD.n2630 VDDD.n79 4.5005
R2815 VDDD.n2631 VDDD.n79 4.5005
R2816 VDDD.n2672 VDDD.n79 4.5005
R2817 VDDD.n2674 VDDD.n76 4.5005
R2818 VDDD.n99 VDDD.n76 4.5005
R2819 VDDD.n2619 VDDD.n76 4.5005
R2820 VDDD.n98 VDDD.n76 4.5005
R2821 VDDD.n2620 VDDD.n76 4.5005
R2822 VDDD.n97 VDDD.n76 4.5005
R2823 VDDD.n2621 VDDD.n76 4.5005
R2824 VDDD.n96 VDDD.n76 4.5005
R2825 VDDD.n2622 VDDD.n76 4.5005
R2826 VDDD.n95 VDDD.n76 4.5005
R2827 VDDD.n2623 VDDD.n76 4.5005
R2828 VDDD.n94 VDDD.n76 4.5005
R2829 VDDD.n2624 VDDD.n76 4.5005
R2830 VDDD.n93 VDDD.n76 4.5005
R2831 VDDD.n2625 VDDD.n76 4.5005
R2832 VDDD.n92 VDDD.n76 4.5005
R2833 VDDD.n2626 VDDD.n76 4.5005
R2834 VDDD.n91 VDDD.n76 4.5005
R2835 VDDD.n2627 VDDD.n76 4.5005
R2836 VDDD.n90 VDDD.n76 4.5005
R2837 VDDD.n2628 VDDD.n76 4.5005
R2838 VDDD.n89 VDDD.n76 4.5005
R2839 VDDD.n2629 VDDD.n76 4.5005
R2840 VDDD.n88 VDDD.n76 4.5005
R2841 VDDD.n2630 VDDD.n76 4.5005
R2842 VDDD.n2631 VDDD.n76 4.5005
R2843 VDDD.n2672 VDDD.n76 4.5005
R2844 VDDD.n2674 VDDD.n80 4.5005
R2845 VDDD.n99 VDDD.n80 4.5005
R2846 VDDD.n2619 VDDD.n80 4.5005
R2847 VDDD.n98 VDDD.n80 4.5005
R2848 VDDD.n2620 VDDD.n80 4.5005
R2849 VDDD.n97 VDDD.n80 4.5005
R2850 VDDD.n2621 VDDD.n80 4.5005
R2851 VDDD.n96 VDDD.n80 4.5005
R2852 VDDD.n2622 VDDD.n80 4.5005
R2853 VDDD.n95 VDDD.n80 4.5005
R2854 VDDD.n2623 VDDD.n80 4.5005
R2855 VDDD.n94 VDDD.n80 4.5005
R2856 VDDD.n2624 VDDD.n80 4.5005
R2857 VDDD.n93 VDDD.n80 4.5005
R2858 VDDD.n2625 VDDD.n80 4.5005
R2859 VDDD.n92 VDDD.n80 4.5005
R2860 VDDD.n2626 VDDD.n80 4.5005
R2861 VDDD.n91 VDDD.n80 4.5005
R2862 VDDD.n2627 VDDD.n80 4.5005
R2863 VDDD.n90 VDDD.n80 4.5005
R2864 VDDD.n2628 VDDD.n80 4.5005
R2865 VDDD.n89 VDDD.n80 4.5005
R2866 VDDD.n2629 VDDD.n80 4.5005
R2867 VDDD.n88 VDDD.n80 4.5005
R2868 VDDD.n2630 VDDD.n80 4.5005
R2869 VDDD.n2631 VDDD.n80 4.5005
R2870 VDDD.n2672 VDDD.n80 4.5005
R2871 VDDD.n2674 VDDD.n75 4.5005
R2872 VDDD.n99 VDDD.n75 4.5005
R2873 VDDD.n2619 VDDD.n75 4.5005
R2874 VDDD.n98 VDDD.n75 4.5005
R2875 VDDD.n2620 VDDD.n75 4.5005
R2876 VDDD.n97 VDDD.n75 4.5005
R2877 VDDD.n2621 VDDD.n75 4.5005
R2878 VDDD.n96 VDDD.n75 4.5005
R2879 VDDD.n2622 VDDD.n75 4.5005
R2880 VDDD.n95 VDDD.n75 4.5005
R2881 VDDD.n2623 VDDD.n75 4.5005
R2882 VDDD.n94 VDDD.n75 4.5005
R2883 VDDD.n2624 VDDD.n75 4.5005
R2884 VDDD.n93 VDDD.n75 4.5005
R2885 VDDD.n2625 VDDD.n75 4.5005
R2886 VDDD.n92 VDDD.n75 4.5005
R2887 VDDD.n2626 VDDD.n75 4.5005
R2888 VDDD.n91 VDDD.n75 4.5005
R2889 VDDD.n2627 VDDD.n75 4.5005
R2890 VDDD.n90 VDDD.n75 4.5005
R2891 VDDD.n2628 VDDD.n75 4.5005
R2892 VDDD.n89 VDDD.n75 4.5005
R2893 VDDD.n2629 VDDD.n75 4.5005
R2894 VDDD.n88 VDDD.n75 4.5005
R2895 VDDD.n2630 VDDD.n75 4.5005
R2896 VDDD.n2631 VDDD.n75 4.5005
R2897 VDDD.n2672 VDDD.n75 4.5005
R2898 VDDD.n2674 VDDD.n81 4.5005
R2899 VDDD.n99 VDDD.n81 4.5005
R2900 VDDD.n2619 VDDD.n81 4.5005
R2901 VDDD.n98 VDDD.n81 4.5005
R2902 VDDD.n2620 VDDD.n81 4.5005
R2903 VDDD.n97 VDDD.n81 4.5005
R2904 VDDD.n2621 VDDD.n81 4.5005
R2905 VDDD.n96 VDDD.n81 4.5005
R2906 VDDD.n2622 VDDD.n81 4.5005
R2907 VDDD.n95 VDDD.n81 4.5005
R2908 VDDD.n2623 VDDD.n81 4.5005
R2909 VDDD.n94 VDDD.n81 4.5005
R2910 VDDD.n2624 VDDD.n81 4.5005
R2911 VDDD.n93 VDDD.n81 4.5005
R2912 VDDD.n2625 VDDD.n81 4.5005
R2913 VDDD.n92 VDDD.n81 4.5005
R2914 VDDD.n2626 VDDD.n81 4.5005
R2915 VDDD.n91 VDDD.n81 4.5005
R2916 VDDD.n2627 VDDD.n81 4.5005
R2917 VDDD.n90 VDDD.n81 4.5005
R2918 VDDD.n2628 VDDD.n81 4.5005
R2919 VDDD.n89 VDDD.n81 4.5005
R2920 VDDD.n2629 VDDD.n81 4.5005
R2921 VDDD.n88 VDDD.n81 4.5005
R2922 VDDD.n2630 VDDD.n81 4.5005
R2923 VDDD.n2631 VDDD.n81 4.5005
R2924 VDDD.n2672 VDDD.n81 4.5005
R2925 VDDD.n2674 VDDD.n74 4.5005
R2926 VDDD.n99 VDDD.n74 4.5005
R2927 VDDD.n2619 VDDD.n74 4.5005
R2928 VDDD.n98 VDDD.n74 4.5005
R2929 VDDD.n2620 VDDD.n74 4.5005
R2930 VDDD.n97 VDDD.n74 4.5005
R2931 VDDD.n2621 VDDD.n74 4.5005
R2932 VDDD.n96 VDDD.n74 4.5005
R2933 VDDD.n2622 VDDD.n74 4.5005
R2934 VDDD.n95 VDDD.n74 4.5005
R2935 VDDD.n2623 VDDD.n74 4.5005
R2936 VDDD.n94 VDDD.n74 4.5005
R2937 VDDD.n2624 VDDD.n74 4.5005
R2938 VDDD.n93 VDDD.n74 4.5005
R2939 VDDD.n2625 VDDD.n74 4.5005
R2940 VDDD.n92 VDDD.n74 4.5005
R2941 VDDD.n2626 VDDD.n74 4.5005
R2942 VDDD.n91 VDDD.n74 4.5005
R2943 VDDD.n2627 VDDD.n74 4.5005
R2944 VDDD.n90 VDDD.n74 4.5005
R2945 VDDD.n2628 VDDD.n74 4.5005
R2946 VDDD.n89 VDDD.n74 4.5005
R2947 VDDD.n2629 VDDD.n74 4.5005
R2948 VDDD.n88 VDDD.n74 4.5005
R2949 VDDD.n2630 VDDD.n74 4.5005
R2950 VDDD.n2631 VDDD.n74 4.5005
R2951 VDDD.n2672 VDDD.n74 4.5005
R2952 VDDD.n2674 VDDD.n82 4.5005
R2953 VDDD.n99 VDDD.n82 4.5005
R2954 VDDD.n2619 VDDD.n82 4.5005
R2955 VDDD.n98 VDDD.n82 4.5005
R2956 VDDD.n2620 VDDD.n82 4.5005
R2957 VDDD.n97 VDDD.n82 4.5005
R2958 VDDD.n2621 VDDD.n82 4.5005
R2959 VDDD.n96 VDDD.n82 4.5005
R2960 VDDD.n2622 VDDD.n82 4.5005
R2961 VDDD.n95 VDDD.n82 4.5005
R2962 VDDD.n2623 VDDD.n82 4.5005
R2963 VDDD.n94 VDDD.n82 4.5005
R2964 VDDD.n2624 VDDD.n82 4.5005
R2965 VDDD.n93 VDDD.n82 4.5005
R2966 VDDD.n2625 VDDD.n82 4.5005
R2967 VDDD.n92 VDDD.n82 4.5005
R2968 VDDD.n2626 VDDD.n82 4.5005
R2969 VDDD.n91 VDDD.n82 4.5005
R2970 VDDD.n2627 VDDD.n82 4.5005
R2971 VDDD.n90 VDDD.n82 4.5005
R2972 VDDD.n2628 VDDD.n82 4.5005
R2973 VDDD.n89 VDDD.n82 4.5005
R2974 VDDD.n2629 VDDD.n82 4.5005
R2975 VDDD.n88 VDDD.n82 4.5005
R2976 VDDD.n2630 VDDD.n82 4.5005
R2977 VDDD.n2631 VDDD.n82 4.5005
R2978 VDDD.n2672 VDDD.n82 4.5005
R2979 VDDD.n2674 VDDD.n73 4.5005
R2980 VDDD.n99 VDDD.n73 4.5005
R2981 VDDD.n2619 VDDD.n73 4.5005
R2982 VDDD.n98 VDDD.n73 4.5005
R2983 VDDD.n2620 VDDD.n73 4.5005
R2984 VDDD.n97 VDDD.n73 4.5005
R2985 VDDD.n2621 VDDD.n73 4.5005
R2986 VDDD.n96 VDDD.n73 4.5005
R2987 VDDD.n2622 VDDD.n73 4.5005
R2988 VDDD.n95 VDDD.n73 4.5005
R2989 VDDD.n2623 VDDD.n73 4.5005
R2990 VDDD.n94 VDDD.n73 4.5005
R2991 VDDD.n2624 VDDD.n73 4.5005
R2992 VDDD.n93 VDDD.n73 4.5005
R2993 VDDD.n2625 VDDD.n73 4.5005
R2994 VDDD.n92 VDDD.n73 4.5005
R2995 VDDD.n2626 VDDD.n73 4.5005
R2996 VDDD.n91 VDDD.n73 4.5005
R2997 VDDD.n2627 VDDD.n73 4.5005
R2998 VDDD.n90 VDDD.n73 4.5005
R2999 VDDD.n2628 VDDD.n73 4.5005
R3000 VDDD.n89 VDDD.n73 4.5005
R3001 VDDD.n2629 VDDD.n73 4.5005
R3002 VDDD.n88 VDDD.n73 4.5005
R3003 VDDD.n2630 VDDD.n73 4.5005
R3004 VDDD.n2631 VDDD.n73 4.5005
R3005 VDDD.n2672 VDDD.n73 4.5005
R3006 VDDD.n2674 VDDD.n2673 4.5005
R3007 VDDD.n2673 VDDD.n99 4.5005
R3008 VDDD.n2673 VDDD.n2619 4.5005
R3009 VDDD.n2673 VDDD.n98 4.5005
R3010 VDDD.n2673 VDDD.n2620 4.5005
R3011 VDDD.n2673 VDDD.n97 4.5005
R3012 VDDD.n2673 VDDD.n2621 4.5005
R3013 VDDD.n2673 VDDD.n96 4.5005
R3014 VDDD.n2673 VDDD.n2622 4.5005
R3015 VDDD.n2673 VDDD.n95 4.5005
R3016 VDDD.n2673 VDDD.n2623 4.5005
R3017 VDDD.n2673 VDDD.n94 4.5005
R3018 VDDD.n2673 VDDD.n2624 4.5005
R3019 VDDD.n2673 VDDD.n93 4.5005
R3020 VDDD.n2673 VDDD.n2625 4.5005
R3021 VDDD.n2673 VDDD.n92 4.5005
R3022 VDDD.n2673 VDDD.n2626 4.5005
R3023 VDDD.n2673 VDDD.n91 4.5005
R3024 VDDD.n2673 VDDD.n2627 4.5005
R3025 VDDD.n2673 VDDD.n90 4.5005
R3026 VDDD.n2673 VDDD.n2628 4.5005
R3027 VDDD.n2673 VDDD.n89 4.5005
R3028 VDDD.n2673 VDDD.n2629 4.5005
R3029 VDDD.n2673 VDDD.n88 4.5005
R3030 VDDD.n2673 VDDD.n2630 4.5005
R3031 VDDD.n2673 VDDD.n87 4.5005
R3032 VDDD.n2673 VDDD.n2631 4.5005
R3033 VDDD.n2673 VDDD.n2672 4.5005
R3034 VDDD.n2647 VDDD.n99 4.5005
R3035 VDDD.n2647 VDDD.n2619 4.5005
R3036 VDDD.n2647 VDDD.n98 4.5005
R3037 VDDD.n2647 VDDD.n2620 4.5005
R3038 VDDD.n2647 VDDD.n97 4.5005
R3039 VDDD.n2647 VDDD.n2621 4.5005
R3040 VDDD.n2647 VDDD.n96 4.5005
R3041 VDDD.n2647 VDDD.n2622 4.5005
R3042 VDDD.n2647 VDDD.n95 4.5005
R3043 VDDD.n2647 VDDD.n2623 4.5005
R3044 VDDD.n2647 VDDD.n94 4.5005
R3045 VDDD.n2647 VDDD.n2624 4.5005
R3046 VDDD.n2647 VDDD.n93 4.5005
R3047 VDDD.n2647 VDDD.n2625 4.5005
R3048 VDDD.n2647 VDDD.n92 4.5005
R3049 VDDD.n2647 VDDD.n2626 4.5005
R3050 VDDD.n2647 VDDD.n91 4.5005
R3051 VDDD.n2647 VDDD.n2627 4.5005
R3052 VDDD.n2647 VDDD.n90 4.5005
R3053 VDDD.n2647 VDDD.n2628 4.5005
R3054 VDDD.n2647 VDDD.n89 4.5005
R3055 VDDD.n2647 VDDD.n2629 4.5005
R3056 VDDD.n2647 VDDD.n88 4.5005
R3057 VDDD.n2647 VDDD.n2630 4.5005
R3058 VDDD.n2647 VDDD.n87 4.5005
R3059 VDDD.n2647 VDDD.n2631 4.5005
R3060 VDDD.n2672 VDDD.n2647 4.5005
R3061 VDDD.n2671 VDDD.n99 4.5005
R3062 VDDD.n2671 VDDD.n2619 4.5005
R3063 VDDD.n2671 VDDD.n98 4.5005
R3064 VDDD.n2671 VDDD.n2620 4.5005
R3065 VDDD.n2671 VDDD.n97 4.5005
R3066 VDDD.n2671 VDDD.n2621 4.5005
R3067 VDDD.n2671 VDDD.n96 4.5005
R3068 VDDD.n2671 VDDD.n2622 4.5005
R3069 VDDD.n2671 VDDD.n95 4.5005
R3070 VDDD.n2671 VDDD.n2623 4.5005
R3071 VDDD.n2671 VDDD.n94 4.5005
R3072 VDDD.n2671 VDDD.n2624 4.5005
R3073 VDDD.n2671 VDDD.n93 4.5005
R3074 VDDD.n2671 VDDD.n2625 4.5005
R3075 VDDD.n2671 VDDD.n92 4.5005
R3076 VDDD.n2671 VDDD.n2626 4.5005
R3077 VDDD.n2671 VDDD.n91 4.5005
R3078 VDDD.n2671 VDDD.n2627 4.5005
R3079 VDDD.n2671 VDDD.n90 4.5005
R3080 VDDD.n2671 VDDD.n2628 4.5005
R3081 VDDD.n2671 VDDD.n89 4.5005
R3082 VDDD.n2671 VDDD.n2629 4.5005
R3083 VDDD.n2671 VDDD.n88 4.5005
R3084 VDDD.n2671 VDDD.n2630 4.5005
R3085 VDDD.n2672 VDDD.n2671 4.5005
R3086 VDDD.n2743 VDDD.n2742 4.5005
R3087 VDDD.n2742 VDDD.n70 4.5005
R3088 VDDD.n2742 VDDD.n2741 4.5005
R3089 VDDD.n2742 VDDD.n2675 4.5005
R3090 VDDD.n2686 VDDD.n69 4.5005
R3091 VDDD.n2686 VDDD.n2677 4.5005
R3092 VDDD.n2741 VDDD.n2686 4.5005
R3093 VDDD.n2686 VDDD.n2675 4.5005
R3094 VDDD.n2739 VDDD.n68 4.5005
R3095 VDDD.n2739 VDDD.n2688 4.5005
R3096 VDDD.n2739 VDDD.n2675 4.5005
R3097 VDDD.n2680 VDDD.n68 4.5005
R3098 VDDD.n2743 VDDD.n2680 4.5005
R3099 VDDD.n2680 VDDD.n69 4.5005
R3100 VDDD.n2680 VDDD.n2677 4.5005
R3101 VDDD.n2680 VDDD.n70 4.5005
R3102 VDDD.n2741 VDDD.n2680 4.5005
R3103 VDDD.n2744 VDDD.n2675 4.5005
R3104 VDDD.n2744 VDDD.n2676 4.5005
R3105 VDDD.n2744 VDDD.n70 4.5005
R3106 VDDD.n2744 VDDD.n2677 4.5005
R3107 VDDD.n2744 VDDD.n69 4.5005
R3108 VDDD.n2744 VDDD.n2743 4.5005
R3109 VDDD.n2744 VDDD.n68 4.5005
R3110 VDDD.n2748 VDDD.n57 4.5005
R3111 VDDD.n57 VDDD.n49 4.5005
R3112 VDDD.n56 VDDD.n49 4.5005
R3113 VDDD.n2750 VDDD.n49 4.5005
R3114 VDDD.n2752 VDDD.n49 4.5005
R3115 VDDD.n57 VDDD.n51 4.5005
R3116 VDDD.n62 VDDD.n51 4.5005
R3117 VDDD.n55 VDDD.n51 4.5005
R3118 VDDD.n64 VDDD.n51 4.5005
R3119 VDDD.n2750 VDDD.n51 4.5005
R3120 VDDD.n2752 VDDD.n51 4.5005
R3121 VDDD.n56 VDDD.n48 4.5005
R3122 VDDD.n62 VDDD.n48 4.5005
R3123 VDDD.n55 VDDD.n48 4.5005
R3124 VDDD.n64 VDDD.n48 4.5005
R3125 VDDD.n2750 VDDD.n48 4.5005
R3126 VDDD.n2752 VDDD.n48 4.5005
R3127 VDDD.n2751 VDDD.n57 4.5005
R3128 VDDD.n2751 VDDD.n60 4.5005
R3129 VDDD.n2751 VDDD.n56 4.5005
R3130 VDDD.n2751 VDDD.n62 4.5005
R3131 VDDD.n2751 VDDD.n55 4.5005
R3132 VDDD.n2751 VDDD.n64 4.5005
R3133 VDDD.n2751 VDDD.n54 4.5005
R3134 VDDD.n2751 VDDD.n2750 4.5005
R3135 VDDD.n2752 VDDD.n2751 4.5005
R3136 VDDD.n38 VDDD.n33 4.5005
R3137 VDDD.n2778 VDDD.n33 4.5005
R3138 VDDD.n28 VDDD.n22 4.5005
R3139 VDDD.n2778 VDDD.n28 4.5005
R3140 VDDD.n35 VDDD.n22 4.5005
R3141 VDDD.n35 VDDD.n20 4.5005
R3142 VDDD.n35 VDDD.n23 4.5005
R3143 VDDD.n35 VDDD.n19 4.5005
R3144 VDDD.n35 VDDD.n24 4.5005
R3145 VDDD.n35 VDDD.n18 4.5005
R3146 VDDD.n38 VDDD.n35 4.5005
R3147 VDDD.n2778 VDDD.n35 4.5005
R3148 VDDD.n2779 VDDD.n22 4.5005
R3149 VDDD.n2779 VDDD.n20 4.5005
R3150 VDDD.n2779 VDDD.n23 4.5005
R3151 VDDD.n2779 VDDD.n19 4.5005
R3152 VDDD.n2779 VDDD.n24 4.5005
R3153 VDDD.n2779 VDDD.n18 4.5005
R3154 VDDD.n2779 VDDD.n2778 4.5005
R3155 VDDD.n2777 VDDD.n20 4.5005
R3156 VDDD.n2777 VDDD.n23 4.5005
R3157 VDDD.n2777 VDDD.n19 4.5005
R3158 VDDD.n2777 VDDD.n24 4.5005
R3159 VDDD.n2777 VDDD.n18 4.5005
R3160 VDDD.n2777 VDDD.n38 4.5005
R3161 VDDD.n2778 VDDD.n2777 4.5005
R3162 VDDD.n2781 VDDD.n2 4.5005
R3163 VDDD.n2785 VDDD.n2781 4.5005
R3164 VDDD.n2781 VDDD.n5 4.5005
R3165 VDDD.n2799 VDDD.n2781 4.5005
R3166 VDDD.n2781 VDDD.n8 4.5005
R3167 VDDD.n2781 VDDD.n9 4.5005
R3168 VDDD.n2781 VDDD.n13 4.5005
R3169 VDDD.n2802 VDDD.n2781 4.5005
R3170 VDDD.n2800 VDDD.n2 4.5005
R3171 VDDD.n2800 VDDD.n2785 4.5005
R3172 VDDD.n2800 VDDD.n5 4.5005
R3173 VDDD.n2800 VDDD.n2799 4.5005
R3174 VDDD.n2800 VDDD.n8 4.5005
R3175 VDDD.n2800 VDDD.n9 4.5005
R3176 VDDD.n2800 VDDD.n13 4.5005
R3177 VDDD.n2785 VDDD.n2780 4.5005
R3178 VDDD.n2780 VDDD.n5 4.5005
R3179 VDDD.n2799 VDDD.n2780 4.5005
R3180 VDDD.n2780 VDDD.n8 4.5005
R3181 VDDD.n2780 VDDD.n9 4.5005
R3182 VDDD.n2793 VDDD.n2780 4.5005
R3183 VDDD.n2780 VDDD.n13 4.5005
R3184 VDDD.n2783 VDDD.n2780 4.5005
R3185 VDDD.n2802 VDDD.n2780 4.5005
R3186 VDDD.n2806 VDDD.n2805 4.5005
R3187 VDDD.n15 VDDD.n10 4.5005
R3188 VDDD.n2810 VDDD.n11 4.5005
R3189 VDDD.n2812 VDDD.n2811 4.5005
R3190 VDDD.n6 VDDD.n4 4.5005
R3191 VDDD.n2817 VDDD.n2816 4.5005
R3192 VDDD.n2538 VDDD.n2537 2.31036
R3193 VDDD.n140 VDDD.n117 2.31036
R3194 VDDD.n2476 VDDD.n2475 2.31036
R3195 VDDD.n293 VDDD.n270 2.31036
R3196 VDDD.n2414 VDDD.n2413 2.31036
R3197 VDDD.n446 VDDD.n423 2.31036
R3198 VDDD.n2352 VDDD.n2351 2.31036
R3199 VDDD.n599 VDDD.n576 2.31036
R3200 VDDD.n2290 VDDD.n2289 2.31036
R3201 VDDD.n752 VDDD.n729 2.31036
R3202 VDDD.n1527 VDDD.n1526 2.31036
R3203 VDDD.n1514 VDDD.n1513 2.31036
R3204 VDDD.n1673 VDDD.n1672 2.31036
R3205 VDDD.n1660 VDDD.n1659 2.31036
R3206 VDDD.n1819 VDDD.n1818 2.31036
R3207 VDDD.n1806 VDDD.n1805 2.31036
R3208 VDDD.n1965 VDDD.n1964 2.31036
R3209 VDDD.n1952 VDDD.n1951 2.31036
R3210 VDDD.n2098 VDDD.n2097 2.31036
R3211 VDDD.n2085 VDDD.n2084 2.31036
R3212 VDDD.n2818 VDDD.n2817 2.31036
R3213 VDDD.n2805 VDDD.n2804 2.31036
R3214 VDDD.n2104 VDDD.n918 2.2503
R3215 VDDD.n1012 VDDD.n953 2.2503
R3216 VDDD.n2104 VDDD.n917 2.2503
R3217 VDDD.n1012 VDDD.n938 2.2503
R3218 VDDD.n2104 VDDD.n916 2.2503
R3219 VDDD.n1012 VDDD.n937 2.2503
R3220 VDDD.n2104 VDDD.n915 2.2503
R3221 VDDD.n1012 VDDD.n936 2.2503
R3222 VDDD.n2104 VDDD.n914 2.2503
R3223 VDDD.n1012 VDDD.n935 2.2503
R3224 VDDD.n2104 VDDD.n913 2.2503
R3225 VDDD.n1013 VDDD.n1012 2.2503
R3226 VDDD.n1015 VDDD.n885 2.2503
R3227 VDDD.n2241 VDDD.n2113 2.2503
R3228 VDDD.n2152 VDDD.n2151 2.2503
R3229 VDDD.n2186 VDDD.n2185 2.2503
R3230 VDDD.n2151 VDDD.n2147 2.2503
R3231 VDDD.n2186 VDDD.n2184 2.2503
R3232 VDDD.n2151 VDDD.n2148 2.2503
R3233 VDDD.n2186 VDDD.n2183 2.2503
R3234 VDDD.n2151 VDDD.n2149 2.2503
R3235 VDDD.n2186 VDDD.n2182 2.2503
R3236 VDDD.n2151 VDDD.n2150 2.2503
R3237 VDDD.n2186 VDDD.n2119 2.2503
R3238 VDDD.n2151 VDDD.n2118 2.2503
R3239 VDDD.n2179 VDDD.n2131 2.2503
R3240 VDDD.n2559 VDDD.n100 2.2503
R3241 VDDD.n2560 VDDD.n114 2.2503
R3242 VDDD.n2562 VDDD.n2559 2.2503
R3243 VDDD.n2563 VDDD.n114 2.2503
R3244 VDDD.n2565 VDDD.n2559 2.2503
R3245 VDDD.n2566 VDDD.n114 2.2503
R3246 VDDD.n2568 VDDD.n2559 2.2503
R3247 VDDD.n2569 VDDD.n114 2.2503
R3248 VDDD.n2571 VDDD.n2559 2.2503
R3249 VDDD.n2572 VDDD.n114 2.2503
R3250 VDDD.n2574 VDDD.n2559 2.2503
R3251 VDDD.n2575 VDDD.n114 2.2503
R3252 VDDD.n2577 VDDD.n2559 2.2503
R3253 VDDD.n2674 VDDD.n78 2.2503
R3254 VDDD.n2669 VDDD.n2668 2.2503
R3255 VDDD.n2648 VDDD.n87 2.2503
R3256 VDDD.n2669 VDDD.n2667 2.2503
R3257 VDDD.n87 VDDD.n84 2.2503
R3258 VDDD.n2669 VDDD.n2666 2.2503
R3259 VDDD.n87 VDDD.n85 2.2503
R3260 VDDD.n2669 VDDD.n2665 2.2503
R3261 VDDD.n87 VDDD.n86 2.2503
R3262 VDDD.n2669 VDDD.n2664 2.2503
R3263 VDDD.n2674 VDDD.n72 2.2503
R3264 VDDD.n2669 VDDD.n83 2.2503
R3265 VDDD.n2663 VDDD.n87 2.2503
R3266 VDDD.n1451 VDDD.n1394 2.24977
R3267 VDDD.n1451 VDDD.n1393 2.24977
R3268 VDDD.n1395 VDDD.n1387 2.24977
R3269 VDDD.n1396 VDDD.n1395 2.24977
R3270 VDDD.n1448 VDDD.n1390 2.24977
R3271 VDDD.n1448 VDDD.n1398 2.24977
R3272 VDDD.n1449 VDDD.n1448 2.24977
R3273 VDDD.n1389 VDDD.n1388 2.24977
R3274 VDDD.n1453 VDDD.n1384 2.24977
R3275 VDDD.n1597 VDDD.n1540 2.24977
R3276 VDDD.n1597 VDDD.n1539 2.24977
R3277 VDDD.n1541 VDDD.n1533 2.24977
R3278 VDDD.n1542 VDDD.n1541 2.24977
R3279 VDDD.n1594 VDDD.n1536 2.24977
R3280 VDDD.n1594 VDDD.n1544 2.24977
R3281 VDDD.n1595 VDDD.n1594 2.24977
R3282 VDDD.n1535 VDDD.n1534 2.24977
R3283 VDDD.n1599 VDDD.n1313 2.24977
R3284 VDDD.n1743 VDDD.n1686 2.24977
R3285 VDDD.n1743 VDDD.n1685 2.24977
R3286 VDDD.n1687 VDDD.n1679 2.24977
R3287 VDDD.n1688 VDDD.n1687 2.24977
R3288 VDDD.n1740 VDDD.n1682 2.24977
R3289 VDDD.n1740 VDDD.n1690 2.24977
R3290 VDDD.n1741 VDDD.n1740 2.24977
R3291 VDDD.n1681 VDDD.n1680 2.24977
R3292 VDDD.n1745 VDDD.n1242 2.24977
R3293 VDDD.n1889 VDDD.n1832 2.24977
R3294 VDDD.n1889 VDDD.n1831 2.24977
R3295 VDDD.n1833 VDDD.n1825 2.24977
R3296 VDDD.n1834 VDDD.n1833 2.24977
R3297 VDDD.n1886 VDDD.n1828 2.24977
R3298 VDDD.n1886 VDDD.n1836 2.24977
R3299 VDDD.n1887 VDDD.n1886 2.24977
R3300 VDDD.n1827 VDDD.n1826 2.24977
R3301 VDDD.n1891 VDDD.n1171 2.24977
R3302 VDDD.n2022 VDDD.n1097 2.24977
R3303 VDDD.n2020 VDDD.n1093 2.24977
R3304 VDDD.n2020 VDDD.n2019 2.24977
R3305 VDDD.n2020 VDDD.n2018 2.24977
R3306 VDDD.n1100 VDDD.n1095 2.24977
R3307 VDDD.n1100 VDDD.n1099 2.24977
R3308 VDDD.n1100 VDDD.n1098 2.24977
R3309 VDDD.n2024 VDDD.n1090 2.24977
R3310 VDDD.n875 VDDD.n780 2.24977
R3311 VDDD.n878 VDDD.n780 2.24977
R3312 VDDD.n880 VDDD.n780 2.24977
R3313 VDDD.n2248 VDDD.n780 2.24977
R3314 VDDD.n874 VDDD.n779 2.24977
R3315 VDDD.n877 VDDD.n779 2.24977
R3316 VDDD.n872 VDDD.n781 2.24977
R3317 VDDD.n2245 VDDD.n778 2.24977
R3318 VDDD.n2310 VDDD.n2308 2.24977
R3319 VDDD.n2310 VDDD.n2307 2.24977
R3320 VDDD.n2310 VDDD.n2306 2.24977
R3321 VDDD.n2310 VDDD.n625 2.24977
R3322 VDDD.n724 VDDD.n627 2.24977
R3323 VDDD.n721 VDDD.n627 2.24977
R3324 VDDD.n726 VDDD.n628 2.24977
R3325 VDDD.n2305 VDDD.n626 2.24977
R3326 VDDD.n2372 VDDD.n2370 2.24977
R3327 VDDD.n2372 VDDD.n2369 2.24977
R3328 VDDD.n2372 VDDD.n2368 2.24977
R3329 VDDD.n2372 VDDD.n472 2.24977
R3330 VDDD.n571 VDDD.n474 2.24977
R3331 VDDD.n568 VDDD.n474 2.24977
R3332 VDDD.n573 VDDD.n475 2.24977
R3333 VDDD.n2367 VDDD.n473 2.24977
R3334 VDDD.n2434 VDDD.n2432 2.24977
R3335 VDDD.n2434 VDDD.n2431 2.24977
R3336 VDDD.n2434 VDDD.n2430 2.24977
R3337 VDDD.n2434 VDDD.n319 2.24977
R3338 VDDD.n418 VDDD.n321 2.24977
R3339 VDDD.n415 VDDD.n321 2.24977
R3340 VDDD.n420 VDDD.n322 2.24977
R3341 VDDD.n2429 VDDD.n320 2.24977
R3342 VDDD.n2496 VDDD.n2494 2.24977
R3343 VDDD.n2496 VDDD.n2493 2.24977
R3344 VDDD.n2496 VDDD.n2492 2.24977
R3345 VDDD.n2496 VDDD.n166 2.24977
R3346 VDDD.n265 VDDD.n168 2.24977
R3347 VDDD.n262 VDDD.n168 2.24977
R3348 VDDD.n267 VDDD.n169 2.24977
R3349 VDDD.n2491 VDDD.n167 2.24977
R3350 VDDD.n2742 VDDD.n2685 2.24977
R3351 VDDD.n2742 VDDD.n2684 2.24977
R3352 VDDD.n2686 VDDD.n2678 2.24977
R3353 VDDD.n2687 VDDD.n2686 2.24977
R3354 VDDD.n2739 VDDD.n2681 2.24977
R3355 VDDD.n2739 VDDD.n2689 2.24977
R3356 VDDD.n2740 VDDD.n2739 2.24977
R3357 VDDD.n2680 VDDD.n2679 2.24977
R3358 VDDD.n2744 VDDD.n71 2.24977
R3359 VDDD.n2618 VDDD.n112 2.24961
R3360 VDDD.n2618 VDDD.n111 2.24961
R3361 VDDD.n2618 VDDD.n110 2.24961
R3362 VDDD.n2618 VDDD.n109 2.24961
R3363 VDDD.n2618 VDDD.n108 2.24961
R3364 VDDD.n2618 VDDD.n107 2.24961
R3365 VDDD.n2618 VDDD.n106 2.24961
R3366 VDDD.n2618 VDDD.n105 2.24961
R3367 VDDD.n2618 VDDD.n104 2.24961
R3368 VDDD.n2618 VDDD.n103 2.24961
R3369 VDDD.n2618 VDDD.n102 2.24961
R3370 VDDD.n2618 VDDD.n101 2.24961
R3371 VDDD.n2592 VDDD.n2561 2.24961
R3372 VDDD.n2594 VDDD.n2561 2.24961
R3373 VDDD.n2596 VDDD.n2561 2.24961
R3374 VDDD.n2598 VDDD.n2561 2.24961
R3375 VDDD.n2600 VDDD.n2561 2.24961
R3376 VDDD.n2602 VDDD.n2561 2.24961
R3377 VDDD.n2604 VDDD.n2561 2.24961
R3378 VDDD.n2606 VDDD.n2561 2.24961
R3379 VDDD.n2608 VDDD.n2561 2.24961
R3380 VDDD.n2610 VDDD.n2561 2.24961
R3381 VDDD.n2612 VDDD.n2561 2.24961
R3382 VDDD.n2614 VDDD.n2561 2.24961
R3383 VDDD.n2578 VDDD.n2561 2.24961
R3384 VDDD.n2616 VDDD.n2591 2.24961
R3385 VDDD.n2645 VDDD.n2644 2.24961
R3386 VDDD.n2645 VDDD.n2643 2.24961
R3387 VDDD.n2645 VDDD.n2642 2.24961
R3388 VDDD.n2645 VDDD.n2641 2.24961
R3389 VDDD.n2645 VDDD.n2640 2.24961
R3390 VDDD.n2645 VDDD.n2639 2.24961
R3391 VDDD.n2645 VDDD.n2638 2.24961
R3392 VDDD.n2645 VDDD.n2637 2.24961
R3393 VDDD.n2645 VDDD.n2636 2.24961
R3394 VDDD.n2645 VDDD.n2635 2.24961
R3395 VDDD.n2645 VDDD.n2634 2.24961
R3396 VDDD.n2645 VDDD.n2633 2.24961
R3397 VDDD.n2645 VDDD.n2632 2.24961
R3398 VDDD.n2646 VDDD.n2645 2.24961
R3399 VDDD.n2662 VDDD.n2661 2.24961
R3400 VDDD.n2662 VDDD.n2660 2.24961
R3401 VDDD.n2662 VDDD.n2659 2.24961
R3402 VDDD.n2662 VDDD.n2658 2.24961
R3403 VDDD.n2662 VDDD.n2657 2.24961
R3404 VDDD.n2662 VDDD.n2656 2.24961
R3405 VDDD.n2662 VDDD.n2655 2.24961
R3406 VDDD.n2662 VDDD.n2654 2.24961
R3407 VDDD.n2662 VDDD.n2653 2.24961
R3408 VDDD.n2662 VDDD.n2652 2.24961
R3409 VDDD.n2662 VDDD.n2651 2.24961
R3410 VDDD.n2662 VDDD.n2650 2.24961
R3411 VDDD.n2649 VDDD.n77 2.24961
R3412 VDDD.n2671 VDDD.n2670 2.24961
R3413 VDDD.n1011 VDDD.n1010 2.24945
R3414 VDDD.n1011 VDDD.n1009 2.24945
R3415 VDDD.n1011 VDDD.n1008 2.24945
R3416 VDDD.n1011 VDDD.n1007 2.24945
R3417 VDDD.n1011 VDDD.n1006 2.24945
R3418 VDDD.n1011 VDDD.n1005 2.24945
R3419 VDDD.n1011 VDDD.n1004 2.24945
R3420 VDDD.n1011 VDDD.n1003 2.24945
R3421 VDDD.n1011 VDDD.n1002 2.24945
R3422 VDDD.n1011 VDDD.n1001 2.24945
R3423 VDDD.n1011 VDDD.n1000 2.24945
R3424 VDDD.n952 VDDD.n951 2.24945
R3425 VDDD.n952 VDDD.n950 2.24945
R3426 VDDD.n952 VDDD.n949 2.24945
R3427 VDDD.n952 VDDD.n948 2.24945
R3428 VDDD.n952 VDDD.n947 2.24945
R3429 VDDD.n952 VDDD.n946 2.24945
R3430 VDDD.n952 VDDD.n945 2.24945
R3431 VDDD.n952 VDDD.n944 2.24945
R3432 VDDD.n952 VDDD.n943 2.24945
R3433 VDDD.n952 VDDD.n942 2.24945
R3434 VDDD.n952 VDDD.n941 2.24945
R3435 VDDD.n952 VDDD.n923 2.24945
R3436 VDDD.n940 VDDD.n939 2.24945
R3437 VDDD.n940 VDDD.n929 2.24945
R3438 VDDD.n924 VDDD.n912 2.24945
R3439 VDDD.n2106 VDDD.n899 2.24945
R3440 VDDD.n2106 VDDD.n2105 2.24945
R3441 VDDD.n2180 VDDD.n2178 2.24945
R3442 VDDD.n2180 VDDD.n2177 2.24945
R3443 VDDD.n2180 VDDD.n2176 2.24945
R3444 VDDD.n2180 VDDD.n2175 2.24945
R3445 VDDD.n2180 VDDD.n2174 2.24945
R3446 VDDD.n2180 VDDD.n2173 2.24945
R3447 VDDD.n2180 VDDD.n2172 2.24945
R3448 VDDD.n2180 VDDD.n2171 2.24945
R3449 VDDD.n2180 VDDD.n2170 2.24945
R3450 VDDD.n2180 VDDD.n2169 2.24945
R3451 VDDD.n2180 VDDD.n2168 2.24945
R3452 VDDD.n2181 VDDD.n2180 2.24945
R3453 VDDD.n2180 VDDD.n2146 2.24945
R3454 VDDD.n2165 VDDD.n2164 2.24945
R3455 VDDD.n2165 VDDD.n2163 2.24945
R3456 VDDD.n2165 VDDD.n2162 2.24945
R3457 VDDD.n2165 VDDD.n2161 2.24945
R3458 VDDD.n2165 VDDD.n2160 2.24945
R3459 VDDD.n2165 VDDD.n2159 2.24945
R3460 VDDD.n2165 VDDD.n2158 2.24945
R3461 VDDD.n2165 VDDD.n2157 2.24945
R3462 VDDD.n2165 VDDD.n2156 2.24945
R3463 VDDD.n2165 VDDD.n2155 2.24945
R3464 VDDD.n2165 VDDD.n2154 2.24945
R3465 VDDD.n2165 VDDD.n2153 2.24945
R3466 VDDD.n2166 VDDD.n2165 2.24945
R3467 VDDD.n2133 VDDD.n2112 2.24945
R3468 VDDD.n2167 VDDD.n884 2.24945
R3469 VDDD.n122 VDDD.n118 2.24901
R3470 VDDD.n124 VDDD.n118 2.24901
R3471 VDDD.n219 VDDD.n195 2.24901
R3472 VDDD.n221 VDDD.n204 2.24901
R3473 VDDD.n224 VDDD.n223 2.24901
R3474 VDDD.n208 VDDD.n202 2.24901
R3475 VDDD.n185 VDDD.n184 2.24901
R3476 VDDD.n187 VDDD.n184 2.24901
R3477 VDDD.n275 VDDD.n271 2.24901
R3478 VDDD.n277 VDDD.n271 2.24901
R3479 VDDD.n372 VDDD.n348 2.24901
R3480 VDDD.n374 VDDD.n357 2.24901
R3481 VDDD.n377 VDDD.n376 2.24901
R3482 VDDD.n361 VDDD.n355 2.24901
R3483 VDDD.n338 VDDD.n337 2.24901
R3484 VDDD.n340 VDDD.n337 2.24901
R3485 VDDD.n428 VDDD.n424 2.24901
R3486 VDDD.n430 VDDD.n424 2.24901
R3487 VDDD.n525 VDDD.n501 2.24901
R3488 VDDD.n527 VDDD.n510 2.24901
R3489 VDDD.n530 VDDD.n529 2.24901
R3490 VDDD.n514 VDDD.n508 2.24901
R3491 VDDD.n491 VDDD.n490 2.24901
R3492 VDDD.n493 VDDD.n490 2.24901
R3493 VDDD.n581 VDDD.n577 2.24901
R3494 VDDD.n583 VDDD.n577 2.24901
R3495 VDDD.n678 VDDD.n654 2.24901
R3496 VDDD.n680 VDDD.n663 2.24901
R3497 VDDD.n683 VDDD.n682 2.24901
R3498 VDDD.n667 VDDD.n661 2.24901
R3499 VDDD.n644 VDDD.n643 2.24901
R3500 VDDD.n646 VDDD.n643 2.24901
R3501 VDDD.n734 VDDD.n730 2.24901
R3502 VDDD.n736 VDDD.n730 2.24901
R3503 VDDD.n828 VDDD.n804 2.24901
R3504 VDDD.n830 VDDD.n813 2.24901
R3505 VDDD.n833 VDDD.n832 2.24901
R3506 VDDD.n817 VDDD.n811 2.24901
R3507 VDDD.n794 VDDD.n793 2.24901
R3508 VDDD.n796 VDDD.n793 2.24901
R3509 VDDD.n1391 VDDD.n1385 2.24901
R3510 VDDD.n1397 VDDD.n1392 2.24901
R3511 VDDD.n1456 VDDD.n1373 2.24901
R3512 VDDD.n1379 VDDD.n1378 2.24901
R3513 VDDD.n1367 VDDD.n1366 2.24901
R3514 VDDD.n1379 VDDD.n1365 2.24901
R3515 VDDD.n1347 VDDD.n1338 2.24901
R3516 VDDD.n1349 VDDD.n1338 2.24901
R3517 VDDD.n1499 VDDD.n1315 2.24901
R3518 VDDD.n1511 VDDD.n1491 2.24901
R3519 VDDD.n1496 VDDD.n1492 2.24901
R3520 VDDD.n1502 VDDD.n1493 2.24901
R3521 VDDD.n1537 VDDD.n1531 2.24901
R3522 VDDD.n1543 VDDD.n1538 2.24901
R3523 VDDD.n1602 VDDD.n1302 2.24901
R3524 VDDD.n1308 VDDD.n1307 2.24901
R3525 VDDD.n1296 VDDD.n1295 2.24901
R3526 VDDD.n1308 VDDD.n1294 2.24901
R3527 VDDD.n1276 VDDD.n1267 2.24901
R3528 VDDD.n1278 VDDD.n1267 2.24901
R3529 VDDD.n1645 VDDD.n1244 2.24901
R3530 VDDD.n1657 VDDD.n1637 2.24901
R3531 VDDD.n1642 VDDD.n1638 2.24901
R3532 VDDD.n1648 VDDD.n1639 2.24901
R3533 VDDD.n1683 VDDD.n1677 2.24901
R3534 VDDD.n1689 VDDD.n1684 2.24901
R3535 VDDD.n1748 VDDD.n1231 2.24901
R3536 VDDD.n1237 VDDD.n1236 2.24901
R3537 VDDD.n1225 VDDD.n1224 2.24901
R3538 VDDD.n1237 VDDD.n1223 2.24901
R3539 VDDD.n1205 VDDD.n1196 2.24901
R3540 VDDD.n1207 VDDD.n1196 2.24901
R3541 VDDD.n1791 VDDD.n1173 2.24901
R3542 VDDD.n1803 VDDD.n1783 2.24901
R3543 VDDD.n1788 VDDD.n1784 2.24901
R3544 VDDD.n1794 VDDD.n1785 2.24901
R3545 VDDD.n1829 VDDD.n1823 2.24901
R3546 VDDD.n1835 VDDD.n1830 2.24901
R3547 VDDD.n1894 VDDD.n1160 2.24901
R3548 VDDD.n1166 VDDD.n1165 2.24901
R3549 VDDD.n1154 VDDD.n1153 2.24901
R3550 VDDD.n1166 VDDD.n1152 2.24901
R3551 VDDD.n1134 VDDD.n1125 2.24901
R3552 VDDD.n1136 VDDD.n1125 2.24901
R3553 VDDD.n1937 VDDD.n1102 2.24901
R3554 VDDD.n1949 VDDD.n1929 2.24901
R3555 VDDD.n1934 VDDD.n1930 2.24901
R3556 VDDD.n1940 VDDD.n1931 2.24901
R3557 VDDD.n2016 VDDD.n1096 2.24901
R3558 VDDD.n2017 VDDD.n2016 2.24901
R3559 VDDD.n2027 VDDD.n1078 2.24901
R3560 VDDD.n1084 VDDD.n1083 2.24901
R3561 VDDD.n1072 VDDD.n1071 2.24901
R3562 VDDD.n1084 VDDD.n1070 2.24901
R3563 VDDD.n1052 VDDD.n1043 2.24901
R3564 VDDD.n1054 VDDD.n1043 2.24901
R3565 VDDD.n2070 VDDD.n1020 2.24901
R3566 VDDD.n2082 VDDD.n2062 2.24901
R3567 VDDD.n2067 VDDD.n2063 2.24901
R3568 VDDD.n2073 VDDD.n2064 2.24901
R3569 VDDD.n873 VDDD.n871 2.24901
R3570 VDDD.n2247 VDDD.n2246 2.24901
R3571 VDDD.n2244 VDDD.n783 2.24901
R3572 VDDD.n2247 VDDD.n782 2.24901
R3573 VDDD.n2309 VDDD.n630 2.24901
R3574 VDDD.n634 VDDD.n633 2.24901
R3575 VDDD.n723 VDDD.n722 2.24901
R3576 VDDD.n634 VDDD.n629 2.24901
R3577 VDDD.n2371 VDDD.n477 2.24901
R3578 VDDD.n481 VDDD.n480 2.24901
R3579 VDDD.n570 VDDD.n569 2.24901
R3580 VDDD.n481 VDDD.n476 2.24901
R3581 VDDD.n2433 VDDD.n324 2.24901
R3582 VDDD.n328 VDDD.n327 2.24901
R3583 VDDD.n417 VDDD.n416 2.24901
R3584 VDDD.n328 VDDD.n323 2.24901
R3585 VDDD.n2495 VDDD.n171 2.24901
R3586 VDDD.n175 VDDD.n174 2.24901
R3587 VDDD.n264 VDDD.n263 2.24901
R3588 VDDD.n175 VDDD.n170 2.24901
R3589 VDDD.n2682 VDDD.n2676 2.24901
R3590 VDDD.n2688 VDDD.n2683 2.24901
R3591 VDDD.n2747 VDDD.n60 2.24901
R3592 VDDD.n66 VDDD.n65 2.24901
R3593 VDDD.n54 VDDD.n53 2.24901
R3594 VDDD.n66 VDDD.n52 2.24901
R3595 VDDD.n34 VDDD.n25 2.24901
R3596 VDDD.n36 VDDD.n25 2.24901
R3597 VDDD.n2790 VDDD.n2 2.24901
R3598 VDDD.n2802 VDDD.n2782 2.24901
R3599 VDDD.n2787 VDDD.n2783 2.24901
R3600 VDDD.n2793 VDDD.n2784 2.24901
R3601 VDDD.n149 VDDD.n148 2.24901
R3602 VDDD.n149 VDDD.n147 2.24901
R3603 VDDD.n251 VDDD.n181 2.24901
R3604 VDDD.n251 VDDD.n192 2.24901
R3605 VDDD.n302 VDDD.n301 2.24901
R3606 VDDD.n302 VDDD.n300 2.24901
R3607 VDDD.n404 VDDD.n334 2.24901
R3608 VDDD.n404 VDDD.n345 2.24901
R3609 VDDD.n455 VDDD.n454 2.24901
R3610 VDDD.n455 VDDD.n453 2.24901
R3611 VDDD.n557 VDDD.n487 2.24901
R3612 VDDD.n557 VDDD.n498 2.24901
R3613 VDDD.n608 VDDD.n607 2.24901
R3614 VDDD.n608 VDDD.n606 2.24901
R3615 VDDD.n710 VDDD.n640 2.24901
R3616 VDDD.n710 VDDD.n651 2.24901
R3617 VDDD.n761 VDDD.n760 2.24901
R3618 VDDD.n761 VDDD.n759 2.24901
R3619 VDDD.n860 VDDD.n790 2.24901
R3620 VDDD.n860 VDDD.n801 2.24901
R3621 VDDD.n1447 VDDD.n1446 2.24901
R3622 VDDD.n1446 VDDD.n1380 2.24901
R3623 VDDD.n1484 VDDD.n1352 2.24901
R3624 VDDD.n1484 VDDD.n1334 2.24901
R3625 VDDD.n1593 VDDD.n1592 2.24901
R3626 VDDD.n1592 VDDD.n1309 2.24901
R3627 VDDD.n1630 VDDD.n1281 2.24901
R3628 VDDD.n1630 VDDD.n1263 2.24901
R3629 VDDD.n1739 VDDD.n1738 2.24901
R3630 VDDD.n1738 VDDD.n1238 2.24901
R3631 VDDD.n1776 VDDD.n1210 2.24901
R3632 VDDD.n1776 VDDD.n1192 2.24901
R3633 VDDD.n1885 VDDD.n1884 2.24901
R3634 VDDD.n1884 VDDD.n1167 2.24901
R3635 VDDD.n1922 VDDD.n1139 2.24901
R3636 VDDD.n1922 VDDD.n1121 2.24901
R3637 VDDD.n2015 VDDD.n2014 2.24901
R3638 VDDD.n2014 VDDD.n1085 2.24901
R3639 VDDD.n2055 VDDD.n1057 2.24901
R3640 VDDD.n2055 VDDD.n1039 2.24901
R3641 VDDD.n2738 VDDD.n2737 2.24901
R3642 VDDD.n2737 VDDD.n67 2.24901
R3643 VDDD.n2775 VDDD.n39 2.24901
R3644 VDDD.n2775 VDDD.n21 2.24901
R3645 VDDD.n261 VDDD.n180 2.24721
R3646 VDDD.n261 VDDD.n179 2.24721
R3647 VDDD.n261 VDDD.n178 2.24721
R3648 VDDD.n261 VDDD.n177 2.24721
R3649 VDDD.n253 VDDD.n183 2.24721
R3650 VDDD.n255 VDDD.n183 2.24721
R3651 VDDD.n257 VDDD.n183 2.24721
R3652 VDDD.n414 VDDD.n333 2.24721
R3653 VDDD.n414 VDDD.n332 2.24721
R3654 VDDD.n414 VDDD.n331 2.24721
R3655 VDDD.n414 VDDD.n330 2.24721
R3656 VDDD.n406 VDDD.n336 2.24721
R3657 VDDD.n408 VDDD.n336 2.24721
R3658 VDDD.n410 VDDD.n336 2.24721
R3659 VDDD.n567 VDDD.n486 2.24721
R3660 VDDD.n567 VDDD.n485 2.24721
R3661 VDDD.n567 VDDD.n484 2.24721
R3662 VDDD.n567 VDDD.n483 2.24721
R3663 VDDD.n559 VDDD.n489 2.24721
R3664 VDDD.n561 VDDD.n489 2.24721
R3665 VDDD.n563 VDDD.n489 2.24721
R3666 VDDD.n720 VDDD.n639 2.24721
R3667 VDDD.n720 VDDD.n638 2.24721
R3668 VDDD.n720 VDDD.n637 2.24721
R3669 VDDD.n720 VDDD.n636 2.24721
R3670 VDDD.n712 VDDD.n642 2.24721
R3671 VDDD.n714 VDDD.n642 2.24721
R3672 VDDD.n716 VDDD.n642 2.24721
R3673 VDDD.n870 VDDD.n789 2.24721
R3674 VDDD.n870 VDDD.n788 2.24721
R3675 VDDD.n870 VDDD.n787 2.24721
R3676 VDDD.n870 VDDD.n786 2.24721
R3677 VDDD.n862 VDDD.n792 2.24721
R3678 VDDD.n864 VDDD.n792 2.24721
R3679 VDDD.n866 VDDD.n792 2.24721
R3680 VDDD.n1457 VDDD.n1455 2.24721
R3681 VDDD.n1457 VDDD.n1454 2.24721
R3682 VDDD.n1458 VDDD.n1457 2.24721
R3683 VDDD.n1457 VDDD.n1363 2.24721
R3684 VDDD.n1374 VDDD.n1362 2.24721
R3685 VDDD.n1376 VDDD.n1362 2.24721
R3686 VDDD.n1372 VDDD.n1364 2.24721
R3687 VDDD.n1371 VDDD.n1361 2.24721
R3688 VDDD.n1603 VDDD.n1601 2.24721
R3689 VDDD.n1603 VDDD.n1600 2.24721
R3690 VDDD.n1604 VDDD.n1603 2.24721
R3691 VDDD.n1603 VDDD.n1292 2.24721
R3692 VDDD.n1303 VDDD.n1291 2.24721
R3693 VDDD.n1305 VDDD.n1291 2.24721
R3694 VDDD.n1301 VDDD.n1293 2.24721
R3695 VDDD.n1300 VDDD.n1290 2.24721
R3696 VDDD.n1749 VDDD.n1747 2.24721
R3697 VDDD.n1749 VDDD.n1746 2.24721
R3698 VDDD.n1750 VDDD.n1749 2.24721
R3699 VDDD.n1749 VDDD.n1221 2.24721
R3700 VDDD.n1232 VDDD.n1220 2.24721
R3701 VDDD.n1234 VDDD.n1220 2.24721
R3702 VDDD.n1230 VDDD.n1222 2.24721
R3703 VDDD.n1229 VDDD.n1219 2.24721
R3704 VDDD.n1895 VDDD.n1893 2.24721
R3705 VDDD.n1895 VDDD.n1892 2.24721
R3706 VDDD.n1896 VDDD.n1895 2.24721
R3707 VDDD.n1895 VDDD.n1150 2.24721
R3708 VDDD.n1161 VDDD.n1149 2.24721
R3709 VDDD.n1163 VDDD.n1149 2.24721
R3710 VDDD.n1159 VDDD.n1151 2.24721
R3711 VDDD.n1158 VDDD.n1148 2.24721
R3712 VDDD.n2028 VDDD.n2026 2.24721
R3713 VDDD.n2028 VDDD.n2025 2.24721
R3714 VDDD.n2029 VDDD.n2028 2.24721
R3715 VDDD.n2028 VDDD.n1068 2.24721
R3716 VDDD.n1079 VDDD.n1067 2.24721
R3717 VDDD.n1081 VDDD.n1067 2.24721
R3718 VDDD.n1077 VDDD.n1069 2.24721
R3719 VDDD.n1076 VDDD.n1066 2.24721
R3720 VDDD.n2748 VDDD.n2746 2.24721
R3721 VDDD.n2748 VDDD.n2745 2.24721
R3722 VDDD.n2749 VDDD.n2748 2.24721
R3723 VDDD.n2748 VDDD.n50 2.24721
R3724 VDDD.n61 VDDD.n49 2.24721
R3725 VDDD.n63 VDDD.n49 2.24721
R3726 VDDD.n59 VDDD.n51 2.24721
R3727 VDDD.n58 VDDD.n48 2.24721
R3728 VDDD.n259 VDDD.n252 2.24721
R3729 VDDD.n412 VDDD.n405 2.24721
R3730 VDDD.n565 VDDD.n558 2.24721
R3731 VDDD.n718 VDDD.n711 2.24721
R3732 VDDD.n868 VDDD.n861 2.24721
R3733 VDDD.n151 VDDD.n121 2.24702
R3734 VDDD.n133 VDDD.n121 2.24702
R3735 VDDD.n136 VDDD.n121 2.24702
R3736 VDDD.n131 VDDD.n120 2.24702
R3737 VDDD.n134 VDDD.n120 2.24702
R3738 VDDD.n137 VDDD.n120 2.24702
R3739 VDDD.n125 VDDD.n119 2.24702
R3740 VDDD.n220 VDDD.n218 2.24702
R3741 VDDD.n220 VDDD.n217 2.24702
R3742 VDDD.n220 VDDD.n215 2.24702
R3743 VDDD.n220 VDDD.n205 2.24702
R3744 VDDD.n222 VDDD.n214 2.24702
R3745 VDDD.n222 VDDD.n213 2.24702
R3746 VDDD.n222 VDDD.n212 2.24702
R3747 VDDD.n222 VDDD.n211 2.24702
R3748 VDDD.n207 VDDD.n130 2.24702
R3749 VDDD.n304 VDDD.n274 2.24702
R3750 VDDD.n286 VDDD.n274 2.24702
R3751 VDDD.n289 VDDD.n274 2.24702
R3752 VDDD.n284 VDDD.n273 2.24702
R3753 VDDD.n287 VDDD.n273 2.24702
R3754 VDDD.n290 VDDD.n273 2.24702
R3755 VDDD.n278 VDDD.n272 2.24702
R3756 VDDD.n373 VDDD.n371 2.24702
R3757 VDDD.n373 VDDD.n370 2.24702
R3758 VDDD.n373 VDDD.n368 2.24702
R3759 VDDD.n373 VDDD.n358 2.24702
R3760 VDDD.n375 VDDD.n367 2.24702
R3761 VDDD.n375 VDDD.n366 2.24702
R3762 VDDD.n375 VDDD.n365 2.24702
R3763 VDDD.n375 VDDD.n364 2.24702
R3764 VDDD.n360 VDDD.n283 2.24702
R3765 VDDD.n457 VDDD.n427 2.24702
R3766 VDDD.n439 VDDD.n427 2.24702
R3767 VDDD.n442 VDDD.n427 2.24702
R3768 VDDD.n437 VDDD.n426 2.24702
R3769 VDDD.n440 VDDD.n426 2.24702
R3770 VDDD.n443 VDDD.n426 2.24702
R3771 VDDD.n431 VDDD.n425 2.24702
R3772 VDDD.n526 VDDD.n524 2.24702
R3773 VDDD.n526 VDDD.n523 2.24702
R3774 VDDD.n526 VDDD.n521 2.24702
R3775 VDDD.n526 VDDD.n511 2.24702
R3776 VDDD.n528 VDDD.n520 2.24702
R3777 VDDD.n528 VDDD.n519 2.24702
R3778 VDDD.n528 VDDD.n518 2.24702
R3779 VDDD.n528 VDDD.n517 2.24702
R3780 VDDD.n513 VDDD.n436 2.24702
R3781 VDDD.n610 VDDD.n580 2.24702
R3782 VDDD.n592 VDDD.n580 2.24702
R3783 VDDD.n595 VDDD.n580 2.24702
R3784 VDDD.n590 VDDD.n579 2.24702
R3785 VDDD.n593 VDDD.n579 2.24702
R3786 VDDD.n596 VDDD.n579 2.24702
R3787 VDDD.n584 VDDD.n578 2.24702
R3788 VDDD.n679 VDDD.n677 2.24702
R3789 VDDD.n679 VDDD.n676 2.24702
R3790 VDDD.n679 VDDD.n674 2.24702
R3791 VDDD.n679 VDDD.n664 2.24702
R3792 VDDD.n681 VDDD.n673 2.24702
R3793 VDDD.n681 VDDD.n672 2.24702
R3794 VDDD.n681 VDDD.n671 2.24702
R3795 VDDD.n681 VDDD.n670 2.24702
R3796 VDDD.n666 VDDD.n589 2.24702
R3797 VDDD.n763 VDDD.n733 2.24702
R3798 VDDD.n745 VDDD.n733 2.24702
R3799 VDDD.n748 VDDD.n733 2.24702
R3800 VDDD.n743 VDDD.n732 2.24702
R3801 VDDD.n746 VDDD.n732 2.24702
R3802 VDDD.n749 VDDD.n732 2.24702
R3803 VDDD.n737 VDDD.n731 2.24702
R3804 VDDD.n829 VDDD.n827 2.24702
R3805 VDDD.n829 VDDD.n826 2.24702
R3806 VDDD.n829 VDDD.n824 2.24702
R3807 VDDD.n829 VDDD.n814 2.24702
R3808 VDDD.n831 VDDD.n823 2.24702
R3809 VDDD.n831 VDDD.n822 2.24702
R3810 VDDD.n831 VDDD.n821 2.24702
R3811 VDDD.n831 VDDD.n820 2.24702
R3812 VDDD.n816 VDDD.n742 2.24702
R3813 VDDD.n1346 VDDD.n1345 2.24702
R3814 VDDD.n1346 VDDD.n1344 2.24702
R3815 VDDD.n1346 VDDD.n1343 2.24702
R3816 VDDD.n1341 VDDD.n1340 2.24702
R3817 VDDD.n1341 VDDD.n1339 2.24702
R3818 VDDD.n1350 VDDD.n1341 2.24702
R3819 VDDD.n1488 VDDD.n1330 2.24702
R3820 VDDD.n1500 VDDD.n1498 2.24702
R3821 VDDD.n1500 VDDD.n1495 2.24702
R3822 VDDD.n1501 VDDD.n1500 2.24702
R3823 VDDD.n1500 VDDD.n1497 2.24702
R3824 VDDD.n1506 VDDD.n1505 2.24702
R3825 VDDD.n1507 VDDD.n1506 2.24702
R3826 VDDD.n1506 VDDD.n1504 2.24702
R3827 VDDD.n1506 VDDD.n1503 2.24702
R3828 VDDD.n1510 VDDD.n1509 2.24702
R3829 VDDD.n1275 VDDD.n1274 2.24702
R3830 VDDD.n1275 VDDD.n1273 2.24702
R3831 VDDD.n1275 VDDD.n1272 2.24702
R3832 VDDD.n1270 VDDD.n1269 2.24702
R3833 VDDD.n1270 VDDD.n1268 2.24702
R3834 VDDD.n1279 VDDD.n1270 2.24702
R3835 VDDD.n1634 VDDD.n1259 2.24702
R3836 VDDD.n1646 VDDD.n1644 2.24702
R3837 VDDD.n1646 VDDD.n1641 2.24702
R3838 VDDD.n1647 VDDD.n1646 2.24702
R3839 VDDD.n1646 VDDD.n1643 2.24702
R3840 VDDD.n1652 VDDD.n1651 2.24702
R3841 VDDD.n1653 VDDD.n1652 2.24702
R3842 VDDD.n1652 VDDD.n1650 2.24702
R3843 VDDD.n1652 VDDD.n1649 2.24702
R3844 VDDD.n1656 VDDD.n1655 2.24702
R3845 VDDD.n1204 VDDD.n1203 2.24702
R3846 VDDD.n1204 VDDD.n1202 2.24702
R3847 VDDD.n1204 VDDD.n1201 2.24702
R3848 VDDD.n1199 VDDD.n1198 2.24702
R3849 VDDD.n1199 VDDD.n1197 2.24702
R3850 VDDD.n1208 VDDD.n1199 2.24702
R3851 VDDD.n1780 VDDD.n1188 2.24702
R3852 VDDD.n1792 VDDD.n1790 2.24702
R3853 VDDD.n1792 VDDD.n1787 2.24702
R3854 VDDD.n1793 VDDD.n1792 2.24702
R3855 VDDD.n1792 VDDD.n1789 2.24702
R3856 VDDD.n1798 VDDD.n1797 2.24702
R3857 VDDD.n1799 VDDD.n1798 2.24702
R3858 VDDD.n1798 VDDD.n1796 2.24702
R3859 VDDD.n1798 VDDD.n1795 2.24702
R3860 VDDD.n1802 VDDD.n1801 2.24702
R3861 VDDD.n1133 VDDD.n1132 2.24702
R3862 VDDD.n1133 VDDD.n1131 2.24702
R3863 VDDD.n1133 VDDD.n1130 2.24702
R3864 VDDD.n1128 VDDD.n1127 2.24702
R3865 VDDD.n1128 VDDD.n1126 2.24702
R3866 VDDD.n1137 VDDD.n1128 2.24702
R3867 VDDD.n1926 VDDD.n1117 2.24702
R3868 VDDD.n1938 VDDD.n1936 2.24702
R3869 VDDD.n1938 VDDD.n1933 2.24702
R3870 VDDD.n1939 VDDD.n1938 2.24702
R3871 VDDD.n1938 VDDD.n1935 2.24702
R3872 VDDD.n1944 VDDD.n1943 2.24702
R3873 VDDD.n1945 VDDD.n1944 2.24702
R3874 VDDD.n1944 VDDD.n1942 2.24702
R3875 VDDD.n1944 VDDD.n1941 2.24702
R3876 VDDD.n1948 VDDD.n1947 2.24702
R3877 VDDD.n1051 VDDD.n1050 2.24702
R3878 VDDD.n1051 VDDD.n1049 2.24702
R3879 VDDD.n1051 VDDD.n1048 2.24702
R3880 VDDD.n1046 VDDD.n1045 2.24702
R3881 VDDD.n1046 VDDD.n1044 2.24702
R3882 VDDD.n1055 VDDD.n1046 2.24702
R3883 VDDD.n2059 VDDD.n1035 2.24702
R3884 VDDD.n2071 VDDD.n2069 2.24702
R3885 VDDD.n2071 VDDD.n2066 2.24702
R3886 VDDD.n2072 VDDD.n2071 2.24702
R3887 VDDD.n2071 VDDD.n2068 2.24702
R3888 VDDD.n2077 VDDD.n2076 2.24702
R3889 VDDD.n2078 VDDD.n2077 2.24702
R3890 VDDD.n2077 VDDD.n2075 2.24702
R3891 VDDD.n2077 VDDD.n2074 2.24702
R3892 VDDD.n2081 VDDD.n2080 2.24702
R3893 VDDD.n33 VDDD.n32 2.24702
R3894 VDDD.n33 VDDD.n31 2.24702
R3895 VDDD.n33 VDDD.n30 2.24702
R3896 VDDD.n28 VDDD.n27 2.24702
R3897 VDDD.n28 VDDD.n26 2.24702
R3898 VDDD.n37 VDDD.n28 2.24702
R3899 VDDD.n2779 VDDD.n17 2.24702
R3900 VDDD.n2791 VDDD.n2789 2.24702
R3901 VDDD.n2791 VDDD.n2786 2.24702
R3902 VDDD.n2792 VDDD.n2791 2.24702
R3903 VDDD.n2791 VDDD.n2788 2.24702
R3904 VDDD.n2797 VDDD.n2796 2.24702
R3905 VDDD.n2798 VDDD.n2797 2.24702
R3906 VDDD.n2797 VDDD.n2795 2.24702
R3907 VDDD.n2797 VDDD.n2794 2.24702
R3908 VDDD.n2801 VDDD.n2800 2.24702
R3909 VDDD.n2549 VDDD.n129 2.24702
R3910 VDDD.n2487 VDDD.n282 2.24702
R3911 VDDD.n2425 VDDD.n435 2.24702
R3912 VDDD.n2363 VDDD.n588 2.24702
R3913 VDDD.n2301 VDDD.n741 2.24702
R3914 VDDD.n1486 VDDD.n1485 2.24702
R3915 VDDD.n1632 VDDD.n1631 2.24702
R3916 VDDD.n1778 VDDD.n1777 2.24702
R3917 VDDD.n1924 VDDD.n1923 2.24702
R3918 VDDD.n2057 VDDD.n2056 2.24702
R3919 VDDD.n2777 VDDD.n2776 2.24702
R3920 VDDD.n2523 VDDD.n2522 2.0005
R3921 VDDD.n2461 VDDD.n2460 2.0005
R3922 VDDD.n2399 VDDD.n2398 2.0005
R3923 VDDD.n2337 VDDD.n2336 2.0005
R3924 VDDD.n2275 VDDD.n2274 2.0005
R3925 VDDD.n1434 VDDD.n1433 2.0005
R3926 VDDD.n1580 VDDD.n1579 2.0005
R3927 VDDD.n1726 VDDD.n1725 2.0005
R3928 VDDD.n1872 VDDD.n1871 2.0005
R3929 VDDD.n2002 VDDD.n2001 2.0005
R3930 VDDD.n2725 VDDD.n2724 2.0005
R3931 VDDD.n249 VDDD.t295 1.8511
R3932 VDDD.n246 VDDD.t176 1.8511
R3933 VDDD.n247 VDDD.t558 1.8511
R3934 VDDD.n402 VDDD.t282 1.8511
R3935 VDDD.n399 VDDD.t133 1.8511
R3936 VDDD.n400 VDDD.t220 1.8511
R3937 VDDD.n555 VDDD.t317 1.8511
R3938 VDDD.n552 VDDD.t397 1.8511
R3939 VDDD.n553 VDDD.t433 1.8511
R3940 VDDD.n708 VDDD.t554 1.8511
R3941 VDDD.n705 VDDD.t569 1.8511
R3942 VDDD.n706 VDDD.t452 1.8511
R3943 VDDD.n858 VDDD.t9 1.8511
R3944 VDDD.n855 VDDD.t506 1.8511
R3945 VDDD.n856 VDDD.t84 1.8511
R3946 VDDD.n1467 VDDD.t68 1.8511
R3947 VDDD.n1469 VDDD.t490 1.8511
R3948 VDDD.n1470 VDDD.t522 1.8511
R3949 VDDD.n1613 VDDD.t261 1.8511
R3950 VDDD.n1615 VDDD.t517 1.8511
R3951 VDDD.n1616 VDDD.t513 1.8511
R3952 VDDD.n1759 VDDD.t197 1.8511
R3953 VDDD.n1761 VDDD.t369 1.8511
R3954 VDDD.n1762 VDDD.t222 1.8511
R3955 VDDD.n1905 VDDD.t41 1.8511
R3956 VDDD.n1907 VDDD.t349 1.8511
R3957 VDDD.n1908 VDDD.t415 1.8511
R3958 VDDD.n2038 VDDD.t95 1.8511
R3959 VDDD.n2040 VDDD.t253 1.8511
R3960 VDDD.n2041 VDDD.t509 1.8511
R3961 VDDD.n2758 VDDD.t4 1.8511
R3962 VDDD.n2760 VDDD.t93 1.8511
R3963 VDDD.n2761 VDDD.t511 1.8511
R3964 VDDD.n248 VDDD.t542 1.8511
R3965 VDDD.n401 VDDD.t405 1.8511
R3966 VDDD.n554 VDDD.t580 1.8511
R3967 VDDD.n707 VDDD.t428 1.8511
R3968 VDDD.n857 VDDD.t422 1.8511
R3969 VDDD.n1468 VDDD.t147 1.8511
R3970 VDDD.n1614 VDDD.t529 1.8511
R3971 VDDD.n1760 VDDD.t603 1.8511
R3972 VDDD.n1906 VDDD.t527 1.8511
R3973 VDDD.n2039 VDDD.t600 1.8511
R3974 VDDD.n2759 VDDD.t577 1.8511
R3975 VDDD.n2512 VDDD.t539 1.8501
R3976 VDDD.n2450 VDDD.t426 1.8501
R3977 VDDD.n2388 VDDD.t420 1.8501
R3978 VDDD.n2326 VDDD.t418 1.8501
R3979 VDDD.n2264 VDDD.t595 1.8501
R3980 VDDD.n1440 VDDD.t403 1.8501
R3981 VDDD.n1586 VDDD.t424 1.8501
R3982 VDDD.n1732 VDDD.t597 1.8501
R3983 VDDD.n1878 VDDD.t537 1.8501
R3984 VDDD.n2008 VDDD.t153 1.8501
R3985 VDDD.n2731 VDDD.t575 1.8501
R3986 VDDD.n2513 VDDD.t182 1.8501
R3987 VDDD.n2511 VDDD.t343 1.8501
R3988 VDDD.n2510 VDDD.t137 1.8501
R3989 VDDD.n2451 VDDD.t113 1.8501
R3990 VDDD.n2449 VDDD.t413 1.8501
R3991 VDDD.n2448 VDDD.t567 1.8501
R3992 VDDD.n2389 VDDD.t52 1.8501
R3993 VDDD.n2387 VDDD.t184 1.8501
R3994 VDDD.n2386 VDDD.t143 1.8501
R3995 VDDD.n2327 VDDD.t387 1.8501
R3996 VDDD.n2325 VDDD.t267 1.8501
R3997 VDDD.n2324 VDDD.t58 1.8501
R3998 VDDD.n2265 VDDD.t247 1.8501
R3999 VDDD.n2263 VDDD.t571 1.8501
R4000 VDDD.n2262 VDDD.t499 1.8501
R4001 VDDD.n1439 VDDD.t210 1.8501
R4002 VDDD.n1442 VDDD.t504 1.8501
R4003 VDDD.n1441 VDDD.t299 1.8501
R4004 VDDD.n1585 VDDD.t128 1.8501
R4005 VDDD.n1588 VDDD.t258 1.8501
R4006 VDDD.n1587 VDDD.t319 1.8501
R4007 VDDD.n1731 VDDD.t265 1.8501
R4008 VDDD.n1734 VDDD.t135 1.8501
R4009 VDDD.n1733 VDDD.t102 1.8501
R4010 VDDD.n1877 VDDD.t391 1.8501
R4011 VDDD.n1880 VDDD.t141 1.8501
R4012 VDDD.n1879 VDDD.t37 1.8501
R4013 VDDD.n2007 VDDD.t124 1.8501
R4014 VDDD.n2010 VDDD.t217 1.8501
R4015 VDDD.n2009 VDDD.t351 1.8501
R4016 VDDD.n2730 VDDD.t28 1.8501
R4017 VDDD.n2733 VDDD.t173 1.8501
R4018 VDDD.n2732 VDDD.t43 1.8501
R4019 VDDD.n244 VDDD.n243 1.8005
R4020 VDDD.n242 VDDD.n241 1.8005
R4021 VDDD.n240 VDDD.n193 1.8005
R4022 VDDD.n397 VDDD.n396 1.8005
R4023 VDDD.n395 VDDD.n394 1.8005
R4024 VDDD.n393 VDDD.n346 1.8005
R4025 VDDD.n550 VDDD.n549 1.8005
R4026 VDDD.n548 VDDD.n547 1.8005
R4027 VDDD.n546 VDDD.n499 1.8005
R4028 VDDD.n703 VDDD.n702 1.8005
R4029 VDDD.n701 VDDD.n700 1.8005
R4030 VDDD.n699 VDDD.n652 1.8005
R4031 VDDD.n853 VDDD.n852 1.8005
R4032 VDDD.n851 VDDD.n850 1.8005
R4033 VDDD.n849 VDDD.n802 1.8005
R4034 VDDD.n1431 VDDD.n1403 1.8005
R4035 VDDD.n1426 VDDD.n1400 1.8005
R4036 VDDD.n1425 VDDD.n1402 1.8005
R4037 VDDD.n1427 VDDD.n1401 1.8005
R4038 VDDD.n1465 VDDD.n1464 1.8005
R4039 VDDD.n1463 VDDD.n1360 1.8005
R4040 VDDD.n1462 VDDD.n1359 1.8005
R4041 VDDD.n1577 VDDD.n1549 1.8005
R4042 VDDD.n1572 VDDD.n1546 1.8005
R4043 VDDD.n1571 VDDD.n1548 1.8005
R4044 VDDD.n1573 VDDD.n1547 1.8005
R4045 VDDD.n1611 VDDD.n1610 1.8005
R4046 VDDD.n1609 VDDD.n1289 1.8005
R4047 VDDD.n1608 VDDD.n1288 1.8005
R4048 VDDD.n1723 VDDD.n1695 1.8005
R4049 VDDD.n1718 VDDD.n1692 1.8005
R4050 VDDD.n1717 VDDD.n1694 1.8005
R4051 VDDD.n1719 VDDD.n1693 1.8005
R4052 VDDD.n1757 VDDD.n1756 1.8005
R4053 VDDD.n1755 VDDD.n1218 1.8005
R4054 VDDD.n1754 VDDD.n1217 1.8005
R4055 VDDD.n1869 VDDD.n1841 1.8005
R4056 VDDD.n1864 VDDD.n1838 1.8005
R4057 VDDD.n1863 VDDD.n1840 1.8005
R4058 VDDD.n1865 VDDD.n1839 1.8005
R4059 VDDD.n1903 VDDD.n1902 1.8005
R4060 VDDD.n1901 VDDD.n1147 1.8005
R4061 VDDD.n1900 VDDD.n1146 1.8005
R4062 VDDD.n1994 VDDD.n1969 1.8005
R4063 VDDD.n1999 VDDD.n1972 1.8005
R4064 VDDD.n1996 VDDD.n1971 1.8005
R4065 VDDD.n1997 VDDD.n1970 1.8005
R4066 VDDD.n2036 VDDD.n2035 1.8005
R4067 VDDD.n2034 VDDD.n1065 1.8005
R4068 VDDD.n2033 VDDD.n1064 1.8005
R4069 VDDD.n2254 VDDD.n776 1.8005
R4070 VDDD.n2255 VDDD.n775 1.8005
R4071 VDDD.n2257 VDDD.n777 1.8005
R4072 VDDD.n2252 VDDD.n774 1.8005
R4073 VDDD.n2316 VDDD.n623 1.8005
R4074 VDDD.n2317 VDDD.n622 1.8005
R4075 VDDD.n2319 VDDD.n624 1.8005
R4076 VDDD.n2314 VDDD.n621 1.8005
R4077 VDDD.n2378 VDDD.n470 1.8005
R4078 VDDD.n2379 VDDD.n469 1.8005
R4079 VDDD.n2381 VDDD.n471 1.8005
R4080 VDDD.n2376 VDDD.n468 1.8005
R4081 VDDD.n2440 VDDD.n317 1.8005
R4082 VDDD.n2441 VDDD.n316 1.8005
R4083 VDDD.n2443 VDDD.n318 1.8005
R4084 VDDD.n2438 VDDD.n315 1.8005
R4085 VDDD.n2502 VDDD.n164 1.8005
R4086 VDDD.n2503 VDDD.n163 1.8005
R4087 VDDD.n2505 VDDD.n165 1.8005
R4088 VDDD.n2500 VDDD.n162 1.8005
R4089 VDDD.n2722 VDDD.n2694 1.8005
R4090 VDDD.n2717 VDDD.n2691 1.8005
R4091 VDDD.n2716 VDDD.n2693 1.8005
R4092 VDDD.n2718 VDDD.n2692 1.8005
R4093 VDDD.n2756 VDDD.n2755 1.8005
R4094 VDDD.n2754 VDDD.n47 1.8005
R4095 VDDD.n2753 VDDD.n46 1.8005
R4096 VDDD.n2617 VDDD.n2552 1.58045
R4097 VDDD.n46 VDDD.t474 1.4972
R4098 VDDD.n47 VDDD.t336 1.4972
R4099 VDDD.n2756 VDDD.t2 1.4972
R4100 VDDD.n162 VDDD.t180 1.4972
R4101 VDDD.n161 VDDD.t321 1.4972
R4102 VDDD.n2526 VDDD.t365 1.4972
R4103 VDDD.n2506 VDDD.t371 1.4972
R4104 VDDD.n244 VDDD.t292 1.4972
R4105 VDDD.n241 VDDD.t468 1.4972
R4106 VDDD.n193 VDDD.t118 1.4972
R4107 VDDD.n315 VDDD.t111 1.4972
R4108 VDDD.n314 VDDD.t121 1.4972
R4109 VDDD.n2464 VDDD.t556 1.4972
R4110 VDDD.n2444 VDDD.t241 1.4972
R4111 VDDD.n397 VDDD.t301 1.4972
R4112 VDDD.n394 VDDD.t472 1.4972
R4113 VDDD.n346 VDDD.t280 1.4972
R4114 VDDD.n468 VDDD.t50 1.4972
R4115 VDDD.n467 VDDD.t449 1.4972
R4116 VDDD.n2402 VDDD.t325 1.4972
R4117 VDDD.n2382 VDDD.t361 1.4972
R4118 VDDD.n550 VDDD.t33 1.4972
R4119 VDDD.n547 VDDD.t466 1.4972
R4120 VDDD.n499 VDDD.t201 1.4972
R4121 VDDD.n621 VDDD.t389 1.4972
R4122 VDDD.n620 VDDD.t410 1.4972
R4123 VDDD.n2340 VDDD.t47 1.4972
R4124 VDDD.n2320 VDDD.t314 1.4972
R4125 VDDD.n703 VDDD.t546 1.4972
R4126 VDDD.n700 VDDD.t470 1.4972
R4127 VDDD.n652 VDDD.t552 1.4972
R4128 VDDD.n774 VDDD.t168 1.4972
R4129 VDDD.n773 VDDD.t445 1.4972
R4130 VDDD.n2278 VDDD.t157 1.4972
R4131 VDDD.n2258 VDDD.t367 1.4972
R4132 VDDD.n853 VDDD.t227 1.4972
R4133 VDDD.n850 VDDD.t476 1.4972
R4134 VDDD.n802 VDDD.t11 1.4972
R4135 VDDD.n1064 VDDD.t480 1.4972
R4136 VDDD.n1065 VDDD.t271 1.4972
R4137 VDDD.n2036 VDDD.t250 1.4972
R4138 VDDD.n1146 VDDD.t478 1.4972
R4139 VDDD.n1147 VDDD.t98 1.4972
R4140 VDDD.n1903 VDDD.t224 1.4972
R4141 VDDD.n1217 VDDD.t482 1.4972
R4142 VDDD.n1218 VDDD.t393 1.4972
R4143 VDDD.n1757 VDDD.t199 1.4972
R4144 VDDD.n1288 VDDD.t484 1.4972
R4145 VDDD.n1289 VDDD.t55 1.4972
R4146 VDDD.n1611 VDDD.t589 1.4972
R4147 VDDD.n1359 VDDD.t464 1.4972
R4148 VDDD.n1360 VDDD.t89 1.4972
R4149 VDDD.n1465 VDDD.t66 1.4972
R4150 VDDD.n1402 VDDD.t284 1.4972
R4151 VDDD.n1403 VDDD.t212 1.4972
R4152 VDDD.n1404 VDDD.t286 1.4972
R4153 VDDD.n1410 VDDD.t159 1.4972
R4154 VDDD.n1399 VDDD.t233 1.4972
R4155 VDDD.n1400 VDDD.t328 1.4972
R4156 VDDD.n1401 VDDD.t488 1.4972
R4157 VDDD.n1548 VDDD.t586 1.4972
R4158 VDDD.n1549 VDDD.t130 1.4972
R4159 VDDD.n1550 VDDD.t584 1.4972
R4160 VDDD.n1556 VDDD.t462 1.4972
R4161 VDDD.n1545 VDDD.t236 1.4972
R4162 VDDD.n1546 VDDD.t192 1.4972
R4163 VDDD.n1547 VDDD.t86 1.4972
R4164 VDDD.n1694 VDDD.t385 1.4972
R4165 VDDD.n1695 VDDD.t263 1.4972
R4166 VDDD.n1696 VDDD.t373 1.4972
R4167 VDDD.n1702 VDDD.t347 1.4972
R4168 VDDD.n1691 VDDD.t20 1.4972
R4169 VDDD.n1692 VDDD.t308 1.4972
R4170 VDDD.n1693 VDDD.t493 1.4972
R4171 VDDD.n1840 VDDD.t81 1.4972
R4172 VDDD.n1841 VDDD.t456 1.4972
R4173 VDDD.n1842 VDDD.t79 1.4972
R4174 VDDD.n1848 VDDD.t104 1.4972
R4175 VDDD.n1837 VDDD.t288 1.4972
R4176 VDDD.n1838 VDDD.t76 1.4972
R4177 VDDD.n1839 VDDD.t62 1.4972
R4178 VDDD.n1971 VDDD.t276 1.4972
R4179 VDDD.n1968 VDDD.t363 1.4972
R4180 VDDD.n1969 VDDD.t355 1.4972
R4181 VDDD.n1972 VDDD.t164 1.4972
R4182 VDDD.n1973 VDDD.t273 1.4972
R4183 VDDD.n1979 VDDD.t278 1.4972
R4184 VDDD.n1970 VDDD.t339 1.4972
R4185 VDDD.n775 VDDD.t443 1.4972
R4186 VDDD.n776 VDDD.t331 1.4972
R4187 VDDD.n777 VDDD.t145 1.4972
R4188 VDDD.n622 VDDD.t407 1.4972
R4189 VDDD.n623 VDDD.t187 1.4972
R4190 VDDD.n624 VDDD.t16 1.4972
R4191 VDDD.n469 VDDD.t208 1.4972
R4192 VDDD.n470 VDDD.t203 1.4972
R4193 VDDD.n471 VDDD.t436 1.4972
R4194 VDDD.n316 VDDD.t116 1.4972
R4195 VDDD.n317 VDDD.t72 1.4972
R4196 VDDD.n318 VDDD.t161 1.4972
R4197 VDDD.n163 VDDD.t323 1.4972
R4198 VDDD.n164 VDDD.t7 1.4972
R4199 VDDD.n165 VDDD.t239 1.4972
R4200 VDDD.n2693 VDDD.t441 1.4972
R4201 VDDD.n2694 VDDD.t26 1.4972
R4202 VDDD.n2695 VDDD.t439 1.4972
R4203 VDDD.n2701 VDDD.t550 1.4972
R4204 VDDD.n2690 VDDD.t215 1.4972
R4205 VDDD.n2691 VDDD.t519 1.4972
R4206 VDDD.n2692 VDDD.t312 1.4972
R4207 VDDD.n2529 VDDD.n2528 1.2605
R4208 VDDD.t364 VDDD.n2529 1.2605
R4209 VDDD.n2519 VDDD.n160 1.2605
R4210 VDDD.n2467 VDDD.n2466 1.2605
R4211 VDDD.t555 VDDD.n2467 1.2605
R4212 VDDD.n2457 VDDD.n313 1.2605
R4213 VDDD.n2405 VDDD.n2404 1.2605
R4214 VDDD.t324 VDDD.n2405 1.2605
R4215 VDDD.n2395 VDDD.n466 1.2605
R4216 VDDD.n2343 VDDD.n2342 1.2605
R4217 VDDD.t46 VDDD.n2343 1.2605
R4218 VDDD.n2333 VDDD.n619 1.2605
R4219 VDDD.n2281 VDDD.n2280 1.2605
R4220 VDDD.t156 VDDD.n2281 1.2605
R4221 VDDD.n2271 VDDD.n772 1.2605
R4222 VDDD.n1417 VDDD.n1409 1.2605
R4223 VDDD.n1409 VDDD.t158 1.2605
R4224 VDDD.n1424 VDDD.n1423 1.2605
R4225 VDDD.n1412 VDDD.n1408 1.2605
R4226 VDDD.n1408 VDDD.t158 1.2605
R4227 VDDD.n1436 VDDD.n1435 1.2605
R4228 VDDD.n1563 VDDD.n1555 1.2605
R4229 VDDD.n1555 VDDD.t461 1.2605
R4230 VDDD.n1570 VDDD.n1569 1.2605
R4231 VDDD.n1558 VDDD.n1554 1.2605
R4232 VDDD.n1554 VDDD.t461 1.2605
R4233 VDDD.n1582 VDDD.n1581 1.2605
R4234 VDDD.n1709 VDDD.n1701 1.2605
R4235 VDDD.n1701 VDDD.t346 1.2605
R4236 VDDD.n1716 VDDD.n1715 1.2605
R4237 VDDD.n1704 VDDD.n1700 1.2605
R4238 VDDD.n1700 VDDD.t346 1.2605
R4239 VDDD.n1728 VDDD.n1727 1.2605
R4240 VDDD.n1855 VDDD.n1847 1.2605
R4241 VDDD.n1847 VDDD.t103 1.2605
R4242 VDDD.n1862 VDDD.n1861 1.2605
R4243 VDDD.n1850 VDDD.n1846 1.2605
R4244 VDDD.n1846 VDDD.t103 1.2605
R4245 VDDD.n1874 VDDD.n1873 1.2605
R4246 VDDD.n1986 VDDD.n1978 1.2605
R4247 VDDD.n1978 VDDD.t277 1.2605
R4248 VDDD.n1993 VDDD.n1992 1.2605
R4249 VDDD.n1981 VDDD.n1977 1.2605
R4250 VDDD.n1977 VDDD.t277 1.2605
R4251 VDDD.n2004 VDDD.n2003 1.2605
R4252 VDDD.n2268 VDDD.n771 1.2605
R4253 VDDD.n2283 VDDD.n2282 1.2605
R4254 VDDD.n2282 VDDD.t156 1.2605
R4255 VDDD.n2330 VDDD.n618 1.2605
R4256 VDDD.n2345 VDDD.n2344 1.2605
R4257 VDDD.n2344 VDDD.t46 1.2605
R4258 VDDD.n2392 VDDD.n465 1.2605
R4259 VDDD.n2407 VDDD.n2406 1.2605
R4260 VDDD.n2406 VDDD.t324 1.2605
R4261 VDDD.n2454 VDDD.n312 1.2605
R4262 VDDD.n2469 VDDD.n2468 1.2605
R4263 VDDD.n2468 VDDD.t555 1.2605
R4264 VDDD.n2516 VDDD.n159 1.2605
R4265 VDDD.n2531 VDDD.n2530 1.2605
R4266 VDDD.n2530 VDDD.t364 1.2605
R4267 VDDD.n2708 VDDD.n2700 1.2605
R4268 VDDD.n2700 VDDD.t549 1.2605
R4269 VDDD.n2715 VDDD.n2714 1.2605
R4270 VDDD.n2703 VDDD.n2699 1.2605
R4271 VDDD.n2699 VDDD.t549 1.2605
R4272 VDDD.n2727 VDDD.n2726 1.2605
R4273 VDDD.n1512 VDDD.n1329 1.1255
R4274 VDDD.n1529 VDDD.n1528 1.1255
R4275 VDDD.n1316 VDDD.n1314 1.1255
R4276 VDDD.n1525 VDDD.n1524 1.1255
R4277 VDDD.n1523 VDDD.n1319 1.1255
R4278 VDDD.n1522 VDDD.n1521 1.1255
R4279 VDDD.n1519 VDDD.n1518 1.1255
R4280 VDDD.n1517 VDDD.n1323 1.1255
R4281 VDDD.n1516 VDDD.n1515 1.1255
R4282 VDDD.n1327 VDDD.n1325 1.1255
R4283 VDDD.n1658 VDDD.n1258 1.1255
R4284 VDDD.n1675 VDDD.n1674 1.1255
R4285 VDDD.n1245 VDDD.n1243 1.1255
R4286 VDDD.n1671 VDDD.n1670 1.1255
R4287 VDDD.n1669 VDDD.n1248 1.1255
R4288 VDDD.n1668 VDDD.n1667 1.1255
R4289 VDDD.n1665 VDDD.n1664 1.1255
R4290 VDDD.n1663 VDDD.n1252 1.1255
R4291 VDDD.n1662 VDDD.n1661 1.1255
R4292 VDDD.n1256 VDDD.n1254 1.1255
R4293 VDDD.n1804 VDDD.n1187 1.1255
R4294 VDDD.n1821 VDDD.n1820 1.1255
R4295 VDDD.n1174 VDDD.n1172 1.1255
R4296 VDDD.n1817 VDDD.n1816 1.1255
R4297 VDDD.n1815 VDDD.n1177 1.1255
R4298 VDDD.n1814 VDDD.n1813 1.1255
R4299 VDDD.n1811 VDDD.n1810 1.1255
R4300 VDDD.n1809 VDDD.n1181 1.1255
R4301 VDDD.n1808 VDDD.n1807 1.1255
R4302 VDDD.n1185 VDDD.n1183 1.1255
R4303 VDDD.n1950 VDDD.n1116 1.1255
R4304 VDDD.n1967 VDDD.n1966 1.1255
R4305 VDDD.n1103 VDDD.n1101 1.1255
R4306 VDDD.n1963 VDDD.n1962 1.1255
R4307 VDDD.n1961 VDDD.n1106 1.1255
R4308 VDDD.n1960 VDDD.n1959 1.1255
R4309 VDDD.n1957 VDDD.n1956 1.1255
R4310 VDDD.n1955 VDDD.n1110 1.1255
R4311 VDDD.n1954 VDDD.n1953 1.1255
R4312 VDDD.n1114 VDDD.n1112 1.1255
R4313 VDDD.n2083 VDDD.n1034 1.1255
R4314 VDDD.n1032 VDDD.n1030 1.1255
R4315 VDDD.n2087 VDDD.n2086 1.1255
R4316 VDDD.n2088 VDDD.n1028 1.1255
R4317 VDDD.n2090 VDDD.n2089 1.1255
R4318 VDDD.n2093 VDDD.n2092 1.1255
R4319 VDDD.n2094 VDDD.n1024 1.1255
R4320 VDDD.n2096 VDDD.n2095 1.1255
R4321 VDDD.n1021 VDDD.n1019 1.1255
R4322 VDDD.n2100 VDDD.n2099 1.1255
R4323 VDDD.n2285 VDDD.n762 1.1255
R4324 VDDD.n2288 VDDD.n2287 1.1255
R4325 VDDD.n2286 VDDD.n758 1.1255
R4326 VDDD.n2292 VDDD.n757 1.1255
R4327 VDDD.n2294 VDDD.n2293 1.1255
R4328 VDDD.n2296 VDDD.n750 1.1255
R4329 VDDD.n2299 VDDD.n2298 1.1255
R4330 VDDD.n2297 VDDD.n754 1.1255
R4331 VDDD.n753 VDDD.n728 1.1255
R4332 VDDD.n2304 VDDD.n2303 1.1255
R4333 VDDD.n2347 VDDD.n609 1.1255
R4334 VDDD.n2350 VDDD.n2349 1.1255
R4335 VDDD.n2348 VDDD.n605 1.1255
R4336 VDDD.n2354 VDDD.n604 1.1255
R4337 VDDD.n2356 VDDD.n2355 1.1255
R4338 VDDD.n2358 VDDD.n597 1.1255
R4339 VDDD.n2361 VDDD.n2360 1.1255
R4340 VDDD.n2359 VDDD.n601 1.1255
R4341 VDDD.n600 VDDD.n575 1.1255
R4342 VDDD.n2366 VDDD.n2365 1.1255
R4343 VDDD.n2409 VDDD.n456 1.1255
R4344 VDDD.n2412 VDDD.n2411 1.1255
R4345 VDDD.n2410 VDDD.n452 1.1255
R4346 VDDD.n2416 VDDD.n451 1.1255
R4347 VDDD.n2418 VDDD.n2417 1.1255
R4348 VDDD.n2420 VDDD.n444 1.1255
R4349 VDDD.n2423 VDDD.n2422 1.1255
R4350 VDDD.n2421 VDDD.n448 1.1255
R4351 VDDD.n447 VDDD.n422 1.1255
R4352 VDDD.n2428 VDDD.n2427 1.1255
R4353 VDDD.n2471 VDDD.n303 1.1255
R4354 VDDD.n2474 VDDD.n2473 1.1255
R4355 VDDD.n2472 VDDD.n299 1.1255
R4356 VDDD.n2478 VDDD.n298 1.1255
R4357 VDDD.n2480 VDDD.n2479 1.1255
R4358 VDDD.n2482 VDDD.n291 1.1255
R4359 VDDD.n2485 VDDD.n2484 1.1255
R4360 VDDD.n2483 VDDD.n295 1.1255
R4361 VDDD.n294 VDDD.n269 1.1255
R4362 VDDD.n2490 VDDD.n2489 1.1255
R4363 VDDD.n2533 VDDD.n150 1.1255
R4364 VDDD.n2536 VDDD.n2535 1.1255
R4365 VDDD.n2534 VDDD.n146 1.1255
R4366 VDDD.n2540 VDDD.n145 1.1255
R4367 VDDD.n2542 VDDD.n2541 1.1255
R4368 VDDD.n2544 VDDD.n138 1.1255
R4369 VDDD.n2547 VDDD.n2546 1.1255
R4370 VDDD.n2545 VDDD.n142 1.1255
R4371 VDDD.n141 VDDD.n116 1.1255
R4372 VDDD.n2552 VDDD.n2551 1.1255
R4373 VDDD.n2803 VDDD.n16 1.1255
R4374 VDDD.n2820 VDDD.n2819 1.1255
R4375 VDDD.n3 VDDD.n1 1.1255
R4376 VDDD.n2816 VDDD.n2815 1.1255
R4377 VDDD.n2814 VDDD.n6 1.1255
R4378 VDDD.n2813 VDDD.n2812 1.1255
R4379 VDDD.n2810 VDDD.n2809 1.1255
R4380 VDDD.n2808 VDDD.n10 1.1255
R4381 VDDD.n2807 VDDD.n2806 1.1255
R4382 VDDD.n14 VDDD.n12 1.1255
R4383 VDDD.n2519 VDDD.n2518 1.09471
R4384 VDDD.n2528 VDDD.n153 1.09471
R4385 VDDD.n2457 VDDD.n2456 1.09471
R4386 VDDD.n2466 VDDD.n306 1.09471
R4387 VDDD.n2395 VDDD.n2394 1.09471
R4388 VDDD.n2404 VDDD.n459 1.09471
R4389 VDDD.n2333 VDDD.n2332 1.09471
R4390 VDDD.n2342 VDDD.n612 1.09471
R4391 VDDD.n2271 VDDD.n2270 1.09471
R4392 VDDD.n2280 VDDD.n765 1.09471
R4393 VDDD.n1423 VDDD.n1421 1.09471
R4394 VDDD.n1417 VDDD.n1416 1.09471
R4395 VDDD.n1569 VDDD.n1567 1.09471
R4396 VDDD.n1563 VDDD.n1562 1.09471
R4397 VDDD.n1715 VDDD.n1713 1.09471
R4398 VDDD.n1709 VDDD.n1708 1.09471
R4399 VDDD.n1861 VDDD.n1859 1.09471
R4400 VDDD.n1855 VDDD.n1854 1.09471
R4401 VDDD.n1992 VDDD.n1990 1.09471
R4402 VDDD.n1986 VDDD.n1985 1.09471
R4403 VDDD.n2714 VDDD.n2712 1.09471
R4404 VDDD.n2708 VDDD.n2707 1.09471
R4405 VDDD.n1473 VDDD.n1472 0.968742
R4406 VDDD.n1619 VDDD.n1618 0.968742
R4407 VDDD.n1765 VDDD.n1764 0.968742
R4408 VDDD.n1911 VDDD.n1910 0.968742
R4409 VDDD.n2044 VDDD.n2043 0.968742
R4410 VDDD.n2764 VDDD.n2763 0.968742
R4411 VDDD.n239 VDDD.n238 0.968742
R4412 VDDD.n392 VDDD.n391 0.968742
R4413 VDDD.n545 VDDD.n544 0.968742
R4414 VDDD.n698 VDDD.n697 0.968742
R4415 VDDD.n848 VDDD.n847 0.968742
R4416 VDDD.n226 VDDD.n204 0.90897
R4417 VDDD.n379 VDDD.n357 0.90897
R4418 VDDD.n532 VDDD.n510 0.90897
R4419 VDDD.n685 VDDD.n663 0.90897
R4420 VDDD.n835 VDDD.n813 0.90897
R4421 VDDD.n1484 VDDD.n1483 0.90897
R4422 VDDD.n1630 VDDD.n1629 0.90897
R4423 VDDD.n1776 VDDD.n1775 0.90897
R4424 VDDD.n1922 VDDD.n1921 0.90897
R4425 VDDD.n2055 VDDD.n2054 0.90897
R4426 VDDD.n2775 VDDD.n2774 0.90897
R4427 VDDD.n150 VDDD.n149 0.9005
R4428 VDDD.n2536 VDDD.n152 0.9005
R4429 VDDD.n146 VDDD.n132 0.9005
R4430 VDDD.n2540 VDDD.n128 0.9005
R4431 VDDD.n2541 VDDD.n135 0.9005
R4432 VDDD.n138 VDDD.n127 0.9005
R4433 VDDD.n2548 VDDD.n2547 0.9005
R4434 VDDD.n142 VDDD.n126 0.9005
R4435 VDDD.n141 VDDD.n118 0.9005
R4436 VDDD.n2551 VDDD.n2550 0.9005
R4437 VDDD.n237 VDDD.n195 0.9005
R4438 VDDD.n236 VDDD.n196 0.9005
R4439 VDDD.n235 VDDD.n197 0.9005
R4440 VDDD.n216 VDDD.n198 0.9005
R4441 VDDD.n231 VDDD.n200 0.9005
R4442 VDDD.n230 VDDD.n201 0.9005
R4443 VDDD.n229 VDDD.n202 0.9005
R4444 VDDD.n210 VDDD.n203 0.9005
R4445 VDDD.n225 VDDD.n224 0.9005
R4446 VDDD.n227 VDDD.n203 0.9005
R4447 VDDD.n229 VDDD.n228 0.9005
R4448 VDDD.n230 VDDD.n199 0.9005
R4449 VDDD.n232 VDDD.n231 0.9005
R4450 VDDD.n233 VDDD.n198 0.9005
R4451 VDDD.n235 VDDD.n234 0.9005
R4452 VDDD.n236 VDDD.n194 0.9005
R4453 VDDD.n238 VDDD.n237 0.9005
R4454 VDDD.n303 VDDD.n302 0.9005
R4455 VDDD.n2474 VDDD.n305 0.9005
R4456 VDDD.n299 VDDD.n285 0.9005
R4457 VDDD.n2478 VDDD.n281 0.9005
R4458 VDDD.n2479 VDDD.n288 0.9005
R4459 VDDD.n291 VDDD.n280 0.9005
R4460 VDDD.n2486 VDDD.n2485 0.9005
R4461 VDDD.n295 VDDD.n279 0.9005
R4462 VDDD.n294 VDDD.n271 0.9005
R4463 VDDD.n2489 VDDD.n2488 0.9005
R4464 VDDD.n390 VDDD.n348 0.9005
R4465 VDDD.n389 VDDD.n349 0.9005
R4466 VDDD.n388 VDDD.n350 0.9005
R4467 VDDD.n369 VDDD.n351 0.9005
R4468 VDDD.n384 VDDD.n353 0.9005
R4469 VDDD.n383 VDDD.n354 0.9005
R4470 VDDD.n382 VDDD.n355 0.9005
R4471 VDDD.n363 VDDD.n356 0.9005
R4472 VDDD.n378 VDDD.n377 0.9005
R4473 VDDD.n380 VDDD.n356 0.9005
R4474 VDDD.n382 VDDD.n381 0.9005
R4475 VDDD.n383 VDDD.n352 0.9005
R4476 VDDD.n385 VDDD.n384 0.9005
R4477 VDDD.n386 VDDD.n351 0.9005
R4478 VDDD.n388 VDDD.n387 0.9005
R4479 VDDD.n389 VDDD.n347 0.9005
R4480 VDDD.n391 VDDD.n390 0.9005
R4481 VDDD.n456 VDDD.n455 0.9005
R4482 VDDD.n2412 VDDD.n458 0.9005
R4483 VDDD.n452 VDDD.n438 0.9005
R4484 VDDD.n2416 VDDD.n434 0.9005
R4485 VDDD.n2417 VDDD.n441 0.9005
R4486 VDDD.n444 VDDD.n433 0.9005
R4487 VDDD.n2424 VDDD.n2423 0.9005
R4488 VDDD.n448 VDDD.n432 0.9005
R4489 VDDD.n447 VDDD.n424 0.9005
R4490 VDDD.n2427 VDDD.n2426 0.9005
R4491 VDDD.n543 VDDD.n501 0.9005
R4492 VDDD.n542 VDDD.n502 0.9005
R4493 VDDD.n541 VDDD.n503 0.9005
R4494 VDDD.n522 VDDD.n504 0.9005
R4495 VDDD.n537 VDDD.n506 0.9005
R4496 VDDD.n536 VDDD.n507 0.9005
R4497 VDDD.n535 VDDD.n508 0.9005
R4498 VDDD.n516 VDDD.n509 0.9005
R4499 VDDD.n531 VDDD.n530 0.9005
R4500 VDDD.n533 VDDD.n509 0.9005
R4501 VDDD.n535 VDDD.n534 0.9005
R4502 VDDD.n536 VDDD.n505 0.9005
R4503 VDDD.n538 VDDD.n537 0.9005
R4504 VDDD.n539 VDDD.n504 0.9005
R4505 VDDD.n541 VDDD.n540 0.9005
R4506 VDDD.n542 VDDD.n500 0.9005
R4507 VDDD.n544 VDDD.n543 0.9005
R4508 VDDD.n609 VDDD.n608 0.9005
R4509 VDDD.n2350 VDDD.n611 0.9005
R4510 VDDD.n605 VDDD.n591 0.9005
R4511 VDDD.n2354 VDDD.n587 0.9005
R4512 VDDD.n2355 VDDD.n594 0.9005
R4513 VDDD.n597 VDDD.n586 0.9005
R4514 VDDD.n2362 VDDD.n2361 0.9005
R4515 VDDD.n601 VDDD.n585 0.9005
R4516 VDDD.n600 VDDD.n577 0.9005
R4517 VDDD.n2365 VDDD.n2364 0.9005
R4518 VDDD.n696 VDDD.n654 0.9005
R4519 VDDD.n695 VDDD.n655 0.9005
R4520 VDDD.n694 VDDD.n656 0.9005
R4521 VDDD.n675 VDDD.n657 0.9005
R4522 VDDD.n690 VDDD.n659 0.9005
R4523 VDDD.n689 VDDD.n660 0.9005
R4524 VDDD.n688 VDDD.n661 0.9005
R4525 VDDD.n669 VDDD.n662 0.9005
R4526 VDDD.n684 VDDD.n683 0.9005
R4527 VDDD.n686 VDDD.n662 0.9005
R4528 VDDD.n688 VDDD.n687 0.9005
R4529 VDDD.n689 VDDD.n658 0.9005
R4530 VDDD.n691 VDDD.n690 0.9005
R4531 VDDD.n692 VDDD.n657 0.9005
R4532 VDDD.n694 VDDD.n693 0.9005
R4533 VDDD.n695 VDDD.n653 0.9005
R4534 VDDD.n697 VDDD.n696 0.9005
R4535 VDDD.n762 VDDD.n761 0.9005
R4536 VDDD.n2288 VDDD.n764 0.9005
R4537 VDDD.n758 VDDD.n744 0.9005
R4538 VDDD.n2292 VDDD.n740 0.9005
R4539 VDDD.n2293 VDDD.n747 0.9005
R4540 VDDD.n750 VDDD.n739 0.9005
R4541 VDDD.n2300 VDDD.n2299 0.9005
R4542 VDDD.n754 VDDD.n738 0.9005
R4543 VDDD.n753 VDDD.n730 0.9005
R4544 VDDD.n2303 VDDD.n2302 0.9005
R4545 VDDD.n846 VDDD.n804 0.9005
R4546 VDDD.n845 VDDD.n805 0.9005
R4547 VDDD.n844 VDDD.n806 0.9005
R4548 VDDD.n825 VDDD.n807 0.9005
R4549 VDDD.n840 VDDD.n809 0.9005
R4550 VDDD.n839 VDDD.n810 0.9005
R4551 VDDD.n838 VDDD.n811 0.9005
R4552 VDDD.n819 VDDD.n812 0.9005
R4553 VDDD.n834 VDDD.n833 0.9005
R4554 VDDD.n836 VDDD.n812 0.9005
R4555 VDDD.n838 VDDD.n837 0.9005
R4556 VDDD.n839 VDDD.n808 0.9005
R4557 VDDD.n841 VDDD.n840 0.9005
R4558 VDDD.n842 VDDD.n807 0.9005
R4559 VDDD.n844 VDDD.n843 0.9005
R4560 VDDD.n845 VDDD.n803 0.9005
R4561 VDDD.n847 VDDD.n846 0.9005
R4562 VDDD.n1473 VDDD.n1342 0.9005
R4563 VDDD.n1475 VDDD.n1474 0.9005
R4564 VDDD.n1476 VDDD.n1358 0.9005
R4565 VDDD.n1477 VDDD.n1357 0.9005
R4566 VDDD.n1478 VDDD.n1356 0.9005
R4567 VDDD.n1479 VDDD.n1355 0.9005
R4568 VDDD.n1480 VDDD.n1354 0.9005
R4569 VDDD.n1482 VDDD.n1481 0.9005
R4570 VDDD.n1353 VDDD.n1335 0.9005
R4571 VDDD.n1481 VDDD.n1333 0.9005
R4572 VDDD.n1480 VDDD.n1336 0.9005
R4573 VDDD.n1479 VDDD.n1332 0.9005
R4574 VDDD.n1478 VDDD.n1337 0.9005
R4575 VDDD.n1477 VDDD.n1331 0.9005
R4576 VDDD.n1476 VDDD.n1351 0.9005
R4577 VDDD.n1475 VDDD.n1338 0.9005
R4578 VDDD.n1487 VDDD.n1342 0.9005
R4579 VDDD.n1528 VDDD.n1315 0.9005
R4580 VDDD.n1494 VDDD.n1316 0.9005
R4581 VDDD.n1525 VDDD.n1318 0.9005
R4582 VDDD.n1508 VDDD.n1319 0.9005
R4583 VDDD.n1521 VDDD.n1321 0.9005
R4584 VDDD.n1519 VDDD.n1322 0.9005
R4585 VDDD.n1502 VDDD.n1323 0.9005
R4586 VDDD.n1515 VDDD.n1326 0.9005
R4587 VDDD.n1492 VDDD.n1327 0.9005
R4588 VDDD.n1512 VDDD.n1511 0.9005
R4589 VDDD.n1619 VDDD.n1271 0.9005
R4590 VDDD.n1621 VDDD.n1620 0.9005
R4591 VDDD.n1622 VDDD.n1287 0.9005
R4592 VDDD.n1623 VDDD.n1286 0.9005
R4593 VDDD.n1624 VDDD.n1285 0.9005
R4594 VDDD.n1625 VDDD.n1284 0.9005
R4595 VDDD.n1626 VDDD.n1283 0.9005
R4596 VDDD.n1628 VDDD.n1627 0.9005
R4597 VDDD.n1282 VDDD.n1264 0.9005
R4598 VDDD.n1627 VDDD.n1262 0.9005
R4599 VDDD.n1626 VDDD.n1265 0.9005
R4600 VDDD.n1625 VDDD.n1261 0.9005
R4601 VDDD.n1624 VDDD.n1266 0.9005
R4602 VDDD.n1623 VDDD.n1260 0.9005
R4603 VDDD.n1622 VDDD.n1280 0.9005
R4604 VDDD.n1621 VDDD.n1267 0.9005
R4605 VDDD.n1633 VDDD.n1271 0.9005
R4606 VDDD.n1674 VDDD.n1244 0.9005
R4607 VDDD.n1640 VDDD.n1245 0.9005
R4608 VDDD.n1671 VDDD.n1247 0.9005
R4609 VDDD.n1654 VDDD.n1248 0.9005
R4610 VDDD.n1667 VDDD.n1250 0.9005
R4611 VDDD.n1665 VDDD.n1251 0.9005
R4612 VDDD.n1648 VDDD.n1252 0.9005
R4613 VDDD.n1661 VDDD.n1255 0.9005
R4614 VDDD.n1638 VDDD.n1256 0.9005
R4615 VDDD.n1658 VDDD.n1657 0.9005
R4616 VDDD.n1765 VDDD.n1200 0.9005
R4617 VDDD.n1767 VDDD.n1766 0.9005
R4618 VDDD.n1768 VDDD.n1216 0.9005
R4619 VDDD.n1769 VDDD.n1215 0.9005
R4620 VDDD.n1770 VDDD.n1214 0.9005
R4621 VDDD.n1771 VDDD.n1213 0.9005
R4622 VDDD.n1772 VDDD.n1212 0.9005
R4623 VDDD.n1774 VDDD.n1773 0.9005
R4624 VDDD.n1211 VDDD.n1193 0.9005
R4625 VDDD.n1773 VDDD.n1191 0.9005
R4626 VDDD.n1772 VDDD.n1194 0.9005
R4627 VDDD.n1771 VDDD.n1190 0.9005
R4628 VDDD.n1770 VDDD.n1195 0.9005
R4629 VDDD.n1769 VDDD.n1189 0.9005
R4630 VDDD.n1768 VDDD.n1209 0.9005
R4631 VDDD.n1767 VDDD.n1196 0.9005
R4632 VDDD.n1779 VDDD.n1200 0.9005
R4633 VDDD.n1820 VDDD.n1173 0.9005
R4634 VDDD.n1786 VDDD.n1174 0.9005
R4635 VDDD.n1817 VDDD.n1176 0.9005
R4636 VDDD.n1800 VDDD.n1177 0.9005
R4637 VDDD.n1813 VDDD.n1179 0.9005
R4638 VDDD.n1811 VDDD.n1180 0.9005
R4639 VDDD.n1794 VDDD.n1181 0.9005
R4640 VDDD.n1807 VDDD.n1184 0.9005
R4641 VDDD.n1784 VDDD.n1185 0.9005
R4642 VDDD.n1804 VDDD.n1803 0.9005
R4643 VDDD.n1911 VDDD.n1129 0.9005
R4644 VDDD.n1913 VDDD.n1912 0.9005
R4645 VDDD.n1914 VDDD.n1145 0.9005
R4646 VDDD.n1915 VDDD.n1144 0.9005
R4647 VDDD.n1916 VDDD.n1143 0.9005
R4648 VDDD.n1917 VDDD.n1142 0.9005
R4649 VDDD.n1918 VDDD.n1141 0.9005
R4650 VDDD.n1920 VDDD.n1919 0.9005
R4651 VDDD.n1140 VDDD.n1122 0.9005
R4652 VDDD.n1919 VDDD.n1120 0.9005
R4653 VDDD.n1918 VDDD.n1123 0.9005
R4654 VDDD.n1917 VDDD.n1119 0.9005
R4655 VDDD.n1916 VDDD.n1124 0.9005
R4656 VDDD.n1915 VDDD.n1118 0.9005
R4657 VDDD.n1914 VDDD.n1138 0.9005
R4658 VDDD.n1913 VDDD.n1125 0.9005
R4659 VDDD.n1925 VDDD.n1129 0.9005
R4660 VDDD.n1966 VDDD.n1102 0.9005
R4661 VDDD.n1932 VDDD.n1103 0.9005
R4662 VDDD.n1963 VDDD.n1105 0.9005
R4663 VDDD.n1946 VDDD.n1106 0.9005
R4664 VDDD.n1959 VDDD.n1108 0.9005
R4665 VDDD.n1957 VDDD.n1109 0.9005
R4666 VDDD.n1940 VDDD.n1110 0.9005
R4667 VDDD.n1953 VDDD.n1113 0.9005
R4668 VDDD.n1930 VDDD.n1114 0.9005
R4669 VDDD.n1950 VDDD.n1949 0.9005
R4670 VDDD.n2044 VDDD.n1047 0.9005
R4671 VDDD.n2046 VDDD.n2045 0.9005
R4672 VDDD.n2047 VDDD.n1063 0.9005
R4673 VDDD.n2048 VDDD.n1062 0.9005
R4674 VDDD.n2049 VDDD.n1061 0.9005
R4675 VDDD.n2050 VDDD.n1060 0.9005
R4676 VDDD.n2051 VDDD.n1059 0.9005
R4677 VDDD.n2053 VDDD.n2052 0.9005
R4678 VDDD.n1058 VDDD.n1040 0.9005
R4679 VDDD.n2052 VDDD.n1038 0.9005
R4680 VDDD.n2051 VDDD.n1041 0.9005
R4681 VDDD.n2050 VDDD.n1037 0.9005
R4682 VDDD.n2049 VDDD.n1042 0.9005
R4683 VDDD.n2048 VDDD.n1036 0.9005
R4684 VDDD.n2047 VDDD.n1056 0.9005
R4685 VDDD.n2046 VDDD.n1043 0.9005
R4686 VDDD.n2058 VDDD.n1047 0.9005
R4687 VDDD.n2099 VDDD.n1020 0.9005
R4688 VDDD.n2065 VDDD.n1021 0.9005
R4689 VDDD.n2096 VDDD.n1023 0.9005
R4690 VDDD.n2079 VDDD.n1024 0.9005
R4691 VDDD.n2092 VDDD.n1026 0.9005
R4692 VDDD.n2090 VDDD.n1027 0.9005
R4693 VDDD.n2073 VDDD.n1028 0.9005
R4694 VDDD.n2086 VDDD.n1031 0.9005
R4695 VDDD.n2063 VDDD.n1032 0.9005
R4696 VDDD.n2083 VDDD.n2082 0.9005
R4697 VDDD.n2764 VDDD.n29 0.9005
R4698 VDDD.n2766 VDDD.n2765 0.9005
R4699 VDDD.n2767 VDDD.n45 0.9005
R4700 VDDD.n2768 VDDD.n44 0.9005
R4701 VDDD.n2769 VDDD.n43 0.9005
R4702 VDDD.n2770 VDDD.n42 0.9005
R4703 VDDD.n2771 VDDD.n41 0.9005
R4704 VDDD.n2773 VDDD.n2772 0.9005
R4705 VDDD.n40 VDDD.n22 0.9005
R4706 VDDD.n2772 VDDD.n20 0.9005
R4707 VDDD.n2771 VDDD.n23 0.9005
R4708 VDDD.n2770 VDDD.n19 0.9005
R4709 VDDD.n2769 VDDD.n24 0.9005
R4710 VDDD.n2768 VDDD.n18 0.9005
R4711 VDDD.n2767 VDDD.n38 0.9005
R4712 VDDD.n2766 VDDD.n25 0.9005
R4713 VDDD.n2778 VDDD.n29 0.9005
R4714 VDDD.n2819 VDDD.n2 0.9005
R4715 VDDD.n2785 VDDD.n3 0.9005
R4716 VDDD.n2816 VDDD.n5 0.9005
R4717 VDDD.n2799 VDDD.n6 0.9005
R4718 VDDD.n2812 VDDD.n8 0.9005
R4719 VDDD.n2810 VDDD.n9 0.9005
R4720 VDDD.n2793 VDDD.n10 0.9005
R4721 VDDD.n2806 VDDD.n13 0.9005
R4722 VDDD.n2783 VDDD.n14 0.9005
R4723 VDDD.n2803 VDDD.n2802 0.9005
R4724 VDDD.n2520 VDDD.n2519 0.83992
R4725 VDDD.n2528 VDDD.n2527 0.83992
R4726 VDDD.n2458 VDDD.n2457 0.83992
R4727 VDDD.n2466 VDDD.n2465 0.83992
R4728 VDDD.n2396 VDDD.n2395 0.83992
R4729 VDDD.n2404 VDDD.n2403 0.83992
R4730 VDDD.n2334 VDDD.n2333 0.83992
R4731 VDDD.n2342 VDDD.n2341 0.83992
R4732 VDDD.n2272 VDDD.n2271 0.83992
R4733 VDDD.n2280 VDDD.n2279 0.83992
R4734 VDDD.n1423 VDDD.n1422 0.83992
R4735 VDDD.n1418 VDDD.n1417 0.83992
R4736 VDDD.n1569 VDDD.n1568 0.83992
R4737 VDDD.n1564 VDDD.n1563 0.83992
R4738 VDDD.n1715 VDDD.n1714 0.83992
R4739 VDDD.n1710 VDDD.n1709 0.83992
R4740 VDDD.n1861 VDDD.n1860 0.83992
R4741 VDDD.n1856 VDDD.n1855 0.83992
R4742 VDDD.n1992 VDDD.n1991 0.83992
R4743 VDDD.n1987 VDDD.n1986 0.83992
R4744 VDDD.n2714 VDDD.n2713 0.83992
R4745 VDDD.n2709 VDDD.n2708 0.83992
R4746 VDDD.n2527 VDDD.n155 0.7005
R4747 VDDD.n2524 VDDD.n155 0.7005
R4748 VDDD.n156 VDDD.n153 0.7005
R4749 VDDD.n2525 VDDD.n156 0.7005
R4750 VDDD.n2521 VDDD.n2520 0.7005
R4751 VDDD.n2522 VDDD.n2521 0.7005
R4752 VDDD.n2518 VDDD.n157 0.7005
R4753 VDDD.n2522 VDDD.n157 0.7005
R4754 VDDD.n2465 VDDD.n308 0.7005
R4755 VDDD.n2462 VDDD.n308 0.7005
R4756 VDDD.n309 VDDD.n306 0.7005
R4757 VDDD.n2463 VDDD.n309 0.7005
R4758 VDDD.n2459 VDDD.n2458 0.7005
R4759 VDDD.n2460 VDDD.n2459 0.7005
R4760 VDDD.n2456 VDDD.n310 0.7005
R4761 VDDD.n2460 VDDD.n310 0.7005
R4762 VDDD.n2403 VDDD.n461 0.7005
R4763 VDDD.n2400 VDDD.n461 0.7005
R4764 VDDD.n462 VDDD.n459 0.7005
R4765 VDDD.n2401 VDDD.n462 0.7005
R4766 VDDD.n2397 VDDD.n2396 0.7005
R4767 VDDD.n2398 VDDD.n2397 0.7005
R4768 VDDD.n2394 VDDD.n463 0.7005
R4769 VDDD.n2398 VDDD.n463 0.7005
R4770 VDDD.n2341 VDDD.n614 0.7005
R4771 VDDD.n2338 VDDD.n614 0.7005
R4772 VDDD.n615 VDDD.n612 0.7005
R4773 VDDD.n2339 VDDD.n615 0.7005
R4774 VDDD.n2335 VDDD.n2334 0.7005
R4775 VDDD.n2336 VDDD.n2335 0.7005
R4776 VDDD.n2332 VDDD.n616 0.7005
R4777 VDDD.n2336 VDDD.n616 0.7005
R4778 VDDD.n2279 VDDD.n767 0.7005
R4779 VDDD.n2276 VDDD.n767 0.7005
R4780 VDDD.n768 VDDD.n765 0.7005
R4781 VDDD.n2277 VDDD.n768 0.7005
R4782 VDDD.n2273 VDDD.n2272 0.7005
R4783 VDDD.n2274 VDDD.n2273 0.7005
R4784 VDDD.n2270 VDDD.n769 0.7005
R4785 VDDD.n2274 VDDD.n769 0.7005
R4786 VDDD.n1416 VDDD.n1415 0.7005
R4787 VDDD.n1415 VDDD.n1414 0.7005
R4788 VDDD.n1419 VDDD.n1418 0.7005
R4789 VDDD.n1420 VDDD.n1419 0.7005
R4790 VDDD.n1421 VDDD.n1406 0.7005
R4791 VDDD.n1433 VDDD.n1406 0.7005
R4792 VDDD.n1422 VDDD.n1407 0.7005
R4793 VDDD.n1433 VDDD.n1407 0.7005
R4794 VDDD.n1562 VDDD.n1561 0.7005
R4795 VDDD.n1561 VDDD.n1560 0.7005
R4796 VDDD.n1565 VDDD.n1564 0.7005
R4797 VDDD.n1566 VDDD.n1565 0.7005
R4798 VDDD.n1567 VDDD.n1552 0.7005
R4799 VDDD.n1579 VDDD.n1552 0.7005
R4800 VDDD.n1568 VDDD.n1553 0.7005
R4801 VDDD.n1579 VDDD.n1553 0.7005
R4802 VDDD.n1708 VDDD.n1707 0.7005
R4803 VDDD.n1707 VDDD.n1706 0.7005
R4804 VDDD.n1711 VDDD.n1710 0.7005
R4805 VDDD.n1712 VDDD.n1711 0.7005
R4806 VDDD.n1713 VDDD.n1698 0.7005
R4807 VDDD.n1725 VDDD.n1698 0.7005
R4808 VDDD.n1714 VDDD.n1699 0.7005
R4809 VDDD.n1725 VDDD.n1699 0.7005
R4810 VDDD.n1854 VDDD.n1853 0.7005
R4811 VDDD.n1853 VDDD.n1852 0.7005
R4812 VDDD.n1857 VDDD.n1856 0.7005
R4813 VDDD.n1858 VDDD.n1857 0.7005
R4814 VDDD.n1859 VDDD.n1844 0.7005
R4815 VDDD.n1871 VDDD.n1844 0.7005
R4816 VDDD.n1860 VDDD.n1845 0.7005
R4817 VDDD.n1871 VDDD.n1845 0.7005
R4818 VDDD.n1985 VDDD.n1984 0.7005
R4819 VDDD.n1984 VDDD.n1983 0.7005
R4820 VDDD.n1988 VDDD.n1987 0.7005
R4821 VDDD.n1989 VDDD.n1988 0.7005
R4822 VDDD.n1990 VDDD.n1975 0.7005
R4823 VDDD.n2001 VDDD.n1975 0.7005
R4824 VDDD.n1991 VDDD.n1976 0.7005
R4825 VDDD.n2001 VDDD.n1976 0.7005
R4826 VDDD.n2707 VDDD.n2706 0.7005
R4827 VDDD.n2706 VDDD.n2705 0.7005
R4828 VDDD.n2710 VDDD.n2709 0.7005
R4829 VDDD.n2711 VDDD.n2710 0.7005
R4830 VDDD.n2712 VDDD.n2697 0.7005
R4831 VDDD.n2724 VDDD.n2697 0.7005
R4832 VDDD.n2713 VDDD.n2698 0.7005
R4833 VDDD.n2724 VDDD.n2698 0.7005
R4834 VDDD.n248 VDDD.n247 0.68118
R4835 VDDD.n401 VDDD.n400 0.68118
R4836 VDDD.n554 VDDD.n553 0.68118
R4837 VDDD.n707 VDDD.n706 0.68118
R4838 VDDD.n857 VDDD.n856 0.68118
R4839 VDDD.n1469 VDDD.n1468 0.68118
R4840 VDDD.n1615 VDDD.n1614 0.68118
R4841 VDDD.n1761 VDDD.n1760 0.68118
R4842 VDDD.n1907 VDDD.n1906 0.68118
R4843 VDDD.n2040 VDDD.n2039 0.68118
R4844 VDDD.n2760 VDDD.n2759 0.68118
R4845 VDDD.n2518 VDDD.n2517 0.632868
R4846 VDDD.n2532 VDDD.n153 0.632868
R4847 VDDD.n2456 VDDD.n2455 0.632868
R4848 VDDD.n2470 VDDD.n306 0.632868
R4849 VDDD.n2394 VDDD.n2393 0.632868
R4850 VDDD.n2408 VDDD.n459 0.632868
R4851 VDDD.n2332 VDDD.n2331 0.632868
R4852 VDDD.n2346 VDDD.n612 0.632868
R4853 VDDD.n2270 VDDD.n2269 0.632868
R4854 VDDD.n2284 VDDD.n765 0.632868
R4855 VDDD.n1421 VDDD.n1405 0.632868
R4856 VDDD.n1416 VDDD.n1413 0.632868
R4857 VDDD.n1567 VDDD.n1551 0.632868
R4858 VDDD.n1562 VDDD.n1559 0.632868
R4859 VDDD.n1713 VDDD.n1697 0.632868
R4860 VDDD.n1708 VDDD.n1705 0.632868
R4861 VDDD.n1859 VDDD.n1843 0.632868
R4862 VDDD.n1854 VDDD.n1851 0.632868
R4863 VDDD.n1990 VDDD.n1974 0.632868
R4864 VDDD.n1985 VDDD.n1982 0.632868
R4865 VDDD.n2712 VDDD.n2696 0.632868
R4866 VDDD.n2707 VDDD.n2704 0.632868
R4867 VDDD.n227 VDDD.n226 0.466553
R4868 VDDD.n380 VDDD.n379 0.466553
R4869 VDDD.n533 VDDD.n532 0.466553
R4870 VDDD.n686 VDDD.n685 0.466553
R4871 VDDD.n836 VDDD.n835 0.466553
R4872 VDDD.n1483 VDDD.n1482 0.466553
R4873 VDDD.n1629 VDDD.n1628 0.466553
R4874 VDDD.n1775 VDDD.n1774 0.466553
R4875 VDDD.n1921 VDDD.n1920 0.466553
R4876 VDDD.n2054 VDDD.n2053 0.466553
R4877 VDDD.n2774 VDDD.n2773 0.466553
R4878 VDDD.n1438 VDDD.n1403 0.458415
R4879 VDDD.n1584 VDDD.n1549 0.458415
R4880 VDDD.n1730 VDDD.n1695 0.458415
R4881 VDDD.n1876 VDDD.n1841 0.458415
R4882 VDDD.n2006 VDDD.n1972 0.458415
R4883 VDDD.n2729 VDDD.n2694 0.458415
R4884 VDDD.n2266 VDDD.n774 0.458415
R4885 VDDD.n2328 VDDD.n621 0.458415
R4886 VDDD.n2390 VDDD.n468 0.458415
R4887 VDDD.n2452 VDDD.n315 0.458415
R4888 VDDD.n2514 VDDD.n162 0.458415
R4889 VDDD.n2249 VDDD.n2243 0.446331
R4890 VDDD.n1466 VDDD.n1465 0.427444
R4891 VDDD.n1612 VDDD.n1611 0.427444
R4892 VDDD.n1758 VDDD.n1757 0.427444
R4893 VDDD.n1904 VDDD.n1903 0.427444
R4894 VDDD.n2037 VDDD.n2036 0.427444
R4895 VDDD.n2757 VDDD.n2756 0.427444
R4896 VDDD.n250 VDDD.n193 0.427444
R4897 VDDD.n403 VDDD.n346 0.427444
R4898 VDDD.n556 VDDD.n499 0.427444
R4899 VDDD.n709 VDDD.n652 0.427444
R4900 VDDD.n859 VDDD.n802 0.427444
R4901 VDDD.n1467 VDDD.n1466 0.425602
R4902 VDDD.n1613 VDDD.n1612 0.425602
R4903 VDDD.n1759 VDDD.n1758 0.425602
R4904 VDDD.n1905 VDDD.n1904 0.425602
R4905 VDDD.n2038 VDDD.n2037 0.425602
R4906 VDDD.n2758 VDDD.n2757 0.425602
R4907 VDDD.n250 VDDD.n249 0.425602
R4908 VDDD.n403 VDDD.n402 0.425602
R4909 VDDD.n556 VDDD.n555 0.425602
R4910 VDDD.n709 VDDD.n708 0.425602
R4911 VDDD.n859 VDDD.n858 0.425602
R4912 VDDD.n2762 VDDD.n47 0.407591
R4913 VDDD.n241 VDDD.n239 0.407591
R4914 VDDD.n245 VDDD.n244 0.407591
R4915 VDDD.n394 VDDD.n392 0.407591
R4916 VDDD.n398 VDDD.n397 0.407591
R4917 VDDD.n547 VDDD.n545 0.407591
R4918 VDDD.n551 VDDD.n550 0.407591
R4919 VDDD.n700 VDDD.n698 0.407591
R4920 VDDD.n704 VDDD.n703 0.407591
R4921 VDDD.n850 VDDD.n848 0.407591
R4922 VDDD.n854 VDDD.n853 0.407591
R4923 VDDD.n2042 VDDD.n1065 0.407591
R4924 VDDD.n1909 VDDD.n1147 0.407591
R4925 VDDD.n1763 VDDD.n1218 0.407591
R4926 VDDD.n1617 VDDD.n1289 0.407591
R4927 VDDD.n1471 VDDD.n1360 0.407591
R4928 VDDD.n1445 VDDD.n1399 0.407591
R4929 VDDD.n1444 VDDD.n1400 0.407591
R4930 VDDD.n1472 VDDD.n1359 0.407591
R4931 VDDD.n1591 VDDD.n1545 0.407591
R4932 VDDD.n1590 VDDD.n1546 0.407591
R4933 VDDD.n1618 VDDD.n1288 0.407591
R4934 VDDD.n1737 VDDD.n1691 0.407591
R4935 VDDD.n1736 VDDD.n1692 0.407591
R4936 VDDD.n1764 VDDD.n1217 0.407591
R4937 VDDD.n1883 VDDD.n1837 0.407591
R4938 VDDD.n1882 VDDD.n1838 0.407591
R4939 VDDD.n1910 VDDD.n1146 0.407591
R4940 VDDD.n2013 VDDD.n1968 0.407591
R4941 VDDD.n2012 VDDD.n1969 0.407591
R4942 VDDD.n2043 VDDD.n1064 0.407591
R4943 VDDD.n2260 VDDD.n777 0.407591
R4944 VDDD.n2259 VDDD.n2258 0.407591
R4945 VDDD.n2322 VDDD.n624 0.407591
R4946 VDDD.n2321 VDDD.n2320 0.407591
R4947 VDDD.n2384 VDDD.n471 0.407591
R4948 VDDD.n2383 VDDD.n2382 0.407591
R4949 VDDD.n2446 VDDD.n318 0.407591
R4950 VDDD.n2445 VDDD.n2444 0.407591
R4951 VDDD.n2508 VDDD.n165 0.407591
R4952 VDDD.n2507 VDDD.n2506 0.407591
R4953 VDDD.n2736 VDDD.n2690 0.407591
R4954 VDDD.n2735 VDDD.n2691 0.407591
R4955 VDDD.n2763 VDDD.n46 0.407591
R4956 VDDD.n2101 VDDD.n2100 0.37805
R4957 VDDD.n251 VDDD.n250 0.362952
R4958 VDDD.n404 VDDD.n403 0.362952
R4959 VDDD.n557 VDDD.n556 0.362952
R4960 VDDD.n710 VDDD.n709 0.362952
R4961 VDDD.n860 VDDD.n859 0.362952
R4962 VDDD.n1466 VDDD.n1461 0.362952
R4963 VDDD.n1612 VDDD.n1607 0.362952
R4964 VDDD.n1758 VDDD.n1753 0.362952
R4965 VDDD.n1904 VDDD.n1899 0.362952
R4966 VDDD.n2037 VDDD.n2032 0.362952
R4967 VDDD.n2757 VDDD.n2752 0.362952
R4968 VDDD.n246 VDDD.n245 0.344952
R4969 VDDD.n399 VDDD.n398 0.344952
R4970 VDDD.n552 VDDD.n551 0.344952
R4971 VDDD.n705 VDDD.n704 0.344952
R4972 VDDD.n855 VDDD.n854 0.344952
R4973 VDDD.n1471 VDDD.n1470 0.344952
R4974 VDDD.n1617 VDDD.n1616 0.344952
R4975 VDDD.n1763 VDDD.n1762 0.344952
R4976 VDDD.n1909 VDDD.n1908 0.344952
R4977 VDDD.n2042 VDDD.n2041 0.344952
R4978 VDDD.n2762 VDDD.n2761 0.344952
R4979 VDDD.n1012 VDDD.n999 0.325526
R4980 VDDD.n2200 VDDD.n2132 0.325526
R4981 VDDD.n2101 VDDD.n920 0.321929
R4982 VDDD.n2103 VDDD.n2102 0.321929
R4983 VDDD.n1018 VDDD.n919 0.321929
R4984 VDDD.n1017 VDDD.n1016 0.321929
R4985 VDDD.n922 VDDD.n921 0.321929
R4986 VDDD.n966 VDDD.n965 0.321929
R4987 VDDD.n968 VDDD.n967 0.321929
R4988 VDDD.n969 VDDD.n964 0.321929
R4989 VDDD.n971 VDDD.n970 0.321929
R4990 VDDD.n972 VDDD.n963 0.321929
R4991 VDDD.n974 VDDD.n973 0.321929
R4992 VDDD.n975 VDDD.n962 0.321929
R4993 VDDD.n977 VDDD.n976 0.321929
R4994 VDDD.n978 VDDD.n961 0.321929
R4995 VDDD.n980 VDDD.n979 0.321929
R4996 VDDD.n981 VDDD.n960 0.321929
R4997 VDDD.n983 VDDD.n982 0.321929
R4998 VDDD.n984 VDDD.n959 0.321929
R4999 VDDD.n986 VDDD.n985 0.321929
R5000 VDDD.n987 VDDD.n958 0.321929
R5001 VDDD.n989 VDDD.n988 0.321929
R5002 VDDD.n990 VDDD.n957 0.321929
R5003 VDDD.n992 VDDD.n991 0.321929
R5004 VDDD.n993 VDDD.n956 0.321929
R5005 VDDD.n995 VDDD.n994 0.321929
R5006 VDDD.n996 VDDD.n955 0.321929
R5007 VDDD.n998 VDDD.n997 0.321929
R5008 VDDD.n954 VDDD.n934 0.321929
R5009 VDDD.n997 VDDD.n898 0.321929
R5010 VDDD.n996 VDDD.n900 0.321929
R5011 VDDD.n995 VDDD.n897 0.321929
R5012 VDDD.n956 VDDD.n901 0.321929
R5013 VDDD.n991 VDDD.n896 0.321929
R5014 VDDD.n990 VDDD.n902 0.321929
R5015 VDDD.n989 VDDD.n895 0.321929
R5016 VDDD.n958 VDDD.n903 0.321929
R5017 VDDD.n985 VDDD.n894 0.321929
R5018 VDDD.n984 VDDD.n904 0.321929
R5019 VDDD.n983 VDDD.n893 0.321929
R5020 VDDD.n960 VDDD.n905 0.321929
R5021 VDDD.n979 VDDD.n892 0.321929
R5022 VDDD.n978 VDDD.n906 0.321929
R5023 VDDD.n977 VDDD.n891 0.321929
R5024 VDDD.n962 VDDD.n907 0.321929
R5025 VDDD.n973 VDDD.n890 0.321929
R5026 VDDD.n972 VDDD.n908 0.321929
R5027 VDDD.n971 VDDD.n889 0.321929
R5028 VDDD.n964 VDDD.n909 0.321929
R5029 VDDD.n967 VDDD.n888 0.321929
R5030 VDDD.n966 VDDD.n910 0.321929
R5031 VDDD.n922 VDDD.n887 0.321929
R5032 VDDD.n1016 VDDD.n1015 0.321929
R5033 VDDD.n919 VDDD.n886 0.321929
R5034 VDDD.n2104 VDDD.n2103 0.321929
R5035 VDDD.n920 VDDD.n911 0.321929
R5036 VDDD.n2199 VDDD.n2131 0.321929
R5037 VDDD.n2202 VDDD.n2134 0.321929
R5038 VDDD.n2203 VDDD.n2130 0.321929
R5039 VDDD.n2204 VDDD.n2135 0.321929
R5040 VDDD.n2197 VDDD.n2129 0.321929
R5041 VDDD.n2208 VDDD.n2136 0.321929
R5042 VDDD.n2209 VDDD.n2128 0.321929
R5043 VDDD.n2210 VDDD.n2137 0.321929
R5044 VDDD.n2195 VDDD.n2127 0.321929
R5045 VDDD.n2214 VDDD.n2138 0.321929
R5046 VDDD.n2215 VDDD.n2126 0.321929
R5047 VDDD.n2216 VDDD.n2139 0.321929
R5048 VDDD.n2193 VDDD.n2125 0.321929
R5049 VDDD.n2220 VDDD.n2140 0.321929
R5050 VDDD.n2221 VDDD.n2124 0.321929
R5051 VDDD.n2222 VDDD.n2141 0.321929
R5052 VDDD.n2191 VDDD.n2123 0.321929
R5053 VDDD.n2226 VDDD.n2142 0.321929
R5054 VDDD.n2227 VDDD.n2122 0.321929
R5055 VDDD.n2228 VDDD.n2143 0.321929
R5056 VDDD.n2189 VDDD.n2121 0.321929
R5057 VDDD.n2232 VDDD.n2144 0.321929
R5058 VDDD.n2233 VDDD.n2120 0.321929
R5059 VDDD.n2234 VDDD.n2145 0.321929
R5060 VDDD.n2187 VDDD.n2186 0.321929
R5061 VDDD.n2239 VDDD.n2238 0.321929
R5062 VDDD.n2151 VDDD.n883 0.321929
R5063 VDDD.n2242 VDDD.n2241 0.321929
R5064 VDDD.n2243 VDDD.n2242 0.321929
R5065 VDDD.n883 VDDD.n882 0.321929
R5066 VDDD.n2238 VDDD.n2237 0.321929
R5067 VDDD.n2236 VDDD.n2187 0.321929
R5068 VDDD.n2235 VDDD.n2234 0.321929
R5069 VDDD.n2233 VDDD.n2188 0.321929
R5070 VDDD.n2232 VDDD.n2231 0.321929
R5071 VDDD.n2230 VDDD.n2189 0.321929
R5072 VDDD.n2229 VDDD.n2228 0.321929
R5073 VDDD.n2227 VDDD.n2190 0.321929
R5074 VDDD.n2226 VDDD.n2225 0.321929
R5075 VDDD.n2224 VDDD.n2191 0.321929
R5076 VDDD.n2223 VDDD.n2222 0.321929
R5077 VDDD.n2221 VDDD.n2192 0.321929
R5078 VDDD.n2220 VDDD.n2219 0.321929
R5079 VDDD.n2218 VDDD.n2193 0.321929
R5080 VDDD.n2217 VDDD.n2216 0.321929
R5081 VDDD.n2215 VDDD.n2194 0.321929
R5082 VDDD.n2214 VDDD.n2213 0.321929
R5083 VDDD.n2212 VDDD.n2195 0.321929
R5084 VDDD.n2211 VDDD.n2210 0.321929
R5085 VDDD.n2209 VDDD.n2196 0.321929
R5086 VDDD.n2208 VDDD.n2207 0.321929
R5087 VDDD.n2206 VDDD.n2197 0.321929
R5088 VDDD.n2205 VDDD.n2204 0.321929
R5089 VDDD.n2203 VDDD.n2198 0.321929
R5090 VDDD.n2202 VDDD.n2201 0.321929
R5091 VDDD.n1530 VDDD.n1529 0.297021
R5092 VDDD.n1676 VDDD.n1675 0.297021
R5093 VDDD.n1822 VDDD.n1821 0.297021
R5094 VDDD.n2021 VDDD.n1967 0.297021
R5095 VDDD.n2311 VDDD.n2304 0.297021
R5096 VDDD.n2373 VDDD.n2366 0.297021
R5097 VDDD.n2435 VDDD.n2428 0.297021
R5098 VDDD.n2497 VDDD.n2490 0.297021
R5099 VDDD.n2673 VDDD.n2618 0.28022
R5100 VDDD.n2107 VDDD.n2106 0.279095
R5101 VDDD.n249 VDDD.n248 0.243496
R5102 VDDD.n402 VDDD.n401 0.243496
R5103 VDDD.n555 VDDD.n554 0.243496
R5104 VDDD.n708 VDDD.n707 0.243496
R5105 VDDD.n858 VDDD.n857 0.243496
R5106 VDDD.n1468 VDDD.n1467 0.243496
R5107 VDDD.n1614 VDDD.n1613 0.243496
R5108 VDDD.n1760 VDDD.n1759 0.243496
R5109 VDDD.n1906 VDDD.n1905 0.243496
R5110 VDDD.n2039 VDDD.n2038 0.243496
R5111 VDDD.n2759 VDDD.n2758 0.243496
R5112 VDDD.n247 VDDD.n246 0.241671
R5113 VDDD.n400 VDDD.n399 0.241671
R5114 VDDD.n553 VDDD.n552 0.241671
R5115 VDDD.n706 VDDD.n705 0.241671
R5116 VDDD.n856 VDDD.n855 0.241671
R5117 VDDD.n1470 VDDD.n1469 0.241671
R5118 VDDD.n1616 VDDD.n1615 0.241671
R5119 VDDD.n1762 VDDD.n1761 0.241671
R5120 VDDD.n1908 VDDD.n1907 0.241671
R5121 VDDD.n2041 VDDD.n2040 0.241671
R5122 VDDD.n2761 VDDD.n2760 0.241671
R5123 VDDD.n2498 VDDD.n261 0.232571
R5124 VDDD.n2436 VDDD.n414 0.232571
R5125 VDDD.n2374 VDDD.n567 0.232571
R5126 VDDD.n2312 VDDD.n720 0.232571
R5127 VDDD.n2250 VDDD.n870 0.232571
R5128 VDDD.n1457 VDDD.n1453 0.232571
R5129 VDDD.n1603 VDDD.n1599 0.232571
R5130 VDDD.n1749 VDDD.n1745 0.232571
R5131 VDDD.n1895 VDDD.n1891 0.232571
R5132 VDDD.n2028 VDDD.n2024 0.232571
R5133 VDDD.n2748 VDDD.n2744 0.232571
R5134 VDDD.n2549 VDDD.n130 0.226271
R5135 VDDD.n2487 VDDD.n283 0.226271
R5136 VDDD.n2425 VDDD.n436 0.226271
R5137 VDDD.n2363 VDDD.n589 0.226271
R5138 VDDD.n2301 VDDD.n742 0.226271
R5139 VDDD.n1489 VDDD.n1488 0.226271
R5140 VDDD.n1635 VDDD.n1634 0.226271
R5141 VDDD.n1781 VDDD.n1780 0.226271
R5142 VDDD.n1927 VDDD.n1926 0.226271
R5143 VDDD.n2060 VDDD.n2059 0.226271
R5144 VDDD.n2780 VDDD.n2779 0.226271
R5145 VDDD.n2675 VDDD.n2674 0.208731
R5146 VDDD.n2515 VDDD.n161 0.197438
R5147 VDDD.n2526 VDDD.n154 0.197438
R5148 VDDD.n2453 VDDD.n314 0.197438
R5149 VDDD.n2464 VDDD.n307 0.197438
R5150 VDDD.n2391 VDDD.n467 0.197438
R5151 VDDD.n2402 VDDD.n460 0.197438
R5152 VDDD.n2329 VDDD.n620 0.197438
R5153 VDDD.n2340 VDDD.n613 0.197438
R5154 VDDD.n2267 VDDD.n773 0.197438
R5155 VDDD.n2278 VDDD.n766 0.197438
R5156 VDDD.n1437 VDDD.n1404 0.197438
R5157 VDDD.n1411 VDDD.n1410 0.197438
R5158 VDDD.n1583 VDDD.n1550 0.197438
R5159 VDDD.n1557 VDDD.n1556 0.197438
R5160 VDDD.n1729 VDDD.n1696 0.197438
R5161 VDDD.n1703 VDDD.n1702 0.197438
R5162 VDDD.n1875 VDDD.n1842 0.197438
R5163 VDDD.n1849 VDDD.n1848 0.197438
R5164 VDDD.n2005 VDDD.n1973 0.197438
R5165 VDDD.n1980 VDDD.n1979 0.197438
R5166 VDDD.n2728 VDDD.n2695 0.197438
R5167 VDDD.n2702 VDDD.n2701 0.197438
R5168 VDDD.n2512 VDDD.n2511 0.19717
R5169 VDDD.n2450 VDDD.n2449 0.19717
R5170 VDDD.n2388 VDDD.n2387 0.19717
R5171 VDDD.n2326 VDDD.n2325 0.19717
R5172 VDDD.n2264 VDDD.n2263 0.19717
R5173 VDDD.n1441 VDDD.n1440 0.19717
R5174 VDDD.n1587 VDDD.n1586 0.19717
R5175 VDDD.n1733 VDDD.n1732 0.19717
R5176 VDDD.n1879 VDDD.n1878 0.19717
R5177 VDDD.n2009 VDDD.n2008 0.19717
R5178 VDDD.n2732 VDDD.n2731 0.19717
R5179 VDDD VDDD.n2820 0.18482
R5180 VDDD.n999 VDDD.n998 0.167142
R5181 VDDD.n2201 VDDD.n2200 0.167142
R5182 VDDD.n2514 VDDD.n2513 0.125852
R5183 VDDD.n2452 VDDD.n2451 0.125852
R5184 VDDD.n2390 VDDD.n2389 0.125852
R5185 VDDD.n2328 VDDD.n2327 0.125852
R5186 VDDD.n2266 VDDD.n2265 0.125852
R5187 VDDD.n1439 VDDD.n1438 0.125852
R5188 VDDD.n1585 VDDD.n1584 0.125852
R5189 VDDD.n1731 VDDD.n1730 0.125852
R5190 VDDD.n1877 VDDD.n1876 0.125852
R5191 VDDD.n2007 VDDD.n2006 0.125852
R5192 VDDD.n2730 VDDD.n2729 0.125852
R5193 VDDD VDDD.n0 0.112701
R5194 VDDD.n1413 VDDD.n1329 0.107558
R5195 VDDD.n1559 VDDD.n1258 0.107558
R5196 VDDD.n1705 VDDD.n1187 0.107558
R5197 VDDD.n1851 VDDD.n1116 0.107558
R5198 VDDD.n1982 VDDD.n1034 0.107558
R5199 VDDD.n2285 VDDD.n2284 0.107558
R5200 VDDD.n2347 VDDD.n2346 0.107558
R5201 VDDD.n2409 VDDD.n2408 0.107558
R5202 VDDD.n2471 VDDD.n2470 0.107558
R5203 VDDD.n2533 VDDD.n2532 0.107558
R5204 VDDD.n2704 VDDD.n16 0.107558
R5205 VDDD.n2510 VDDD.n2509 0.1064
R5206 VDDD.n2448 VDDD.n2447 0.1064
R5207 VDDD.n2386 VDDD.n2385 0.1064
R5208 VDDD.n2324 VDDD.n2323 0.1064
R5209 VDDD.n2262 VDDD.n2261 0.1064
R5210 VDDD.n1443 VDDD.n1442 0.1064
R5211 VDDD.n1589 VDDD.n1588 0.1064
R5212 VDDD.n1735 VDDD.n1734 0.1064
R5213 VDDD.n1881 VDDD.n1880 0.1064
R5214 VDDD.n2011 VDDD.n2010 0.1064
R5215 VDDD.n2734 VDDD.n2733 0.1064
R5216 VDDD.n245 VDDD.n239 0.0839842
R5217 VDDD.n398 VDDD.n392 0.0839842
R5218 VDDD.n551 VDDD.n545 0.0839842
R5219 VDDD.n704 VDDD.n698 0.0839842
R5220 VDDD.n854 VDDD.n848 0.0839842
R5221 VDDD.n1472 VDDD.n1471 0.0839842
R5222 VDDD.n1618 VDDD.n1617 0.0839842
R5223 VDDD.n1764 VDDD.n1763 0.0839842
R5224 VDDD.n1910 VDDD.n1909 0.0839842
R5225 VDDD.n2043 VDDD.n2042 0.0839842
R5226 VDDD.n2763 VDDD.n2762 0.0839842
R5227 VDDD.n1411 VDDD.n1405 0.0837985
R5228 VDDD.n1557 VDDD.n1551 0.0837985
R5229 VDDD.n1703 VDDD.n1697 0.0837985
R5230 VDDD.n1849 VDDD.n1843 0.0837985
R5231 VDDD.n1980 VDDD.n1974 0.0837985
R5232 VDDD.n2702 VDDD.n2696 0.0837985
R5233 VDDD.n2269 VDDD.n766 0.0837985
R5234 VDDD.n2331 VDDD.n613 0.0837985
R5235 VDDD.n2393 VDDD.n460 0.0837985
R5236 VDDD.n2455 VDDD.n307 0.0837985
R5237 VDDD.n2517 VDDD.n154 0.0837985
R5238 VDDD.n2513 VDDD.n2512 0.0714497
R5239 VDDD.n2451 VDDD.n2450 0.0714497
R5240 VDDD.n2389 VDDD.n2388 0.0714497
R5241 VDDD.n2327 VDDD.n2326 0.0714497
R5242 VDDD.n2265 VDDD.n2264 0.0714497
R5243 VDDD.n1440 VDDD.n1439 0.0714497
R5244 VDDD.n1586 VDDD.n1585 0.0714497
R5245 VDDD.n1732 VDDD.n1731 0.0714497
R5246 VDDD.n1878 VDDD.n1877 0.0714497
R5247 VDDD.n2008 VDDD.n2007 0.0714497
R5248 VDDD.n2731 VDDD.n2730 0.0714497
R5249 VDDD.n2511 VDDD.n2510 0.0709338
R5250 VDDD.n2449 VDDD.n2448 0.0709338
R5251 VDDD.n2387 VDDD.n2386 0.0709338
R5252 VDDD.n2325 VDDD.n2324 0.0709338
R5253 VDDD.n2263 VDDD.n2262 0.0709338
R5254 VDDD.n1442 VDDD.n1441 0.0709338
R5255 VDDD.n1588 VDDD.n1587 0.0709338
R5256 VDDD.n1734 VDDD.n1733 0.0709338
R5257 VDDD.n1880 VDDD.n1879 0.0709338
R5258 VDDD.n2010 VDDD.n2009 0.0709338
R5259 VDDD.n2733 VDDD.n2732 0.0709338
R5260 VDDD.n1444 VDDD.n1443 0.055437
R5261 VDDD.n1590 VDDD.n1589 0.055437
R5262 VDDD.n1736 VDDD.n1735 0.055437
R5263 VDDD.n1882 VDDD.n1881 0.055437
R5264 VDDD.n2012 VDDD.n2011 0.055437
R5265 VDDD.n2261 VDDD.n2260 0.055437
R5266 VDDD.n2323 VDDD.n2322 0.055437
R5267 VDDD.n2385 VDDD.n2384 0.055437
R5268 VDDD.n2447 VDDD.n2446 0.055437
R5269 VDDD.n2509 VDDD.n2508 0.055437
R5270 VDDD.n2735 VDDD.n2734 0.055437
R5271 VDDD.n2539 VDDD.n2538 0.0512273
R5272 VDDD.n2539 VDDD.n143 0.0512273
R5273 VDDD.n144 VDDD.n139 0.0512273
R5274 VDDD.n140 VDDD.n139 0.0512273
R5275 VDDD.n2477 VDDD.n2476 0.0512273
R5276 VDDD.n2477 VDDD.n296 0.0512273
R5277 VDDD.n297 VDDD.n292 0.0512273
R5278 VDDD.n293 VDDD.n292 0.0512273
R5279 VDDD.n2415 VDDD.n2414 0.0512273
R5280 VDDD.n2415 VDDD.n449 0.0512273
R5281 VDDD.n450 VDDD.n445 0.0512273
R5282 VDDD.n446 VDDD.n445 0.0512273
R5283 VDDD.n2353 VDDD.n2352 0.0512273
R5284 VDDD.n2353 VDDD.n602 0.0512273
R5285 VDDD.n603 VDDD.n598 0.0512273
R5286 VDDD.n599 VDDD.n598 0.0512273
R5287 VDDD.n2291 VDDD.n2290 0.0512273
R5288 VDDD.n2291 VDDD.n755 0.0512273
R5289 VDDD.n756 VDDD.n751 0.0512273
R5290 VDDD.n752 VDDD.n751 0.0512273
R5291 VDDD.n1526 VDDD.n1317 0.0512273
R5292 VDDD.n1520 VDDD.n1317 0.0512273
R5293 VDDD.n1328 VDDD.n1324 0.0512273
R5294 VDDD.n1514 VDDD.n1328 0.0512273
R5295 VDDD.n1672 VDDD.n1246 0.0512273
R5296 VDDD.n1666 VDDD.n1246 0.0512273
R5297 VDDD.n1257 VDDD.n1253 0.0512273
R5298 VDDD.n1660 VDDD.n1257 0.0512273
R5299 VDDD.n1818 VDDD.n1175 0.0512273
R5300 VDDD.n1812 VDDD.n1175 0.0512273
R5301 VDDD.n1186 VDDD.n1182 0.0512273
R5302 VDDD.n1806 VDDD.n1186 0.0512273
R5303 VDDD.n1964 VDDD.n1104 0.0512273
R5304 VDDD.n1958 VDDD.n1104 0.0512273
R5305 VDDD.n1115 VDDD.n1111 0.0512273
R5306 VDDD.n1952 VDDD.n1115 0.0512273
R5307 VDDD.n2097 VDDD.n1022 0.0512273
R5308 VDDD.n2091 VDDD.n1022 0.0512273
R5309 VDDD.n1033 VDDD.n1029 0.0512273
R5310 VDDD.n2085 VDDD.n1033 0.0512273
R5311 VDDD.n2817 VDDD.n4 0.0512273
R5312 VDDD.n2811 VDDD.n4 0.0512273
R5313 VDDD.n15 VDDD.n11 0.0512273
R5314 VDDD.n2805 VDDD.n15 0.0512273
R5315 VDDD.n1438 VDDD.n1437 0.04379
R5316 VDDD.n1584 VDDD.n1583 0.04379
R5317 VDDD.n1730 VDDD.n1729 0.04379
R5318 VDDD.n1876 VDDD.n1875 0.04379
R5319 VDDD.n2006 VDDD.n2005 0.04379
R5320 VDDD.n2267 VDDD.n2266 0.04379
R5321 VDDD.n2329 VDDD.n2328 0.04379
R5322 VDDD.n2391 VDDD.n2390 0.04379
R5323 VDDD.n2453 VDDD.n2452 0.04379
R5324 VDDD.n2515 VDDD.n2514 0.04379
R5325 VDDD.n2729 VDDD.n2728 0.04379
R5326 VDDD.n1446 VDDD.n1445 0.0369276
R5327 VDDD.n1592 VDDD.n1591 0.0369276
R5328 VDDD.n1738 VDDD.n1737 0.0369276
R5329 VDDD.n1884 VDDD.n1883 0.0369276
R5330 VDDD.n2014 VDDD.n2013 0.0369276
R5331 VDDD.n2259 VDDD.n2251 0.0369276
R5332 VDDD.n2321 VDDD.n2313 0.0369276
R5333 VDDD.n2383 VDDD.n2375 0.0369276
R5334 VDDD.n2445 VDDD.n2437 0.0369276
R5335 VDDD.n2507 VDDD.n2499 0.0369276
R5336 VDDD.n2737 VDDD.n2736 0.0369276
R5337 VDDD.n1445 VDDD.n1444 0.0342028
R5338 VDDD.n1591 VDDD.n1590 0.0342028
R5339 VDDD.n1737 VDDD.n1736 0.0342028
R5340 VDDD.n1883 VDDD.n1882 0.0342028
R5341 VDDD.n2013 VDDD.n2012 0.0342028
R5342 VDDD.n2260 VDDD.n2259 0.0342028
R5343 VDDD.n2322 VDDD.n2321 0.0342028
R5344 VDDD.n2384 VDDD.n2383 0.0342028
R5345 VDDD.n2446 VDDD.n2445 0.0342028
R5346 VDDD.n2508 VDDD.n2507 0.0342028
R5347 VDDD.n2736 VDDD.n2735 0.0342028
R5348 VDDD.n2543 VDDD.n143 0.0258636
R5349 VDDD.n2543 VDDD.n144 0.0258636
R5350 VDDD.n2481 VDDD.n296 0.0258636
R5351 VDDD.n2481 VDDD.n297 0.0258636
R5352 VDDD.n2419 VDDD.n449 0.0258636
R5353 VDDD.n2419 VDDD.n450 0.0258636
R5354 VDDD.n2357 VDDD.n602 0.0258636
R5355 VDDD.n2357 VDDD.n603 0.0258636
R5356 VDDD.n2295 VDDD.n755 0.0258636
R5357 VDDD.n2295 VDDD.n756 0.0258636
R5358 VDDD.n1520 VDDD.n1320 0.0258636
R5359 VDDD.n1324 VDDD.n1320 0.0258636
R5360 VDDD.n1666 VDDD.n1249 0.0258636
R5361 VDDD.n1253 VDDD.n1249 0.0258636
R5362 VDDD.n1812 VDDD.n1178 0.0258636
R5363 VDDD.n1182 VDDD.n1178 0.0258636
R5364 VDDD.n1958 VDDD.n1107 0.0258636
R5365 VDDD.n1111 VDDD.n1107 0.0258636
R5366 VDDD.n2091 VDDD.n1025 0.0258636
R5367 VDDD.n1029 VDDD.n1025 0.0258636
R5368 VDDD.n2811 VDDD.n7 0.0258636
R5369 VDDD.n11 VDDD.n7 0.0258636
R5370 VDDD.n1413 VDDD.n1412 0.01733
R5371 VDDD.n1436 VDDD.n1405 0.01733
R5372 VDDD.n1559 VDDD.n1558 0.01733
R5373 VDDD.n1582 VDDD.n1551 0.01733
R5374 VDDD.n1705 VDDD.n1704 0.01733
R5375 VDDD.n1728 VDDD.n1697 0.01733
R5376 VDDD.n1851 VDDD.n1850 0.01733
R5377 VDDD.n1874 VDDD.n1843 0.01733
R5378 VDDD.n1982 VDDD.n1981 0.01733
R5379 VDDD.n2004 VDDD.n1974 0.01733
R5380 VDDD.n2269 VDDD.n2268 0.01733
R5381 VDDD.n2284 VDDD.n2283 0.01733
R5382 VDDD.n2331 VDDD.n2330 0.01733
R5383 VDDD.n2346 VDDD.n2345 0.01733
R5384 VDDD.n2393 VDDD.n2392 0.01733
R5385 VDDD.n2408 VDDD.n2407 0.01733
R5386 VDDD.n2455 VDDD.n2454 0.01733
R5387 VDDD.n2470 VDDD.n2469 0.01733
R5388 VDDD.n2517 VDDD.n2516 0.01733
R5389 VDDD.n2532 VDDD.n2531 0.01733
R5390 VDDD.n2704 VDDD.n2703 0.01733
R5391 VDDD.n2727 VDDD.n2696 0.01733
R5392 VDDD.n2536 VDDD.n146 0.0164429
R5393 VDDD.n2540 VDDD.n146 0.0164429
R5394 VDDD.n2541 VDDD.n2540 0.0164429
R5395 VDDD.n2541 VDDD.n138 0.0164429
R5396 VDDD.n2547 VDDD.n138 0.0164429
R5397 VDDD.n2547 VDDD.n142 0.0164429
R5398 VDDD.n142 VDDD.n141 0.0164429
R5399 VDDD.n2550 VDDD.n118 0.0164429
R5400 VDDD.n237 VDDD.n236 0.0164429
R5401 VDDD.n236 VDDD.n235 0.0164429
R5402 VDDD.n235 VDDD.n198 0.0164429
R5403 VDDD.n231 VDDD.n198 0.0164429
R5404 VDDD.n231 VDDD.n230 0.0164429
R5405 VDDD.n230 VDDD.n229 0.0164429
R5406 VDDD.n229 VDDD.n203 0.0164429
R5407 VDDD.n225 VDDD.n203 0.0164429
R5408 VDDD.n2474 VDDD.n299 0.0164429
R5409 VDDD.n2478 VDDD.n299 0.0164429
R5410 VDDD.n2479 VDDD.n2478 0.0164429
R5411 VDDD.n2479 VDDD.n291 0.0164429
R5412 VDDD.n2485 VDDD.n291 0.0164429
R5413 VDDD.n2485 VDDD.n295 0.0164429
R5414 VDDD.n295 VDDD.n294 0.0164429
R5415 VDDD.n2488 VDDD.n271 0.0164429
R5416 VDDD.n390 VDDD.n389 0.0164429
R5417 VDDD.n389 VDDD.n388 0.0164429
R5418 VDDD.n388 VDDD.n351 0.0164429
R5419 VDDD.n384 VDDD.n351 0.0164429
R5420 VDDD.n384 VDDD.n383 0.0164429
R5421 VDDD.n383 VDDD.n382 0.0164429
R5422 VDDD.n382 VDDD.n356 0.0164429
R5423 VDDD.n378 VDDD.n356 0.0164429
R5424 VDDD.n2412 VDDD.n452 0.0164429
R5425 VDDD.n2416 VDDD.n452 0.0164429
R5426 VDDD.n2417 VDDD.n2416 0.0164429
R5427 VDDD.n2417 VDDD.n444 0.0164429
R5428 VDDD.n2423 VDDD.n444 0.0164429
R5429 VDDD.n2423 VDDD.n448 0.0164429
R5430 VDDD.n448 VDDD.n447 0.0164429
R5431 VDDD.n2426 VDDD.n424 0.0164429
R5432 VDDD.n543 VDDD.n542 0.0164429
R5433 VDDD.n542 VDDD.n541 0.0164429
R5434 VDDD.n541 VDDD.n504 0.0164429
R5435 VDDD.n537 VDDD.n504 0.0164429
R5436 VDDD.n537 VDDD.n536 0.0164429
R5437 VDDD.n536 VDDD.n535 0.0164429
R5438 VDDD.n535 VDDD.n509 0.0164429
R5439 VDDD.n531 VDDD.n509 0.0164429
R5440 VDDD.n2350 VDDD.n605 0.0164429
R5441 VDDD.n2354 VDDD.n605 0.0164429
R5442 VDDD.n2355 VDDD.n2354 0.0164429
R5443 VDDD.n2355 VDDD.n597 0.0164429
R5444 VDDD.n2361 VDDD.n597 0.0164429
R5445 VDDD.n2361 VDDD.n601 0.0164429
R5446 VDDD.n601 VDDD.n600 0.0164429
R5447 VDDD.n2364 VDDD.n577 0.0164429
R5448 VDDD.n696 VDDD.n695 0.0164429
R5449 VDDD.n695 VDDD.n694 0.0164429
R5450 VDDD.n694 VDDD.n657 0.0164429
R5451 VDDD.n690 VDDD.n657 0.0164429
R5452 VDDD.n690 VDDD.n689 0.0164429
R5453 VDDD.n689 VDDD.n688 0.0164429
R5454 VDDD.n688 VDDD.n662 0.0164429
R5455 VDDD.n684 VDDD.n662 0.0164429
R5456 VDDD.n2288 VDDD.n758 0.0164429
R5457 VDDD.n2292 VDDD.n758 0.0164429
R5458 VDDD.n2293 VDDD.n2292 0.0164429
R5459 VDDD.n2293 VDDD.n750 0.0164429
R5460 VDDD.n2299 VDDD.n750 0.0164429
R5461 VDDD.n2299 VDDD.n754 0.0164429
R5462 VDDD.n754 VDDD.n753 0.0164429
R5463 VDDD.n2302 VDDD.n730 0.0164429
R5464 VDDD.n846 VDDD.n845 0.0164429
R5465 VDDD.n845 VDDD.n844 0.0164429
R5466 VDDD.n844 VDDD.n807 0.0164429
R5467 VDDD.n840 VDDD.n807 0.0164429
R5468 VDDD.n840 VDDD.n839 0.0164429
R5469 VDDD.n839 VDDD.n838 0.0164429
R5470 VDDD.n838 VDDD.n812 0.0164429
R5471 VDDD.n834 VDDD.n812 0.0164429
R5472 VDDD.n1481 VDDD.n1353 0.0164429
R5473 VDDD.n1481 VDDD.n1480 0.0164429
R5474 VDDD.n1480 VDDD.n1479 0.0164429
R5475 VDDD.n1479 VDDD.n1478 0.0164429
R5476 VDDD.n1478 VDDD.n1477 0.0164429
R5477 VDDD.n1477 VDDD.n1476 0.0164429
R5478 VDDD.n1476 VDDD.n1475 0.0164429
R5479 VDDD.n1475 VDDD.n1342 0.0164429
R5480 VDDD.n1487 VDDD.n1338 0.0164429
R5481 VDDD.n1525 VDDD.n1316 0.0164429
R5482 VDDD.n1525 VDDD.n1319 0.0164429
R5483 VDDD.n1521 VDDD.n1319 0.0164429
R5484 VDDD.n1521 VDDD.n1519 0.0164429
R5485 VDDD.n1519 VDDD.n1323 0.0164429
R5486 VDDD.n1515 VDDD.n1323 0.0164429
R5487 VDDD.n1515 VDDD.n1327 0.0164429
R5488 VDDD.n1627 VDDD.n1282 0.0164429
R5489 VDDD.n1627 VDDD.n1626 0.0164429
R5490 VDDD.n1626 VDDD.n1625 0.0164429
R5491 VDDD.n1625 VDDD.n1624 0.0164429
R5492 VDDD.n1624 VDDD.n1623 0.0164429
R5493 VDDD.n1623 VDDD.n1622 0.0164429
R5494 VDDD.n1622 VDDD.n1621 0.0164429
R5495 VDDD.n1621 VDDD.n1271 0.0164429
R5496 VDDD.n1633 VDDD.n1267 0.0164429
R5497 VDDD.n1671 VDDD.n1245 0.0164429
R5498 VDDD.n1671 VDDD.n1248 0.0164429
R5499 VDDD.n1667 VDDD.n1248 0.0164429
R5500 VDDD.n1667 VDDD.n1665 0.0164429
R5501 VDDD.n1665 VDDD.n1252 0.0164429
R5502 VDDD.n1661 VDDD.n1252 0.0164429
R5503 VDDD.n1661 VDDD.n1256 0.0164429
R5504 VDDD.n1773 VDDD.n1211 0.0164429
R5505 VDDD.n1773 VDDD.n1772 0.0164429
R5506 VDDD.n1772 VDDD.n1771 0.0164429
R5507 VDDD.n1771 VDDD.n1770 0.0164429
R5508 VDDD.n1770 VDDD.n1769 0.0164429
R5509 VDDD.n1769 VDDD.n1768 0.0164429
R5510 VDDD.n1768 VDDD.n1767 0.0164429
R5511 VDDD.n1767 VDDD.n1200 0.0164429
R5512 VDDD.n1779 VDDD.n1196 0.0164429
R5513 VDDD.n1817 VDDD.n1174 0.0164429
R5514 VDDD.n1817 VDDD.n1177 0.0164429
R5515 VDDD.n1813 VDDD.n1177 0.0164429
R5516 VDDD.n1813 VDDD.n1811 0.0164429
R5517 VDDD.n1811 VDDD.n1181 0.0164429
R5518 VDDD.n1807 VDDD.n1181 0.0164429
R5519 VDDD.n1807 VDDD.n1185 0.0164429
R5520 VDDD.n1919 VDDD.n1140 0.0164429
R5521 VDDD.n1919 VDDD.n1918 0.0164429
R5522 VDDD.n1918 VDDD.n1917 0.0164429
R5523 VDDD.n1917 VDDD.n1916 0.0164429
R5524 VDDD.n1916 VDDD.n1915 0.0164429
R5525 VDDD.n1915 VDDD.n1914 0.0164429
R5526 VDDD.n1914 VDDD.n1913 0.0164429
R5527 VDDD.n1913 VDDD.n1129 0.0164429
R5528 VDDD.n1925 VDDD.n1125 0.0164429
R5529 VDDD.n1963 VDDD.n1103 0.0164429
R5530 VDDD.n1963 VDDD.n1106 0.0164429
R5531 VDDD.n1959 VDDD.n1106 0.0164429
R5532 VDDD.n1959 VDDD.n1957 0.0164429
R5533 VDDD.n1957 VDDD.n1110 0.0164429
R5534 VDDD.n1953 VDDD.n1110 0.0164429
R5535 VDDD.n1953 VDDD.n1114 0.0164429
R5536 VDDD.n2052 VDDD.n1058 0.0164429
R5537 VDDD.n2052 VDDD.n2051 0.0164429
R5538 VDDD.n2051 VDDD.n2050 0.0164429
R5539 VDDD.n2050 VDDD.n2049 0.0164429
R5540 VDDD.n2049 VDDD.n2048 0.0164429
R5541 VDDD.n2048 VDDD.n2047 0.0164429
R5542 VDDD.n2047 VDDD.n2046 0.0164429
R5543 VDDD.n2046 VDDD.n1047 0.0164429
R5544 VDDD.n2058 VDDD.n1043 0.0164429
R5545 VDDD.n2096 VDDD.n1021 0.0164429
R5546 VDDD.n2096 VDDD.n1024 0.0164429
R5547 VDDD.n2092 VDDD.n1024 0.0164429
R5548 VDDD.n2092 VDDD.n2090 0.0164429
R5549 VDDD.n2090 VDDD.n1028 0.0164429
R5550 VDDD.n2086 VDDD.n1028 0.0164429
R5551 VDDD.n2086 VDDD.n1032 0.0164429
R5552 VDDD.n2772 VDDD.n40 0.0164429
R5553 VDDD.n2772 VDDD.n2771 0.0164429
R5554 VDDD.n2771 VDDD.n2770 0.0164429
R5555 VDDD.n2770 VDDD.n2769 0.0164429
R5556 VDDD.n2769 VDDD.n2768 0.0164429
R5557 VDDD.n2768 VDDD.n2767 0.0164429
R5558 VDDD.n2767 VDDD.n2766 0.0164429
R5559 VDDD.n2766 VDDD.n29 0.0164429
R5560 VDDD.n2778 VDDD.n25 0.0164429
R5561 VDDD.n2816 VDDD.n3 0.0164429
R5562 VDDD.n2816 VDDD.n6 0.0164429
R5563 VDDD.n2812 VDDD.n6 0.0164429
R5564 VDDD.n2812 VDDD.n2810 0.0164429
R5565 VDDD.n2810 VDDD.n10 0.0164429
R5566 VDDD.n2806 VDDD.n10 0.0164429
R5567 VDDD.n2806 VDDD.n14 0.0164429
R5568 VDDD.n238 VDDD.n194 0.0161303
R5569 VDDD.n234 VDDD.n194 0.0161303
R5570 VDDD.n234 VDDD.n233 0.0161303
R5571 VDDD.n233 VDDD.n232 0.0161303
R5572 VDDD.n232 VDDD.n199 0.0161303
R5573 VDDD.n228 VDDD.n199 0.0161303
R5574 VDDD.n228 VDDD.n227 0.0161303
R5575 VDDD.n391 VDDD.n347 0.0161303
R5576 VDDD.n387 VDDD.n347 0.0161303
R5577 VDDD.n387 VDDD.n386 0.0161303
R5578 VDDD.n386 VDDD.n385 0.0161303
R5579 VDDD.n385 VDDD.n352 0.0161303
R5580 VDDD.n381 VDDD.n352 0.0161303
R5581 VDDD.n381 VDDD.n380 0.0161303
R5582 VDDD.n544 VDDD.n500 0.0161303
R5583 VDDD.n540 VDDD.n500 0.0161303
R5584 VDDD.n540 VDDD.n539 0.0161303
R5585 VDDD.n539 VDDD.n538 0.0161303
R5586 VDDD.n538 VDDD.n505 0.0161303
R5587 VDDD.n534 VDDD.n505 0.0161303
R5588 VDDD.n534 VDDD.n533 0.0161303
R5589 VDDD.n697 VDDD.n653 0.0161303
R5590 VDDD.n693 VDDD.n653 0.0161303
R5591 VDDD.n693 VDDD.n692 0.0161303
R5592 VDDD.n692 VDDD.n691 0.0161303
R5593 VDDD.n691 VDDD.n658 0.0161303
R5594 VDDD.n687 VDDD.n658 0.0161303
R5595 VDDD.n687 VDDD.n686 0.0161303
R5596 VDDD.n847 VDDD.n803 0.0161303
R5597 VDDD.n843 VDDD.n803 0.0161303
R5598 VDDD.n843 VDDD.n842 0.0161303
R5599 VDDD.n842 VDDD.n841 0.0161303
R5600 VDDD.n841 VDDD.n808 0.0161303
R5601 VDDD.n837 VDDD.n808 0.0161303
R5602 VDDD.n837 VDDD.n836 0.0161303
R5603 VDDD.n1482 VDDD.n1354 0.0161303
R5604 VDDD.n1355 VDDD.n1354 0.0161303
R5605 VDDD.n1356 VDDD.n1355 0.0161303
R5606 VDDD.n1357 VDDD.n1356 0.0161303
R5607 VDDD.n1358 VDDD.n1357 0.0161303
R5608 VDDD.n1474 VDDD.n1358 0.0161303
R5609 VDDD.n1474 VDDD.n1473 0.0161303
R5610 VDDD.n1628 VDDD.n1283 0.0161303
R5611 VDDD.n1284 VDDD.n1283 0.0161303
R5612 VDDD.n1285 VDDD.n1284 0.0161303
R5613 VDDD.n1286 VDDD.n1285 0.0161303
R5614 VDDD.n1287 VDDD.n1286 0.0161303
R5615 VDDD.n1620 VDDD.n1287 0.0161303
R5616 VDDD.n1620 VDDD.n1619 0.0161303
R5617 VDDD.n1774 VDDD.n1212 0.0161303
R5618 VDDD.n1213 VDDD.n1212 0.0161303
R5619 VDDD.n1214 VDDD.n1213 0.0161303
R5620 VDDD.n1215 VDDD.n1214 0.0161303
R5621 VDDD.n1216 VDDD.n1215 0.0161303
R5622 VDDD.n1766 VDDD.n1216 0.0161303
R5623 VDDD.n1766 VDDD.n1765 0.0161303
R5624 VDDD.n1920 VDDD.n1141 0.0161303
R5625 VDDD.n1142 VDDD.n1141 0.0161303
R5626 VDDD.n1143 VDDD.n1142 0.0161303
R5627 VDDD.n1144 VDDD.n1143 0.0161303
R5628 VDDD.n1145 VDDD.n1144 0.0161303
R5629 VDDD.n1912 VDDD.n1145 0.0161303
R5630 VDDD.n1912 VDDD.n1911 0.0161303
R5631 VDDD.n2053 VDDD.n1059 0.0161303
R5632 VDDD.n1060 VDDD.n1059 0.0161303
R5633 VDDD.n1061 VDDD.n1060 0.0161303
R5634 VDDD.n1062 VDDD.n1061 0.0161303
R5635 VDDD.n1063 VDDD.n1062 0.0161303
R5636 VDDD.n2045 VDDD.n1063 0.0161303
R5637 VDDD.n2045 VDDD.n2044 0.0161303
R5638 VDDD.n2773 VDDD.n41 0.0161303
R5639 VDDD.n42 VDDD.n41 0.0161303
R5640 VDDD.n43 VDDD.n42 0.0161303
R5641 VDDD.n44 VDDD.n43 0.0161303
R5642 VDDD.n45 VDDD.n44 0.0161303
R5643 VDDD.n2765 VDDD.n45 0.0161303
R5644 VDDD.n2765 VDDD.n2764 0.0161303
R5645 VDDD.n260 VDDD.n184 0.0157044
R5646 VDDD.n413 VDDD.n337 0.0157044
R5647 VDDD.n566 VDDD.n490 0.0157044
R5648 VDDD.n719 VDDD.n643 0.0157044
R5649 VDDD.n869 VDDD.n793 0.0157044
R5650 VDDD.n1459 VDDD.n1379 0.0157044
R5651 VDDD.n1605 VDDD.n1308 0.0157044
R5652 VDDD.n1751 VDDD.n1237 0.0157044
R5653 VDDD.n1897 VDDD.n1166 0.0157044
R5654 VDDD.n2030 VDDD.n1084 0.0157044
R5655 VDDD.n2750 VDDD.n66 0.0157044
R5656 VDDD.n1412 VDDD.n1411 0.01499
R5657 VDDD.n1437 VDDD.n1436 0.01499
R5658 VDDD.n1558 VDDD.n1557 0.01499
R5659 VDDD.n1583 VDDD.n1582 0.01499
R5660 VDDD.n1704 VDDD.n1703 0.01499
R5661 VDDD.n1729 VDDD.n1728 0.01499
R5662 VDDD.n1850 VDDD.n1849 0.01499
R5663 VDDD.n1875 VDDD.n1874 0.01499
R5664 VDDD.n1981 VDDD.n1980 0.01499
R5665 VDDD.n2005 VDDD.n2004 0.01499
R5666 VDDD.n2268 VDDD.n2267 0.01499
R5667 VDDD.n2283 VDDD.n766 0.01499
R5668 VDDD.n2330 VDDD.n2329 0.01499
R5669 VDDD.n2345 VDDD.n613 0.01499
R5670 VDDD.n2392 VDDD.n2391 0.01499
R5671 VDDD.n2407 VDDD.n460 0.01499
R5672 VDDD.n2454 VDDD.n2453 0.01499
R5673 VDDD.n2469 VDDD.n307 0.01499
R5674 VDDD.n2516 VDDD.n2515 0.01499
R5675 VDDD.n2531 VDDD.n154 0.01499
R5676 VDDD.n2703 VDDD.n2702 0.01499
R5677 VDDD.n2728 VDDD.n2727 0.01499
R5678 VDDD.n2520 VDDD.n161 0.0138594
R5679 VDDD.n2527 VDDD.n2526 0.0138594
R5680 VDDD.n2458 VDDD.n314 0.0138594
R5681 VDDD.n2465 VDDD.n2464 0.0138594
R5682 VDDD.n2396 VDDD.n467 0.0138594
R5683 VDDD.n2403 VDDD.n2402 0.0138594
R5684 VDDD.n2334 VDDD.n620 0.0138594
R5685 VDDD.n2341 VDDD.n2340 0.0138594
R5686 VDDD.n2272 VDDD.n773 0.0138594
R5687 VDDD.n2279 VDDD.n2278 0.0138594
R5688 VDDD.n1422 VDDD.n1404 0.0138594
R5689 VDDD.n1418 VDDD.n1410 0.0138594
R5690 VDDD.n1568 VDDD.n1550 0.0138594
R5691 VDDD.n1564 VDDD.n1556 0.0138594
R5692 VDDD.n1714 VDDD.n1696 0.0138594
R5693 VDDD.n1710 VDDD.n1702 0.0138594
R5694 VDDD.n1860 VDDD.n1842 0.0138594
R5695 VDDD.n1856 VDDD.n1848 0.0138594
R5696 VDDD.n1991 VDDD.n1973 0.0138594
R5697 VDDD.n1987 VDDD.n1979 0.0138594
R5698 VDDD.n2713 VDDD.n2695 0.0138594
R5699 VDDD.n2709 VDDD.n2701 0.0138594
R5700 VDDD.n2537 VDDD.n150 0.00900201
R5701 VDDD.n2551 VDDD.n117 0.00900201
R5702 VDDD.n2475 VDDD.n303 0.00900201
R5703 VDDD.n2489 VDDD.n270 0.00900201
R5704 VDDD.n2413 VDDD.n456 0.00900201
R5705 VDDD.n2427 VDDD.n423 0.00900201
R5706 VDDD.n2351 VDDD.n609 0.00900201
R5707 VDDD.n2365 VDDD.n576 0.00900201
R5708 VDDD.n2289 VDDD.n762 0.00900201
R5709 VDDD.n2303 VDDD.n729 0.00900201
R5710 VDDD.n1528 VDDD.n1527 0.00900201
R5711 VDDD.n1513 VDDD.n1512 0.00900201
R5712 VDDD.n1674 VDDD.n1673 0.00900201
R5713 VDDD.n1659 VDDD.n1658 0.00900201
R5714 VDDD.n1820 VDDD.n1819 0.00900201
R5715 VDDD.n1805 VDDD.n1804 0.00900201
R5716 VDDD.n1966 VDDD.n1965 0.00900201
R5717 VDDD.n1951 VDDD.n1950 0.00900201
R5718 VDDD.n2099 VDDD.n2098 0.00900201
R5719 VDDD.n2084 VDDD.n2083 0.00900201
R5720 VDDD.n2819 VDDD.n2818 0.00900201
R5721 VDDD.n2804 VDDD.n2803 0.00900201
R5722 VDDD.n151 VDDD.n132 0.00895733
R5723 VDDD.n132 VDDD.n131 0.00895733
R5724 VDDD.n135 VDDD.n133 0.00895733
R5725 VDDD.n135 VDDD.n134 0.00895733
R5726 VDDD.n2548 VDDD.n136 0.00895733
R5727 VDDD.n2548 VDDD.n137 0.00895733
R5728 VDDD.n125 VDDD.n118 0.00895733
R5729 VDDD.n152 VDDD.n151 0.00895733
R5730 VDDD.n133 VDDD.n128 0.00895733
R5731 VDDD.n136 VDDD.n127 0.00895733
R5732 VDDD.n131 VDDD.n128 0.00895733
R5733 VDDD.n134 VDDD.n127 0.00895733
R5734 VDDD.n137 VDDD.n126 0.00895733
R5735 VDDD.n126 VDDD.n125 0.00895733
R5736 VDDD.n214 VDDD.n195 0.00895733
R5737 VDDD.n218 VDDD.n197 0.00895733
R5738 VDDD.n213 VDDD.n197 0.00895733
R5739 VDDD.n217 VDDD.n200 0.00895733
R5740 VDDD.n212 VDDD.n200 0.00895733
R5741 VDDD.n215 VDDD.n202 0.00895733
R5742 VDDD.n211 VDDD.n202 0.00895733
R5743 VDDD.n224 VDDD.n205 0.00895733
R5744 VDDD.n224 VDDD.n207 0.00895733
R5745 VDDD.n218 VDDD.n196 0.00895733
R5746 VDDD.n217 VDDD.n216 0.00895733
R5747 VDDD.n215 VDDD.n201 0.00895733
R5748 VDDD.n210 VDDD.n205 0.00895733
R5749 VDDD.n214 VDDD.n196 0.00895733
R5750 VDDD.n216 VDDD.n213 0.00895733
R5751 VDDD.n212 VDDD.n201 0.00895733
R5752 VDDD.n211 VDDD.n210 0.00895733
R5753 VDDD.n207 VDDD.n204 0.00895733
R5754 VDDD.n304 VDDD.n285 0.00895733
R5755 VDDD.n285 VDDD.n284 0.00895733
R5756 VDDD.n288 VDDD.n286 0.00895733
R5757 VDDD.n288 VDDD.n287 0.00895733
R5758 VDDD.n2486 VDDD.n289 0.00895733
R5759 VDDD.n2486 VDDD.n290 0.00895733
R5760 VDDD.n278 VDDD.n271 0.00895733
R5761 VDDD.n305 VDDD.n304 0.00895733
R5762 VDDD.n286 VDDD.n281 0.00895733
R5763 VDDD.n289 VDDD.n280 0.00895733
R5764 VDDD.n284 VDDD.n281 0.00895733
R5765 VDDD.n287 VDDD.n280 0.00895733
R5766 VDDD.n290 VDDD.n279 0.00895733
R5767 VDDD.n279 VDDD.n278 0.00895733
R5768 VDDD.n367 VDDD.n348 0.00895733
R5769 VDDD.n371 VDDD.n350 0.00895733
R5770 VDDD.n366 VDDD.n350 0.00895733
R5771 VDDD.n370 VDDD.n353 0.00895733
R5772 VDDD.n365 VDDD.n353 0.00895733
R5773 VDDD.n368 VDDD.n355 0.00895733
R5774 VDDD.n364 VDDD.n355 0.00895733
R5775 VDDD.n377 VDDD.n358 0.00895733
R5776 VDDD.n377 VDDD.n360 0.00895733
R5777 VDDD.n371 VDDD.n349 0.00895733
R5778 VDDD.n370 VDDD.n369 0.00895733
R5779 VDDD.n368 VDDD.n354 0.00895733
R5780 VDDD.n363 VDDD.n358 0.00895733
R5781 VDDD.n367 VDDD.n349 0.00895733
R5782 VDDD.n369 VDDD.n366 0.00895733
R5783 VDDD.n365 VDDD.n354 0.00895733
R5784 VDDD.n364 VDDD.n363 0.00895733
R5785 VDDD.n360 VDDD.n357 0.00895733
R5786 VDDD.n457 VDDD.n438 0.00895733
R5787 VDDD.n438 VDDD.n437 0.00895733
R5788 VDDD.n441 VDDD.n439 0.00895733
R5789 VDDD.n441 VDDD.n440 0.00895733
R5790 VDDD.n2424 VDDD.n442 0.00895733
R5791 VDDD.n2424 VDDD.n443 0.00895733
R5792 VDDD.n431 VDDD.n424 0.00895733
R5793 VDDD.n458 VDDD.n457 0.00895733
R5794 VDDD.n439 VDDD.n434 0.00895733
R5795 VDDD.n442 VDDD.n433 0.00895733
R5796 VDDD.n437 VDDD.n434 0.00895733
R5797 VDDD.n440 VDDD.n433 0.00895733
R5798 VDDD.n443 VDDD.n432 0.00895733
R5799 VDDD.n432 VDDD.n431 0.00895733
R5800 VDDD.n520 VDDD.n501 0.00895733
R5801 VDDD.n524 VDDD.n503 0.00895733
R5802 VDDD.n519 VDDD.n503 0.00895733
R5803 VDDD.n523 VDDD.n506 0.00895733
R5804 VDDD.n518 VDDD.n506 0.00895733
R5805 VDDD.n521 VDDD.n508 0.00895733
R5806 VDDD.n517 VDDD.n508 0.00895733
R5807 VDDD.n530 VDDD.n511 0.00895733
R5808 VDDD.n530 VDDD.n513 0.00895733
R5809 VDDD.n524 VDDD.n502 0.00895733
R5810 VDDD.n523 VDDD.n522 0.00895733
R5811 VDDD.n521 VDDD.n507 0.00895733
R5812 VDDD.n516 VDDD.n511 0.00895733
R5813 VDDD.n520 VDDD.n502 0.00895733
R5814 VDDD.n522 VDDD.n519 0.00895733
R5815 VDDD.n518 VDDD.n507 0.00895733
R5816 VDDD.n517 VDDD.n516 0.00895733
R5817 VDDD.n513 VDDD.n510 0.00895733
R5818 VDDD.n610 VDDD.n591 0.00895733
R5819 VDDD.n591 VDDD.n590 0.00895733
R5820 VDDD.n594 VDDD.n592 0.00895733
R5821 VDDD.n594 VDDD.n593 0.00895733
R5822 VDDD.n2362 VDDD.n595 0.00895733
R5823 VDDD.n2362 VDDD.n596 0.00895733
R5824 VDDD.n584 VDDD.n577 0.00895733
R5825 VDDD.n611 VDDD.n610 0.00895733
R5826 VDDD.n592 VDDD.n587 0.00895733
R5827 VDDD.n595 VDDD.n586 0.00895733
R5828 VDDD.n590 VDDD.n587 0.00895733
R5829 VDDD.n593 VDDD.n586 0.00895733
R5830 VDDD.n596 VDDD.n585 0.00895733
R5831 VDDD.n585 VDDD.n584 0.00895733
R5832 VDDD.n673 VDDD.n654 0.00895733
R5833 VDDD.n677 VDDD.n656 0.00895733
R5834 VDDD.n672 VDDD.n656 0.00895733
R5835 VDDD.n676 VDDD.n659 0.00895733
R5836 VDDD.n671 VDDD.n659 0.00895733
R5837 VDDD.n674 VDDD.n661 0.00895733
R5838 VDDD.n670 VDDD.n661 0.00895733
R5839 VDDD.n683 VDDD.n664 0.00895733
R5840 VDDD.n683 VDDD.n666 0.00895733
R5841 VDDD.n677 VDDD.n655 0.00895733
R5842 VDDD.n676 VDDD.n675 0.00895733
R5843 VDDD.n674 VDDD.n660 0.00895733
R5844 VDDD.n669 VDDD.n664 0.00895733
R5845 VDDD.n673 VDDD.n655 0.00895733
R5846 VDDD.n675 VDDD.n672 0.00895733
R5847 VDDD.n671 VDDD.n660 0.00895733
R5848 VDDD.n670 VDDD.n669 0.00895733
R5849 VDDD.n666 VDDD.n663 0.00895733
R5850 VDDD.n763 VDDD.n744 0.00895733
R5851 VDDD.n744 VDDD.n743 0.00895733
R5852 VDDD.n747 VDDD.n745 0.00895733
R5853 VDDD.n747 VDDD.n746 0.00895733
R5854 VDDD.n2300 VDDD.n748 0.00895733
R5855 VDDD.n2300 VDDD.n749 0.00895733
R5856 VDDD.n737 VDDD.n730 0.00895733
R5857 VDDD.n764 VDDD.n763 0.00895733
R5858 VDDD.n745 VDDD.n740 0.00895733
R5859 VDDD.n748 VDDD.n739 0.00895733
R5860 VDDD.n743 VDDD.n740 0.00895733
R5861 VDDD.n746 VDDD.n739 0.00895733
R5862 VDDD.n749 VDDD.n738 0.00895733
R5863 VDDD.n738 VDDD.n737 0.00895733
R5864 VDDD.n823 VDDD.n804 0.00895733
R5865 VDDD.n827 VDDD.n806 0.00895733
R5866 VDDD.n822 VDDD.n806 0.00895733
R5867 VDDD.n826 VDDD.n809 0.00895733
R5868 VDDD.n821 VDDD.n809 0.00895733
R5869 VDDD.n824 VDDD.n811 0.00895733
R5870 VDDD.n820 VDDD.n811 0.00895733
R5871 VDDD.n833 VDDD.n814 0.00895733
R5872 VDDD.n833 VDDD.n816 0.00895733
R5873 VDDD.n827 VDDD.n805 0.00895733
R5874 VDDD.n826 VDDD.n825 0.00895733
R5875 VDDD.n824 VDDD.n810 0.00895733
R5876 VDDD.n819 VDDD.n814 0.00895733
R5877 VDDD.n823 VDDD.n805 0.00895733
R5878 VDDD.n825 VDDD.n822 0.00895733
R5879 VDDD.n821 VDDD.n810 0.00895733
R5880 VDDD.n820 VDDD.n819 0.00895733
R5881 VDDD.n816 VDDD.n813 0.00895733
R5882 VDDD.n1345 VDDD.n1333 0.00895733
R5883 VDDD.n1340 VDDD.n1333 0.00895733
R5884 VDDD.n1344 VDDD.n1332 0.00895733
R5885 VDDD.n1339 VDDD.n1332 0.00895733
R5886 VDDD.n1343 VDDD.n1331 0.00895733
R5887 VDDD.n1350 VDDD.n1331 0.00895733
R5888 VDDD.n1338 VDDD.n1330 0.00895733
R5889 VDDD.n1345 VDDD.n1335 0.00895733
R5890 VDDD.n1344 VDDD.n1336 0.00895733
R5891 VDDD.n1343 VDDD.n1337 0.00895733
R5892 VDDD.n1340 VDDD.n1336 0.00895733
R5893 VDDD.n1339 VDDD.n1337 0.00895733
R5894 VDDD.n1351 VDDD.n1350 0.00895733
R5895 VDDD.n1351 VDDD.n1330 0.00895733
R5896 VDDD.n1505 VDDD.n1315 0.00895733
R5897 VDDD.n1498 VDDD.n1318 0.00895733
R5898 VDDD.n1507 VDDD.n1318 0.00895733
R5899 VDDD.n1495 VDDD.n1321 0.00895733
R5900 VDDD.n1504 VDDD.n1321 0.00895733
R5901 VDDD.n1502 VDDD.n1501 0.00895733
R5902 VDDD.n1503 VDDD.n1502 0.00895733
R5903 VDDD.n1497 VDDD.n1492 0.00895733
R5904 VDDD.n1510 VDDD.n1492 0.00895733
R5905 VDDD.n1498 VDDD.n1494 0.00895733
R5906 VDDD.n1508 VDDD.n1495 0.00895733
R5907 VDDD.n1501 VDDD.n1322 0.00895733
R5908 VDDD.n1497 VDDD.n1326 0.00895733
R5909 VDDD.n1505 VDDD.n1494 0.00895733
R5910 VDDD.n1508 VDDD.n1507 0.00895733
R5911 VDDD.n1504 VDDD.n1322 0.00895733
R5912 VDDD.n1503 VDDD.n1326 0.00895733
R5913 VDDD.n1511 VDDD.n1510 0.00895733
R5914 VDDD.n1274 VDDD.n1262 0.00895733
R5915 VDDD.n1269 VDDD.n1262 0.00895733
R5916 VDDD.n1273 VDDD.n1261 0.00895733
R5917 VDDD.n1268 VDDD.n1261 0.00895733
R5918 VDDD.n1272 VDDD.n1260 0.00895733
R5919 VDDD.n1279 VDDD.n1260 0.00895733
R5920 VDDD.n1267 VDDD.n1259 0.00895733
R5921 VDDD.n1274 VDDD.n1264 0.00895733
R5922 VDDD.n1273 VDDD.n1265 0.00895733
R5923 VDDD.n1272 VDDD.n1266 0.00895733
R5924 VDDD.n1269 VDDD.n1265 0.00895733
R5925 VDDD.n1268 VDDD.n1266 0.00895733
R5926 VDDD.n1280 VDDD.n1279 0.00895733
R5927 VDDD.n1280 VDDD.n1259 0.00895733
R5928 VDDD.n1651 VDDD.n1244 0.00895733
R5929 VDDD.n1644 VDDD.n1247 0.00895733
R5930 VDDD.n1653 VDDD.n1247 0.00895733
R5931 VDDD.n1641 VDDD.n1250 0.00895733
R5932 VDDD.n1650 VDDD.n1250 0.00895733
R5933 VDDD.n1648 VDDD.n1647 0.00895733
R5934 VDDD.n1649 VDDD.n1648 0.00895733
R5935 VDDD.n1643 VDDD.n1638 0.00895733
R5936 VDDD.n1656 VDDD.n1638 0.00895733
R5937 VDDD.n1644 VDDD.n1640 0.00895733
R5938 VDDD.n1654 VDDD.n1641 0.00895733
R5939 VDDD.n1647 VDDD.n1251 0.00895733
R5940 VDDD.n1643 VDDD.n1255 0.00895733
R5941 VDDD.n1651 VDDD.n1640 0.00895733
R5942 VDDD.n1654 VDDD.n1653 0.00895733
R5943 VDDD.n1650 VDDD.n1251 0.00895733
R5944 VDDD.n1649 VDDD.n1255 0.00895733
R5945 VDDD.n1657 VDDD.n1656 0.00895733
R5946 VDDD.n1203 VDDD.n1191 0.00895733
R5947 VDDD.n1198 VDDD.n1191 0.00895733
R5948 VDDD.n1202 VDDD.n1190 0.00895733
R5949 VDDD.n1197 VDDD.n1190 0.00895733
R5950 VDDD.n1201 VDDD.n1189 0.00895733
R5951 VDDD.n1208 VDDD.n1189 0.00895733
R5952 VDDD.n1196 VDDD.n1188 0.00895733
R5953 VDDD.n1203 VDDD.n1193 0.00895733
R5954 VDDD.n1202 VDDD.n1194 0.00895733
R5955 VDDD.n1201 VDDD.n1195 0.00895733
R5956 VDDD.n1198 VDDD.n1194 0.00895733
R5957 VDDD.n1197 VDDD.n1195 0.00895733
R5958 VDDD.n1209 VDDD.n1208 0.00895733
R5959 VDDD.n1209 VDDD.n1188 0.00895733
R5960 VDDD.n1797 VDDD.n1173 0.00895733
R5961 VDDD.n1790 VDDD.n1176 0.00895733
R5962 VDDD.n1799 VDDD.n1176 0.00895733
R5963 VDDD.n1787 VDDD.n1179 0.00895733
R5964 VDDD.n1796 VDDD.n1179 0.00895733
R5965 VDDD.n1794 VDDD.n1793 0.00895733
R5966 VDDD.n1795 VDDD.n1794 0.00895733
R5967 VDDD.n1789 VDDD.n1784 0.00895733
R5968 VDDD.n1802 VDDD.n1784 0.00895733
R5969 VDDD.n1790 VDDD.n1786 0.00895733
R5970 VDDD.n1800 VDDD.n1787 0.00895733
R5971 VDDD.n1793 VDDD.n1180 0.00895733
R5972 VDDD.n1789 VDDD.n1184 0.00895733
R5973 VDDD.n1797 VDDD.n1786 0.00895733
R5974 VDDD.n1800 VDDD.n1799 0.00895733
R5975 VDDD.n1796 VDDD.n1180 0.00895733
R5976 VDDD.n1795 VDDD.n1184 0.00895733
R5977 VDDD.n1803 VDDD.n1802 0.00895733
R5978 VDDD.n1132 VDDD.n1120 0.00895733
R5979 VDDD.n1127 VDDD.n1120 0.00895733
R5980 VDDD.n1131 VDDD.n1119 0.00895733
R5981 VDDD.n1126 VDDD.n1119 0.00895733
R5982 VDDD.n1130 VDDD.n1118 0.00895733
R5983 VDDD.n1137 VDDD.n1118 0.00895733
R5984 VDDD.n1125 VDDD.n1117 0.00895733
R5985 VDDD.n1132 VDDD.n1122 0.00895733
R5986 VDDD.n1131 VDDD.n1123 0.00895733
R5987 VDDD.n1130 VDDD.n1124 0.00895733
R5988 VDDD.n1127 VDDD.n1123 0.00895733
R5989 VDDD.n1126 VDDD.n1124 0.00895733
R5990 VDDD.n1138 VDDD.n1137 0.00895733
R5991 VDDD.n1138 VDDD.n1117 0.00895733
R5992 VDDD.n1943 VDDD.n1102 0.00895733
R5993 VDDD.n1936 VDDD.n1105 0.00895733
R5994 VDDD.n1945 VDDD.n1105 0.00895733
R5995 VDDD.n1933 VDDD.n1108 0.00895733
R5996 VDDD.n1942 VDDD.n1108 0.00895733
R5997 VDDD.n1940 VDDD.n1939 0.00895733
R5998 VDDD.n1941 VDDD.n1940 0.00895733
R5999 VDDD.n1935 VDDD.n1930 0.00895733
R6000 VDDD.n1948 VDDD.n1930 0.00895733
R6001 VDDD.n1936 VDDD.n1932 0.00895733
R6002 VDDD.n1946 VDDD.n1933 0.00895733
R6003 VDDD.n1939 VDDD.n1109 0.00895733
R6004 VDDD.n1935 VDDD.n1113 0.00895733
R6005 VDDD.n1943 VDDD.n1932 0.00895733
R6006 VDDD.n1946 VDDD.n1945 0.00895733
R6007 VDDD.n1942 VDDD.n1109 0.00895733
R6008 VDDD.n1941 VDDD.n1113 0.00895733
R6009 VDDD.n1949 VDDD.n1948 0.00895733
R6010 VDDD.n1050 VDDD.n1038 0.00895733
R6011 VDDD.n1045 VDDD.n1038 0.00895733
R6012 VDDD.n1049 VDDD.n1037 0.00895733
R6013 VDDD.n1044 VDDD.n1037 0.00895733
R6014 VDDD.n1048 VDDD.n1036 0.00895733
R6015 VDDD.n1055 VDDD.n1036 0.00895733
R6016 VDDD.n1043 VDDD.n1035 0.00895733
R6017 VDDD.n1050 VDDD.n1040 0.00895733
R6018 VDDD.n1049 VDDD.n1041 0.00895733
R6019 VDDD.n1048 VDDD.n1042 0.00895733
R6020 VDDD.n1045 VDDD.n1041 0.00895733
R6021 VDDD.n1044 VDDD.n1042 0.00895733
R6022 VDDD.n1056 VDDD.n1055 0.00895733
R6023 VDDD.n1056 VDDD.n1035 0.00895733
R6024 VDDD.n2076 VDDD.n1020 0.00895733
R6025 VDDD.n2069 VDDD.n1023 0.00895733
R6026 VDDD.n2078 VDDD.n1023 0.00895733
R6027 VDDD.n2066 VDDD.n1026 0.00895733
R6028 VDDD.n2075 VDDD.n1026 0.00895733
R6029 VDDD.n2073 VDDD.n2072 0.00895733
R6030 VDDD.n2074 VDDD.n2073 0.00895733
R6031 VDDD.n2068 VDDD.n2063 0.00895733
R6032 VDDD.n2081 VDDD.n2063 0.00895733
R6033 VDDD.n2069 VDDD.n2065 0.00895733
R6034 VDDD.n2079 VDDD.n2066 0.00895733
R6035 VDDD.n2072 VDDD.n1027 0.00895733
R6036 VDDD.n2068 VDDD.n1031 0.00895733
R6037 VDDD.n2076 VDDD.n2065 0.00895733
R6038 VDDD.n2079 VDDD.n2078 0.00895733
R6039 VDDD.n2075 VDDD.n1027 0.00895733
R6040 VDDD.n2074 VDDD.n1031 0.00895733
R6041 VDDD.n2082 VDDD.n2081 0.00895733
R6042 VDDD.n32 VDDD.n20 0.00895733
R6043 VDDD.n27 VDDD.n20 0.00895733
R6044 VDDD.n31 VDDD.n19 0.00895733
R6045 VDDD.n26 VDDD.n19 0.00895733
R6046 VDDD.n30 VDDD.n18 0.00895733
R6047 VDDD.n37 VDDD.n18 0.00895733
R6048 VDDD.n25 VDDD.n17 0.00895733
R6049 VDDD.n32 VDDD.n22 0.00895733
R6050 VDDD.n31 VDDD.n23 0.00895733
R6051 VDDD.n30 VDDD.n24 0.00895733
R6052 VDDD.n27 VDDD.n23 0.00895733
R6053 VDDD.n26 VDDD.n24 0.00895733
R6054 VDDD.n38 VDDD.n37 0.00895733
R6055 VDDD.n38 VDDD.n17 0.00895733
R6056 VDDD.n2796 VDDD.n2 0.00895733
R6057 VDDD.n2789 VDDD.n5 0.00895733
R6058 VDDD.n2798 VDDD.n5 0.00895733
R6059 VDDD.n2786 VDDD.n8 0.00895733
R6060 VDDD.n2795 VDDD.n8 0.00895733
R6061 VDDD.n2793 VDDD.n2792 0.00895733
R6062 VDDD.n2794 VDDD.n2793 0.00895733
R6063 VDDD.n2788 VDDD.n2783 0.00895733
R6064 VDDD.n2801 VDDD.n2783 0.00895733
R6065 VDDD.n2789 VDDD.n2785 0.00895733
R6066 VDDD.n2799 VDDD.n2786 0.00895733
R6067 VDDD.n2792 VDDD.n9 0.00895733
R6068 VDDD.n2788 VDDD.n13 0.00895733
R6069 VDDD.n2796 VDDD.n2785 0.00895733
R6070 VDDD.n2799 VDDD.n2798 0.00895733
R6071 VDDD.n2795 VDDD.n9 0.00895733
R6072 VDDD.n2794 VDDD.n13 0.00895733
R6073 VDDD.n2802 VDDD.n2801 0.00895733
R6074 VDDD.n152 VDDD.n129 0.00895733
R6075 VDDD.n149 VDDD.n129 0.00895733
R6076 VDDD.n305 VDDD.n282 0.00895733
R6077 VDDD.n302 VDDD.n282 0.00895733
R6078 VDDD.n458 VDDD.n435 0.00895733
R6079 VDDD.n455 VDDD.n435 0.00895733
R6080 VDDD.n611 VDDD.n588 0.00895733
R6081 VDDD.n608 VDDD.n588 0.00895733
R6082 VDDD.n764 VDDD.n741 0.00895733
R6083 VDDD.n761 VDDD.n741 0.00895733
R6084 VDDD.n1485 VDDD.n1335 0.00895733
R6085 VDDD.n1485 VDDD.n1484 0.00895733
R6086 VDDD.n1631 VDDD.n1264 0.00895733
R6087 VDDD.n1631 VDDD.n1630 0.00895733
R6088 VDDD.n1777 VDDD.n1193 0.00895733
R6089 VDDD.n1777 VDDD.n1776 0.00895733
R6090 VDDD.n1923 VDDD.n1122 0.00895733
R6091 VDDD.n1923 VDDD.n1922 0.00895733
R6092 VDDD.n2056 VDDD.n1040 0.00895733
R6093 VDDD.n2056 VDDD.n2055 0.00895733
R6094 VDDD.n2776 VDDD.n22 0.00895733
R6095 VDDD.n2776 VDDD.n2775 0.00895733
R6096 VDDD.n141 VDDD.n117 0.00891281
R6097 VDDD.n2537 VDDD.n2536 0.00891281
R6098 VDDD.n294 VDDD.n270 0.00891281
R6099 VDDD.n2475 VDDD.n2474 0.00891281
R6100 VDDD.n447 VDDD.n423 0.00891281
R6101 VDDD.n2413 VDDD.n2412 0.00891281
R6102 VDDD.n600 VDDD.n576 0.00891281
R6103 VDDD.n2351 VDDD.n2350 0.00891281
R6104 VDDD.n753 VDDD.n729 0.00891281
R6105 VDDD.n2289 VDDD.n2288 0.00891281
R6106 VDDD.n1513 VDDD.n1327 0.00891281
R6107 VDDD.n1527 VDDD.n1316 0.00891281
R6108 VDDD.n1659 VDDD.n1256 0.00891281
R6109 VDDD.n1673 VDDD.n1245 0.00891281
R6110 VDDD.n1805 VDDD.n1185 0.00891281
R6111 VDDD.n1819 VDDD.n1174 0.00891281
R6112 VDDD.n1951 VDDD.n1114 0.00891281
R6113 VDDD.n1965 VDDD.n1103 0.00891281
R6114 VDDD.n2084 VDDD.n1032 0.00891281
R6115 VDDD.n2098 VDDD.n1021 0.00891281
R6116 VDDD.n2804 VDDD.n14 0.00891281
R6117 VDDD.n2818 VDDD.n3 0.00891281
R6118 VDDD.n226 VDDD.n225 0.00883401
R6119 VDDD.n379 VDDD.n378 0.00883401
R6120 VDDD.n532 VDDD.n531 0.00883401
R6121 VDDD.n685 VDDD.n684 0.00883401
R6122 VDDD.n835 VDDD.n834 0.00883401
R6123 VDDD.n1483 VDDD.n1353 0.00883401
R6124 VDDD.n1629 VDDD.n1282 0.00883401
R6125 VDDD.n1775 VDDD.n1211 0.00883401
R6126 VDDD.n1921 VDDD.n1140 0.00883401
R6127 VDDD.n2054 VDDD.n1058 0.00883401
R6128 VDDD.n2774 VDDD.n40 0.00883401
R6129 VDDD.n184 VDDD.n177 0.00858936
R6130 VDDD.n257 VDDD.n188 0.00858936
R6131 VDDD.n188 VDDD.n178 0.00858936
R6132 VDDD.n255 VDDD.n189 0.00858936
R6133 VDDD.n189 VDDD.n179 0.00858936
R6134 VDDD.n253 VDDD.n190 0.00858936
R6135 VDDD.n190 VDDD.n180 0.00858936
R6136 VDDD.n191 VDDD.n180 0.00858936
R6137 VDDD.n254 VDDD.n179 0.00858936
R6138 VDDD.n256 VDDD.n178 0.00858936
R6139 VDDD.n258 VDDD.n177 0.00858936
R6140 VDDD.n254 VDDD.n253 0.00858936
R6141 VDDD.n256 VDDD.n255 0.00858936
R6142 VDDD.n258 VDDD.n257 0.00858936
R6143 VDDD.n337 VDDD.n330 0.00858936
R6144 VDDD.n410 VDDD.n341 0.00858936
R6145 VDDD.n341 VDDD.n331 0.00858936
R6146 VDDD.n408 VDDD.n342 0.00858936
R6147 VDDD.n342 VDDD.n332 0.00858936
R6148 VDDD.n406 VDDD.n343 0.00858936
R6149 VDDD.n343 VDDD.n333 0.00858936
R6150 VDDD.n344 VDDD.n333 0.00858936
R6151 VDDD.n407 VDDD.n332 0.00858936
R6152 VDDD.n409 VDDD.n331 0.00858936
R6153 VDDD.n411 VDDD.n330 0.00858936
R6154 VDDD.n407 VDDD.n406 0.00858936
R6155 VDDD.n409 VDDD.n408 0.00858936
R6156 VDDD.n411 VDDD.n410 0.00858936
R6157 VDDD.n490 VDDD.n483 0.00858936
R6158 VDDD.n563 VDDD.n494 0.00858936
R6159 VDDD.n494 VDDD.n484 0.00858936
R6160 VDDD.n561 VDDD.n495 0.00858936
R6161 VDDD.n495 VDDD.n485 0.00858936
R6162 VDDD.n559 VDDD.n496 0.00858936
R6163 VDDD.n496 VDDD.n486 0.00858936
R6164 VDDD.n497 VDDD.n486 0.00858936
R6165 VDDD.n560 VDDD.n485 0.00858936
R6166 VDDD.n562 VDDD.n484 0.00858936
R6167 VDDD.n564 VDDD.n483 0.00858936
R6168 VDDD.n560 VDDD.n559 0.00858936
R6169 VDDD.n562 VDDD.n561 0.00858936
R6170 VDDD.n564 VDDD.n563 0.00858936
R6171 VDDD.n643 VDDD.n636 0.00858936
R6172 VDDD.n716 VDDD.n647 0.00858936
R6173 VDDD.n647 VDDD.n637 0.00858936
R6174 VDDD.n714 VDDD.n648 0.00858936
R6175 VDDD.n648 VDDD.n638 0.00858936
R6176 VDDD.n712 VDDD.n649 0.00858936
R6177 VDDD.n649 VDDD.n639 0.00858936
R6178 VDDD.n650 VDDD.n639 0.00858936
R6179 VDDD.n713 VDDD.n638 0.00858936
R6180 VDDD.n715 VDDD.n637 0.00858936
R6181 VDDD.n717 VDDD.n636 0.00858936
R6182 VDDD.n713 VDDD.n712 0.00858936
R6183 VDDD.n715 VDDD.n714 0.00858936
R6184 VDDD.n717 VDDD.n716 0.00858936
R6185 VDDD.n793 VDDD.n786 0.00858936
R6186 VDDD.n866 VDDD.n797 0.00858936
R6187 VDDD.n797 VDDD.n787 0.00858936
R6188 VDDD.n864 VDDD.n798 0.00858936
R6189 VDDD.n798 VDDD.n788 0.00858936
R6190 VDDD.n862 VDDD.n799 0.00858936
R6191 VDDD.n799 VDDD.n789 0.00858936
R6192 VDDD.n800 VDDD.n789 0.00858936
R6193 VDDD.n863 VDDD.n788 0.00858936
R6194 VDDD.n865 VDDD.n787 0.00858936
R6195 VDDD.n867 VDDD.n786 0.00858936
R6196 VDDD.n863 VDDD.n862 0.00858936
R6197 VDDD.n865 VDDD.n864 0.00858936
R6198 VDDD.n867 VDDD.n866 0.00858936
R6199 VDDD.n1461 VDDD.n1363 0.00858936
R6200 VDDD.n1459 VDDD.n1458 0.00858936
R6201 VDDD.n1376 VDDD.n1367 0.00858936
R6202 VDDD.n1454 VDDD.n1377 0.00858936
R6203 VDDD.n1374 VDDD.n1368 0.00858936
R6204 VDDD.n1455 VDDD.n1375 0.00858936
R6205 VDDD.n1372 VDDD.n1369 0.00858936
R6206 VDDD.n1371 VDDD.n1370 0.00858936
R6207 VDDD.n1455 VDDD.n1369 0.00858936
R6208 VDDD.n1454 VDDD.n1368 0.00858936
R6209 VDDD.n1458 VDDD.n1367 0.00858936
R6210 VDDD.n1379 VDDD.n1363 0.00858936
R6211 VDDD.n1375 VDDD.n1374 0.00858936
R6212 VDDD.n1377 VDDD.n1376 0.00858936
R6213 VDDD.n1373 VDDD.n1372 0.00858936
R6214 VDDD.n1373 VDDD.n1371 0.00858936
R6215 VDDD.n1607 VDDD.n1292 0.00858936
R6216 VDDD.n1605 VDDD.n1604 0.00858936
R6217 VDDD.n1305 VDDD.n1296 0.00858936
R6218 VDDD.n1600 VDDD.n1306 0.00858936
R6219 VDDD.n1303 VDDD.n1297 0.00858936
R6220 VDDD.n1601 VDDD.n1304 0.00858936
R6221 VDDD.n1301 VDDD.n1298 0.00858936
R6222 VDDD.n1300 VDDD.n1299 0.00858936
R6223 VDDD.n1601 VDDD.n1298 0.00858936
R6224 VDDD.n1600 VDDD.n1297 0.00858936
R6225 VDDD.n1604 VDDD.n1296 0.00858936
R6226 VDDD.n1308 VDDD.n1292 0.00858936
R6227 VDDD.n1304 VDDD.n1303 0.00858936
R6228 VDDD.n1306 VDDD.n1305 0.00858936
R6229 VDDD.n1302 VDDD.n1301 0.00858936
R6230 VDDD.n1302 VDDD.n1300 0.00858936
R6231 VDDD.n1753 VDDD.n1221 0.00858936
R6232 VDDD.n1751 VDDD.n1750 0.00858936
R6233 VDDD.n1234 VDDD.n1225 0.00858936
R6234 VDDD.n1746 VDDD.n1235 0.00858936
R6235 VDDD.n1232 VDDD.n1226 0.00858936
R6236 VDDD.n1747 VDDD.n1233 0.00858936
R6237 VDDD.n1230 VDDD.n1227 0.00858936
R6238 VDDD.n1229 VDDD.n1228 0.00858936
R6239 VDDD.n1747 VDDD.n1227 0.00858936
R6240 VDDD.n1746 VDDD.n1226 0.00858936
R6241 VDDD.n1750 VDDD.n1225 0.00858936
R6242 VDDD.n1237 VDDD.n1221 0.00858936
R6243 VDDD.n1233 VDDD.n1232 0.00858936
R6244 VDDD.n1235 VDDD.n1234 0.00858936
R6245 VDDD.n1231 VDDD.n1230 0.00858936
R6246 VDDD.n1231 VDDD.n1229 0.00858936
R6247 VDDD.n1899 VDDD.n1150 0.00858936
R6248 VDDD.n1897 VDDD.n1896 0.00858936
R6249 VDDD.n1163 VDDD.n1154 0.00858936
R6250 VDDD.n1892 VDDD.n1164 0.00858936
R6251 VDDD.n1161 VDDD.n1155 0.00858936
R6252 VDDD.n1893 VDDD.n1162 0.00858936
R6253 VDDD.n1159 VDDD.n1156 0.00858936
R6254 VDDD.n1158 VDDD.n1157 0.00858936
R6255 VDDD.n1893 VDDD.n1156 0.00858936
R6256 VDDD.n1892 VDDD.n1155 0.00858936
R6257 VDDD.n1896 VDDD.n1154 0.00858936
R6258 VDDD.n1166 VDDD.n1150 0.00858936
R6259 VDDD.n1162 VDDD.n1161 0.00858936
R6260 VDDD.n1164 VDDD.n1163 0.00858936
R6261 VDDD.n1160 VDDD.n1159 0.00858936
R6262 VDDD.n1160 VDDD.n1158 0.00858936
R6263 VDDD.n2032 VDDD.n1068 0.00858936
R6264 VDDD.n2030 VDDD.n2029 0.00858936
R6265 VDDD.n1081 VDDD.n1072 0.00858936
R6266 VDDD.n2025 VDDD.n1082 0.00858936
R6267 VDDD.n1079 VDDD.n1073 0.00858936
R6268 VDDD.n2026 VDDD.n1080 0.00858936
R6269 VDDD.n1077 VDDD.n1074 0.00858936
R6270 VDDD.n1076 VDDD.n1075 0.00858936
R6271 VDDD.n2026 VDDD.n1074 0.00858936
R6272 VDDD.n2025 VDDD.n1073 0.00858936
R6273 VDDD.n2029 VDDD.n1072 0.00858936
R6274 VDDD.n1084 VDDD.n1068 0.00858936
R6275 VDDD.n1080 VDDD.n1079 0.00858936
R6276 VDDD.n1082 VDDD.n1081 0.00858936
R6277 VDDD.n1078 VDDD.n1077 0.00858936
R6278 VDDD.n1078 VDDD.n1076 0.00858936
R6279 VDDD.n2752 VDDD.n50 0.00858936
R6280 VDDD.n2750 VDDD.n2749 0.00858936
R6281 VDDD.n63 VDDD.n54 0.00858936
R6282 VDDD.n2745 VDDD.n64 0.00858936
R6283 VDDD.n61 VDDD.n55 0.00858936
R6284 VDDD.n2746 VDDD.n62 0.00858936
R6285 VDDD.n59 VDDD.n56 0.00858936
R6286 VDDD.n58 VDDD.n57 0.00858936
R6287 VDDD.n2746 VDDD.n56 0.00858936
R6288 VDDD.n2745 VDDD.n55 0.00858936
R6289 VDDD.n2749 VDDD.n54 0.00858936
R6290 VDDD.n66 VDDD.n50 0.00858936
R6291 VDDD.n62 VDDD.n61 0.00858936
R6292 VDDD.n64 VDDD.n63 0.00858936
R6293 VDDD.n60 VDDD.n59 0.00858936
R6294 VDDD.n60 VDDD.n58 0.00858936
R6295 VDDD.n252 VDDD.n251 0.00858936
R6296 VDDD.n252 VDDD.n191 0.00858936
R6297 VDDD.n405 VDDD.n404 0.00858936
R6298 VDDD.n405 VDDD.n344 0.00858936
R6299 VDDD.n558 VDDD.n557 0.00858936
R6300 VDDD.n558 VDDD.n497 0.00858936
R6301 VDDD.n711 VDDD.n710 0.00858936
R6302 VDDD.n711 VDDD.n650 0.00858936
R6303 VDDD.n861 VDDD.n860 0.00858936
R6304 VDDD.n861 VDDD.n800 0.00858936
R6305 VDDD.n997 VDDD.n954 0.0067
R6306 VDDD.n997 VDDD.n996 0.0067
R6307 VDDD.n996 VDDD.n995 0.0067
R6308 VDDD.n995 VDDD.n956 0.0067
R6309 VDDD.n991 VDDD.n956 0.0067
R6310 VDDD.n991 VDDD.n990 0.0067
R6311 VDDD.n990 VDDD.n989 0.0067
R6312 VDDD.n989 VDDD.n958 0.0067
R6313 VDDD.n985 VDDD.n958 0.0067
R6314 VDDD.n985 VDDD.n984 0.0067
R6315 VDDD.n984 VDDD.n983 0.0067
R6316 VDDD.n983 VDDD.n960 0.0067
R6317 VDDD.n979 VDDD.n960 0.0067
R6318 VDDD.n979 VDDD.n978 0.0067
R6319 VDDD.n978 VDDD.n977 0.0067
R6320 VDDD.n977 VDDD.n962 0.0067
R6321 VDDD.n973 VDDD.n962 0.0067
R6322 VDDD.n973 VDDD.n972 0.0067
R6323 VDDD.n972 VDDD.n971 0.0067
R6324 VDDD.n971 VDDD.n964 0.0067
R6325 VDDD.n967 VDDD.n964 0.0067
R6326 VDDD.n967 VDDD.n966 0.0067
R6327 VDDD.n966 VDDD.n922 0.0067
R6328 VDDD.n1016 VDDD.n922 0.0067
R6329 VDDD.n1016 VDDD.n919 0.0067
R6330 VDDD.n2103 VDDD.n919 0.0067
R6331 VDDD.n2103 VDDD.n920 0.0067
R6332 VDDD.n2202 VDDD.n2199 0.0067
R6333 VDDD.n2203 VDDD.n2202 0.0067
R6334 VDDD.n2204 VDDD.n2203 0.0067
R6335 VDDD.n2204 VDDD.n2197 0.0067
R6336 VDDD.n2208 VDDD.n2197 0.0067
R6337 VDDD.n2209 VDDD.n2208 0.0067
R6338 VDDD.n2210 VDDD.n2209 0.0067
R6339 VDDD.n2210 VDDD.n2195 0.0067
R6340 VDDD.n2214 VDDD.n2195 0.0067
R6341 VDDD.n2215 VDDD.n2214 0.0067
R6342 VDDD.n2216 VDDD.n2215 0.0067
R6343 VDDD.n2216 VDDD.n2193 0.0067
R6344 VDDD.n2220 VDDD.n2193 0.0067
R6345 VDDD.n2221 VDDD.n2220 0.0067
R6346 VDDD.n2222 VDDD.n2221 0.0067
R6347 VDDD.n2222 VDDD.n2191 0.0067
R6348 VDDD.n2226 VDDD.n2191 0.0067
R6349 VDDD.n2227 VDDD.n2226 0.0067
R6350 VDDD.n2228 VDDD.n2227 0.0067
R6351 VDDD.n2228 VDDD.n2189 0.0067
R6352 VDDD.n2232 VDDD.n2189 0.0067
R6353 VDDD.n2233 VDDD.n2232 0.0067
R6354 VDDD.n2234 VDDD.n2233 0.0067
R6355 VDDD.n2234 VDDD.n2187 0.0067
R6356 VDDD.n2238 VDDD.n2187 0.0067
R6357 VDDD.n2238 VDDD.n883 0.0067
R6358 VDDD.n2242 VDDD.n883 0.0067
R6359 VDDD.n1529 VDDD.n1314 0.00608
R6360 VDDD.n1524 VDDD.n1314 0.00608
R6361 VDDD.n1524 VDDD.n1523 0.00608
R6362 VDDD.n1523 VDDD.n1522 0.00608
R6363 VDDD.n1518 VDDD.n1517 0.00608
R6364 VDDD.n1517 VDDD.n1516 0.00608
R6365 VDDD.n1516 VDDD.n1325 0.00608
R6366 VDDD.n1329 VDDD.n1325 0.00608
R6367 VDDD.n1675 VDDD.n1243 0.00608
R6368 VDDD.n1670 VDDD.n1243 0.00608
R6369 VDDD.n1670 VDDD.n1669 0.00608
R6370 VDDD.n1669 VDDD.n1668 0.00608
R6371 VDDD.n1664 VDDD.n1663 0.00608
R6372 VDDD.n1663 VDDD.n1662 0.00608
R6373 VDDD.n1662 VDDD.n1254 0.00608
R6374 VDDD.n1258 VDDD.n1254 0.00608
R6375 VDDD.n1821 VDDD.n1172 0.00608
R6376 VDDD.n1816 VDDD.n1172 0.00608
R6377 VDDD.n1816 VDDD.n1815 0.00608
R6378 VDDD.n1815 VDDD.n1814 0.00608
R6379 VDDD.n1810 VDDD.n1809 0.00608
R6380 VDDD.n1809 VDDD.n1808 0.00608
R6381 VDDD.n1808 VDDD.n1183 0.00608
R6382 VDDD.n1187 VDDD.n1183 0.00608
R6383 VDDD.n1967 VDDD.n1101 0.00608
R6384 VDDD.n1962 VDDD.n1101 0.00608
R6385 VDDD.n1962 VDDD.n1961 0.00608
R6386 VDDD.n1961 VDDD.n1960 0.00608
R6387 VDDD.n1956 VDDD.n1955 0.00608
R6388 VDDD.n1955 VDDD.n1954 0.00608
R6389 VDDD.n1954 VDDD.n1112 0.00608
R6390 VDDD.n1116 VDDD.n1112 0.00608
R6391 VDDD.n998 VDDD.n955 0.00608
R6392 VDDD.n994 VDDD.n955 0.00608
R6393 VDDD.n994 VDDD.n993 0.00608
R6394 VDDD.n993 VDDD.n992 0.00608
R6395 VDDD.n992 VDDD.n957 0.00608
R6396 VDDD.n988 VDDD.n957 0.00608
R6397 VDDD.n988 VDDD.n987 0.00608
R6398 VDDD.n987 VDDD.n986 0.00608
R6399 VDDD.n986 VDDD.n959 0.00608
R6400 VDDD.n982 VDDD.n959 0.00608
R6401 VDDD.n982 VDDD.n981 0.00608
R6402 VDDD.n981 VDDD.n980 0.00608
R6403 VDDD.n980 VDDD.n961 0.00608
R6404 VDDD.n976 VDDD.n961 0.00608
R6405 VDDD.n976 VDDD.n975 0.00608
R6406 VDDD.n975 VDDD.n974 0.00608
R6407 VDDD.n974 VDDD.n963 0.00608
R6408 VDDD.n970 VDDD.n963 0.00608
R6409 VDDD.n970 VDDD.n969 0.00608
R6410 VDDD.n969 VDDD.n968 0.00608
R6411 VDDD.n968 VDDD.n965 0.00608
R6412 VDDD.n965 VDDD.n921 0.00608
R6413 VDDD.n1017 VDDD.n921 0.00608
R6414 VDDD.n1018 VDDD.n1017 0.00608
R6415 VDDD.n2102 VDDD.n1018 0.00608
R6416 VDDD.n2102 VDDD.n2101 0.00608
R6417 VDDD.n2100 VDDD.n1019 0.00608
R6418 VDDD.n2095 VDDD.n1019 0.00608
R6419 VDDD.n2095 VDDD.n2094 0.00608
R6420 VDDD.n2094 VDDD.n2093 0.00608
R6421 VDDD.n2089 VDDD.n2088 0.00608
R6422 VDDD.n2088 VDDD.n2087 0.00608
R6423 VDDD.n2087 VDDD.n1030 0.00608
R6424 VDDD.n1034 VDDD.n1030 0.00608
R6425 VDDD.n2201 VDDD.n2198 0.00608
R6426 VDDD.n2205 VDDD.n2198 0.00608
R6427 VDDD.n2206 VDDD.n2205 0.00608
R6428 VDDD.n2207 VDDD.n2206 0.00608
R6429 VDDD.n2207 VDDD.n2196 0.00608
R6430 VDDD.n2211 VDDD.n2196 0.00608
R6431 VDDD.n2212 VDDD.n2211 0.00608
R6432 VDDD.n2213 VDDD.n2212 0.00608
R6433 VDDD.n2213 VDDD.n2194 0.00608
R6434 VDDD.n2217 VDDD.n2194 0.00608
R6435 VDDD.n2218 VDDD.n2217 0.00608
R6436 VDDD.n2219 VDDD.n2218 0.00608
R6437 VDDD.n2219 VDDD.n2192 0.00608
R6438 VDDD.n2223 VDDD.n2192 0.00608
R6439 VDDD.n2224 VDDD.n2223 0.00608
R6440 VDDD.n2225 VDDD.n2224 0.00608
R6441 VDDD.n2225 VDDD.n2190 0.00608
R6442 VDDD.n2229 VDDD.n2190 0.00608
R6443 VDDD.n2230 VDDD.n2229 0.00608
R6444 VDDD.n2231 VDDD.n2230 0.00608
R6445 VDDD.n2231 VDDD.n2188 0.00608
R6446 VDDD.n2235 VDDD.n2188 0.00608
R6447 VDDD.n2236 VDDD.n2235 0.00608
R6448 VDDD.n2237 VDDD.n2236 0.00608
R6449 VDDD.n2237 VDDD.n882 0.00608
R6450 VDDD.n2243 VDDD.n882 0.00608
R6451 VDDD.n2287 VDDD.n2285 0.00608
R6452 VDDD.n2287 VDDD.n2286 0.00608
R6453 VDDD.n2286 VDDD.n757 0.00608
R6454 VDDD.n2294 VDDD.n757 0.00608
R6455 VDDD.n2298 VDDD.n2296 0.00608
R6456 VDDD.n2298 VDDD.n2297 0.00608
R6457 VDDD.n2297 VDDD.n728 0.00608
R6458 VDDD.n2304 VDDD.n728 0.00608
R6459 VDDD.n2349 VDDD.n2347 0.00608
R6460 VDDD.n2349 VDDD.n2348 0.00608
R6461 VDDD.n2348 VDDD.n604 0.00608
R6462 VDDD.n2356 VDDD.n604 0.00608
R6463 VDDD.n2360 VDDD.n2358 0.00608
R6464 VDDD.n2360 VDDD.n2359 0.00608
R6465 VDDD.n2359 VDDD.n575 0.00608
R6466 VDDD.n2366 VDDD.n575 0.00608
R6467 VDDD.n2411 VDDD.n2409 0.00608
R6468 VDDD.n2411 VDDD.n2410 0.00608
R6469 VDDD.n2410 VDDD.n451 0.00608
R6470 VDDD.n2418 VDDD.n451 0.00608
R6471 VDDD.n2422 VDDD.n2420 0.00608
R6472 VDDD.n2422 VDDD.n2421 0.00608
R6473 VDDD.n2421 VDDD.n422 0.00608
R6474 VDDD.n2428 VDDD.n422 0.00608
R6475 VDDD.n2473 VDDD.n2471 0.00608
R6476 VDDD.n2473 VDDD.n2472 0.00608
R6477 VDDD.n2472 VDDD.n298 0.00608
R6478 VDDD.n2480 VDDD.n298 0.00608
R6479 VDDD.n2484 VDDD.n2482 0.00608
R6480 VDDD.n2484 VDDD.n2483 0.00608
R6481 VDDD.n2483 VDDD.n269 0.00608
R6482 VDDD.n2490 VDDD.n269 0.00608
R6483 VDDD.n2535 VDDD.n2533 0.00608
R6484 VDDD.n2535 VDDD.n2534 0.00608
R6485 VDDD.n2534 VDDD.n145 0.00608
R6486 VDDD.n2542 VDDD.n145 0.00608
R6487 VDDD.n2546 VDDD.n2544 0.00608
R6488 VDDD.n2546 VDDD.n2545 0.00608
R6489 VDDD.n2545 VDDD.n116 0.00608
R6490 VDDD.n2552 VDDD.n116 0.00608
R6491 VDDD.n2617 VDDD.n2559 0.00608
R6492 VDDD.n2559 VDDD.n115 0.00608
R6493 VDDD.n2820 VDDD.n1 0.00608
R6494 VDDD.n2815 VDDD.n1 0.00608
R6495 VDDD.n2815 VDDD.n2814 0.00608
R6496 VDDD.n2814 VDDD.n2813 0.00608
R6497 VDDD.n2809 VDDD.n2808 0.00608
R6498 VDDD.n2808 VDDD.n2807 0.00608
R6499 VDDD.n2807 VDDD.n12 0.00608
R6500 VDDD.n16 VDDD.n12 0.00608
R6501 VDDD.n2016 VDDD.n1089 0.0054163
R6502 VDDD.n2247 VDDD.n881 0.0054163
R6503 VDDD.n635 VDDD.n634 0.0054163
R6504 VDDD.n482 VDDD.n481 0.0054163
R6505 VDDD.n329 VDDD.n328 0.0054163
R6506 VDDD.n176 VDDD.n175 0.0054163
R6507 VDDD.n147 VDDD.n119 0.00498219
R6508 VDDD.n122 VDDD.n120 0.00498219
R6509 VDDD.n148 VDDD.n120 0.00498219
R6510 VDDD.n2549 VDDD.n124 0.00498219
R6511 VDDD.n209 VDDD.n208 0.00498219
R6512 VDDD.n223 VDDD.n222 0.00498219
R6513 VDDD.n221 VDDD.n220 0.00498219
R6514 VDDD.n220 VDDD.n219 0.00498219
R6515 VDDD.n148 VDDD.n121 0.00498219
R6516 VDDD.n124 VDDD.n121 0.00498219
R6517 VDDD.n147 VDDD.n123 0.00498219
R6518 VDDD.n123 VDDD.n122 0.00498219
R6519 VDDD.n222 VDDD.n221 0.00498219
R6520 VDDD.n223 VDDD.n209 0.00498219
R6521 VDDD.n208 VDDD.n130 0.00498219
R6522 VDDD.n219 VDDD.n206 0.00498219
R6523 VDDD.n2495 VDDD.n168 0.00498219
R6524 VDDD.n174 VDDD.n169 0.00498219
R6525 VDDD.n263 VDDD.n167 0.00498219
R6526 VDDD.n2498 VDDD.n170 0.00498219
R6527 VDDD.n183 VDDD.n181 0.00498219
R6528 VDDD.n186 VDDD.n185 0.00498219
R6529 VDDD.n192 VDDD.n182 0.00498219
R6530 VDDD.n259 VDDD.n187 0.00498219
R6531 VDDD.n261 VDDD.n181 0.00498219
R6532 VDDD.n185 VDDD.n183 0.00498219
R6533 VDDD.n192 VDDD.n186 0.00498219
R6534 VDDD.n187 VDDD.n182 0.00498219
R6535 VDDD.n300 VDDD.n272 0.00498219
R6536 VDDD.n275 VDDD.n273 0.00498219
R6537 VDDD.n301 VDDD.n273 0.00498219
R6538 VDDD.n2487 VDDD.n277 0.00498219
R6539 VDDD.n362 VDDD.n361 0.00498219
R6540 VDDD.n376 VDDD.n375 0.00498219
R6541 VDDD.n374 VDDD.n373 0.00498219
R6542 VDDD.n373 VDDD.n372 0.00498219
R6543 VDDD.n301 VDDD.n274 0.00498219
R6544 VDDD.n277 VDDD.n274 0.00498219
R6545 VDDD.n300 VDDD.n276 0.00498219
R6546 VDDD.n276 VDDD.n275 0.00498219
R6547 VDDD.n375 VDDD.n374 0.00498219
R6548 VDDD.n376 VDDD.n362 0.00498219
R6549 VDDD.n361 VDDD.n283 0.00498219
R6550 VDDD.n372 VDDD.n359 0.00498219
R6551 VDDD.n2433 VDDD.n321 0.00498219
R6552 VDDD.n327 VDDD.n322 0.00498219
R6553 VDDD.n416 VDDD.n320 0.00498219
R6554 VDDD.n2436 VDDD.n323 0.00498219
R6555 VDDD.n336 VDDD.n334 0.00498219
R6556 VDDD.n339 VDDD.n338 0.00498219
R6557 VDDD.n345 VDDD.n335 0.00498219
R6558 VDDD.n412 VDDD.n340 0.00498219
R6559 VDDD.n414 VDDD.n334 0.00498219
R6560 VDDD.n338 VDDD.n336 0.00498219
R6561 VDDD.n345 VDDD.n339 0.00498219
R6562 VDDD.n340 VDDD.n335 0.00498219
R6563 VDDD.n453 VDDD.n425 0.00498219
R6564 VDDD.n428 VDDD.n426 0.00498219
R6565 VDDD.n454 VDDD.n426 0.00498219
R6566 VDDD.n2425 VDDD.n430 0.00498219
R6567 VDDD.n515 VDDD.n514 0.00498219
R6568 VDDD.n529 VDDD.n528 0.00498219
R6569 VDDD.n527 VDDD.n526 0.00498219
R6570 VDDD.n526 VDDD.n525 0.00498219
R6571 VDDD.n454 VDDD.n427 0.00498219
R6572 VDDD.n430 VDDD.n427 0.00498219
R6573 VDDD.n453 VDDD.n429 0.00498219
R6574 VDDD.n429 VDDD.n428 0.00498219
R6575 VDDD.n528 VDDD.n527 0.00498219
R6576 VDDD.n529 VDDD.n515 0.00498219
R6577 VDDD.n514 VDDD.n436 0.00498219
R6578 VDDD.n525 VDDD.n512 0.00498219
R6579 VDDD.n2371 VDDD.n474 0.00498219
R6580 VDDD.n480 VDDD.n475 0.00498219
R6581 VDDD.n569 VDDD.n473 0.00498219
R6582 VDDD.n2374 VDDD.n476 0.00498219
R6583 VDDD.n489 VDDD.n487 0.00498219
R6584 VDDD.n492 VDDD.n491 0.00498219
R6585 VDDD.n498 VDDD.n488 0.00498219
R6586 VDDD.n565 VDDD.n493 0.00498219
R6587 VDDD.n567 VDDD.n487 0.00498219
R6588 VDDD.n491 VDDD.n489 0.00498219
R6589 VDDD.n498 VDDD.n492 0.00498219
R6590 VDDD.n493 VDDD.n488 0.00498219
R6591 VDDD.n606 VDDD.n578 0.00498219
R6592 VDDD.n581 VDDD.n579 0.00498219
R6593 VDDD.n607 VDDD.n579 0.00498219
R6594 VDDD.n2363 VDDD.n583 0.00498219
R6595 VDDD.n668 VDDD.n667 0.00498219
R6596 VDDD.n682 VDDD.n681 0.00498219
R6597 VDDD.n680 VDDD.n679 0.00498219
R6598 VDDD.n679 VDDD.n678 0.00498219
R6599 VDDD.n607 VDDD.n580 0.00498219
R6600 VDDD.n583 VDDD.n580 0.00498219
R6601 VDDD.n606 VDDD.n582 0.00498219
R6602 VDDD.n582 VDDD.n581 0.00498219
R6603 VDDD.n681 VDDD.n680 0.00498219
R6604 VDDD.n682 VDDD.n668 0.00498219
R6605 VDDD.n667 VDDD.n589 0.00498219
R6606 VDDD.n678 VDDD.n665 0.00498219
R6607 VDDD.n2309 VDDD.n627 0.00498219
R6608 VDDD.n633 VDDD.n628 0.00498219
R6609 VDDD.n722 VDDD.n626 0.00498219
R6610 VDDD.n2312 VDDD.n629 0.00498219
R6611 VDDD.n642 VDDD.n640 0.00498219
R6612 VDDD.n645 VDDD.n644 0.00498219
R6613 VDDD.n651 VDDD.n641 0.00498219
R6614 VDDD.n718 VDDD.n646 0.00498219
R6615 VDDD.n720 VDDD.n640 0.00498219
R6616 VDDD.n644 VDDD.n642 0.00498219
R6617 VDDD.n651 VDDD.n645 0.00498219
R6618 VDDD.n646 VDDD.n641 0.00498219
R6619 VDDD.n759 VDDD.n731 0.00498219
R6620 VDDD.n734 VDDD.n732 0.00498219
R6621 VDDD.n760 VDDD.n732 0.00498219
R6622 VDDD.n2301 VDDD.n736 0.00498219
R6623 VDDD.n818 VDDD.n817 0.00498219
R6624 VDDD.n832 VDDD.n831 0.00498219
R6625 VDDD.n830 VDDD.n829 0.00498219
R6626 VDDD.n829 VDDD.n828 0.00498219
R6627 VDDD.n760 VDDD.n733 0.00498219
R6628 VDDD.n736 VDDD.n733 0.00498219
R6629 VDDD.n759 VDDD.n735 0.00498219
R6630 VDDD.n735 VDDD.n734 0.00498219
R6631 VDDD.n831 VDDD.n830 0.00498219
R6632 VDDD.n832 VDDD.n818 0.00498219
R6633 VDDD.n817 VDDD.n742 0.00498219
R6634 VDDD.n828 VDDD.n815 0.00498219
R6635 VDDD.n871 VDDD.n779 0.00498219
R6636 VDDD.n2246 VDDD.n781 0.00498219
R6637 VDDD.n2245 VDDD.n2244 0.00498219
R6638 VDDD.n2250 VDDD.n782 0.00498219
R6639 VDDD.n792 VDDD.n790 0.00498219
R6640 VDDD.n795 VDDD.n794 0.00498219
R6641 VDDD.n801 VDDD.n791 0.00498219
R6642 VDDD.n868 VDDD.n796 0.00498219
R6643 VDDD.n870 VDDD.n790 0.00498219
R6644 VDDD.n794 VDDD.n792 0.00498219
R6645 VDDD.n801 VDDD.n795 0.00498219
R6646 VDDD.n796 VDDD.n791 0.00498219
R6647 VDDD.n1448 VDDD.n1447 0.00498219
R6648 VDDD.n1451 VDDD.n1391 0.00498219
R6649 VDDD.n1392 VDDD.n1389 0.00498219
R6650 VDDD.n1453 VDDD.n1380 0.00498219
R6651 VDDD.n1456 VDDD.n1362 0.00498219
R6652 VDDD.n1378 VDDD.n1364 0.00498219
R6653 VDDD.n1366 VDDD.n1361 0.00498219
R6654 VDDD.n1460 VDDD.n1365 0.00498219
R6655 VDDD.n1451 VDDD.n1392 0.00498219
R6656 VDDD.n1447 VDDD.n1395 0.00498219
R6657 VDDD.n1395 VDDD.n1391 0.00498219
R6658 VDDD.n1389 VDDD.n1380 0.00498219
R6659 VDDD.n1457 VDDD.n1456 0.00498219
R6660 VDDD.n1378 VDDD.n1362 0.00498219
R6661 VDDD.n1366 VDDD.n1364 0.00498219
R6662 VDDD.n1365 VDDD.n1361 0.00498219
R6663 VDDD.n1493 VDDD.n1490 0.00498219
R6664 VDDD.n1506 VDDD.n1496 0.00498219
R6665 VDDD.n1500 VDDD.n1491 0.00498219
R6666 VDDD.n1500 VDDD.n1499 0.00498219
R6667 VDDD.n1488 VDDD.n1334 0.00498219
R6668 VDDD.n1347 VDDD.n1341 0.00498219
R6669 VDDD.n1352 VDDD.n1341 0.00498219
R6670 VDDD.n1486 VDDD.n1349 0.00498219
R6671 VDDD.n1352 VDDD.n1346 0.00498219
R6672 VDDD.n1349 VDDD.n1346 0.00498219
R6673 VDDD.n1348 VDDD.n1334 0.00498219
R6674 VDDD.n1348 VDDD.n1347 0.00498219
R6675 VDDD.n1506 VDDD.n1491 0.00498219
R6676 VDDD.n1496 VDDD.n1490 0.00498219
R6677 VDDD.n1509 VDDD.n1493 0.00498219
R6678 VDDD.n1499 VDDD.n1489 0.00498219
R6679 VDDD.n1594 VDDD.n1593 0.00498219
R6680 VDDD.n1597 VDDD.n1537 0.00498219
R6681 VDDD.n1538 VDDD.n1535 0.00498219
R6682 VDDD.n1599 VDDD.n1309 0.00498219
R6683 VDDD.n1602 VDDD.n1291 0.00498219
R6684 VDDD.n1307 VDDD.n1293 0.00498219
R6685 VDDD.n1295 VDDD.n1290 0.00498219
R6686 VDDD.n1606 VDDD.n1294 0.00498219
R6687 VDDD.n1597 VDDD.n1538 0.00498219
R6688 VDDD.n1593 VDDD.n1541 0.00498219
R6689 VDDD.n1541 VDDD.n1537 0.00498219
R6690 VDDD.n1535 VDDD.n1309 0.00498219
R6691 VDDD.n1603 VDDD.n1602 0.00498219
R6692 VDDD.n1307 VDDD.n1291 0.00498219
R6693 VDDD.n1295 VDDD.n1293 0.00498219
R6694 VDDD.n1294 VDDD.n1290 0.00498219
R6695 VDDD.n1639 VDDD.n1636 0.00498219
R6696 VDDD.n1652 VDDD.n1642 0.00498219
R6697 VDDD.n1646 VDDD.n1637 0.00498219
R6698 VDDD.n1646 VDDD.n1645 0.00498219
R6699 VDDD.n1634 VDDD.n1263 0.00498219
R6700 VDDD.n1276 VDDD.n1270 0.00498219
R6701 VDDD.n1281 VDDD.n1270 0.00498219
R6702 VDDD.n1632 VDDD.n1278 0.00498219
R6703 VDDD.n1281 VDDD.n1275 0.00498219
R6704 VDDD.n1278 VDDD.n1275 0.00498219
R6705 VDDD.n1277 VDDD.n1263 0.00498219
R6706 VDDD.n1277 VDDD.n1276 0.00498219
R6707 VDDD.n1652 VDDD.n1637 0.00498219
R6708 VDDD.n1642 VDDD.n1636 0.00498219
R6709 VDDD.n1655 VDDD.n1639 0.00498219
R6710 VDDD.n1645 VDDD.n1635 0.00498219
R6711 VDDD.n1740 VDDD.n1739 0.00498219
R6712 VDDD.n1743 VDDD.n1683 0.00498219
R6713 VDDD.n1684 VDDD.n1681 0.00498219
R6714 VDDD.n1745 VDDD.n1238 0.00498219
R6715 VDDD.n1748 VDDD.n1220 0.00498219
R6716 VDDD.n1236 VDDD.n1222 0.00498219
R6717 VDDD.n1224 VDDD.n1219 0.00498219
R6718 VDDD.n1752 VDDD.n1223 0.00498219
R6719 VDDD.n1743 VDDD.n1684 0.00498219
R6720 VDDD.n1739 VDDD.n1687 0.00498219
R6721 VDDD.n1687 VDDD.n1683 0.00498219
R6722 VDDD.n1681 VDDD.n1238 0.00498219
R6723 VDDD.n1749 VDDD.n1748 0.00498219
R6724 VDDD.n1236 VDDD.n1220 0.00498219
R6725 VDDD.n1224 VDDD.n1222 0.00498219
R6726 VDDD.n1223 VDDD.n1219 0.00498219
R6727 VDDD.n1785 VDDD.n1782 0.00498219
R6728 VDDD.n1798 VDDD.n1788 0.00498219
R6729 VDDD.n1792 VDDD.n1783 0.00498219
R6730 VDDD.n1792 VDDD.n1791 0.00498219
R6731 VDDD.n1780 VDDD.n1192 0.00498219
R6732 VDDD.n1205 VDDD.n1199 0.00498219
R6733 VDDD.n1210 VDDD.n1199 0.00498219
R6734 VDDD.n1778 VDDD.n1207 0.00498219
R6735 VDDD.n1210 VDDD.n1204 0.00498219
R6736 VDDD.n1207 VDDD.n1204 0.00498219
R6737 VDDD.n1206 VDDD.n1192 0.00498219
R6738 VDDD.n1206 VDDD.n1205 0.00498219
R6739 VDDD.n1798 VDDD.n1783 0.00498219
R6740 VDDD.n1788 VDDD.n1782 0.00498219
R6741 VDDD.n1801 VDDD.n1785 0.00498219
R6742 VDDD.n1791 VDDD.n1781 0.00498219
R6743 VDDD.n1886 VDDD.n1885 0.00498219
R6744 VDDD.n1889 VDDD.n1829 0.00498219
R6745 VDDD.n1830 VDDD.n1827 0.00498219
R6746 VDDD.n1891 VDDD.n1167 0.00498219
R6747 VDDD.n1894 VDDD.n1149 0.00498219
R6748 VDDD.n1165 VDDD.n1151 0.00498219
R6749 VDDD.n1153 VDDD.n1148 0.00498219
R6750 VDDD.n1898 VDDD.n1152 0.00498219
R6751 VDDD.n1889 VDDD.n1830 0.00498219
R6752 VDDD.n1885 VDDD.n1833 0.00498219
R6753 VDDD.n1833 VDDD.n1829 0.00498219
R6754 VDDD.n1827 VDDD.n1167 0.00498219
R6755 VDDD.n1895 VDDD.n1894 0.00498219
R6756 VDDD.n1165 VDDD.n1149 0.00498219
R6757 VDDD.n1153 VDDD.n1151 0.00498219
R6758 VDDD.n1152 VDDD.n1148 0.00498219
R6759 VDDD.n1931 VDDD.n1928 0.00498219
R6760 VDDD.n1944 VDDD.n1934 0.00498219
R6761 VDDD.n1938 VDDD.n1929 0.00498219
R6762 VDDD.n1938 VDDD.n1937 0.00498219
R6763 VDDD.n1926 VDDD.n1121 0.00498219
R6764 VDDD.n1134 VDDD.n1128 0.00498219
R6765 VDDD.n1139 VDDD.n1128 0.00498219
R6766 VDDD.n1924 VDDD.n1136 0.00498219
R6767 VDDD.n1139 VDDD.n1133 0.00498219
R6768 VDDD.n1136 VDDD.n1133 0.00498219
R6769 VDDD.n1135 VDDD.n1121 0.00498219
R6770 VDDD.n1135 VDDD.n1134 0.00498219
R6771 VDDD.n1944 VDDD.n1929 0.00498219
R6772 VDDD.n1934 VDDD.n1928 0.00498219
R6773 VDDD.n1947 VDDD.n1931 0.00498219
R6774 VDDD.n1937 VDDD.n1927 0.00498219
R6775 VDDD.n1100 VDDD.n1096 0.00498219
R6776 VDDD.n2020 VDDD.n2015 0.00498219
R6777 VDDD.n2017 VDDD.n1094 0.00498219
R6778 VDDD.n2024 VDDD.n1085 0.00498219
R6779 VDDD.n2027 VDDD.n1067 0.00498219
R6780 VDDD.n1083 VDDD.n1069 0.00498219
R6781 VDDD.n1071 VDDD.n1066 0.00498219
R6782 VDDD.n2031 VDDD.n1070 0.00498219
R6783 VDDD.n2015 VDDD.n1100 0.00498219
R6784 VDDD.n2020 VDDD.n2017 0.00498219
R6785 VDDD.n2022 VDDD.n1096 0.00498219
R6786 VDDD.n1094 VDDD.n1085 0.00498219
R6787 VDDD.n2028 VDDD.n2027 0.00498219
R6788 VDDD.n1083 VDDD.n1067 0.00498219
R6789 VDDD.n1071 VDDD.n1069 0.00498219
R6790 VDDD.n1070 VDDD.n1066 0.00498219
R6791 VDDD.n2064 VDDD.n2061 0.00498219
R6792 VDDD.n2077 VDDD.n2067 0.00498219
R6793 VDDD.n2071 VDDD.n2062 0.00498219
R6794 VDDD.n2071 VDDD.n2070 0.00498219
R6795 VDDD.n2059 VDDD.n1039 0.00498219
R6796 VDDD.n1052 VDDD.n1046 0.00498219
R6797 VDDD.n1057 VDDD.n1046 0.00498219
R6798 VDDD.n2057 VDDD.n1054 0.00498219
R6799 VDDD.n1057 VDDD.n1051 0.00498219
R6800 VDDD.n1054 VDDD.n1051 0.00498219
R6801 VDDD.n1053 VDDD.n1039 0.00498219
R6802 VDDD.n1053 VDDD.n1052 0.00498219
R6803 VDDD.n2077 VDDD.n2062 0.00498219
R6804 VDDD.n2067 VDDD.n2061 0.00498219
R6805 VDDD.n2080 VDDD.n2064 0.00498219
R6806 VDDD.n2070 VDDD.n2060 0.00498219
R6807 VDDD.n871 VDDD.n780 0.00498219
R6808 VDDD.n2246 VDDD.n779 0.00498219
R6809 VDDD.n2244 VDDD.n781 0.00498219
R6810 VDDD.n2245 VDDD.n782 0.00498219
R6811 VDDD.n2310 VDDD.n2309 0.00498219
R6812 VDDD.n633 VDDD.n627 0.00498219
R6813 VDDD.n722 VDDD.n628 0.00498219
R6814 VDDD.n629 VDDD.n626 0.00498219
R6815 VDDD.n2372 VDDD.n2371 0.00498219
R6816 VDDD.n480 VDDD.n474 0.00498219
R6817 VDDD.n569 VDDD.n475 0.00498219
R6818 VDDD.n476 VDDD.n473 0.00498219
R6819 VDDD.n2434 VDDD.n2433 0.00498219
R6820 VDDD.n327 VDDD.n321 0.00498219
R6821 VDDD.n416 VDDD.n322 0.00498219
R6822 VDDD.n323 VDDD.n320 0.00498219
R6823 VDDD.n2496 VDDD.n2495 0.00498219
R6824 VDDD.n174 VDDD.n168 0.00498219
R6825 VDDD.n263 VDDD.n169 0.00498219
R6826 VDDD.n170 VDDD.n167 0.00498219
R6827 VDDD.n2739 VDDD.n2738 0.00498219
R6828 VDDD.n2742 VDDD.n2682 0.00498219
R6829 VDDD.n2683 VDDD.n2680 0.00498219
R6830 VDDD.n2744 VDDD.n67 0.00498219
R6831 VDDD.n2747 VDDD.n49 0.00498219
R6832 VDDD.n65 VDDD.n51 0.00498219
R6833 VDDD.n53 VDDD.n48 0.00498219
R6834 VDDD.n2751 VDDD.n52 0.00498219
R6835 VDDD.n2742 VDDD.n2683 0.00498219
R6836 VDDD.n2738 VDDD.n2686 0.00498219
R6837 VDDD.n2686 VDDD.n2682 0.00498219
R6838 VDDD.n2680 VDDD.n67 0.00498219
R6839 VDDD.n2748 VDDD.n2747 0.00498219
R6840 VDDD.n65 VDDD.n49 0.00498219
R6841 VDDD.n53 VDDD.n51 0.00498219
R6842 VDDD.n52 VDDD.n48 0.00498219
R6843 VDDD.n2784 VDDD.n2781 0.00498219
R6844 VDDD.n2797 VDDD.n2787 0.00498219
R6845 VDDD.n2791 VDDD.n2782 0.00498219
R6846 VDDD.n2791 VDDD.n2790 0.00498219
R6847 VDDD.n2779 VDDD.n21 0.00498219
R6848 VDDD.n34 VDDD.n28 0.00498219
R6849 VDDD.n39 VDDD.n28 0.00498219
R6850 VDDD.n2777 VDDD.n36 0.00498219
R6851 VDDD.n39 VDDD.n33 0.00498219
R6852 VDDD.n36 VDDD.n33 0.00498219
R6853 VDDD.n35 VDDD.n21 0.00498219
R6854 VDDD.n35 VDDD.n34 0.00498219
R6855 VDDD.n2797 VDDD.n2782 0.00498219
R6856 VDDD.n2787 VDDD.n2781 0.00498219
R6857 VDDD.n2800 VDDD.n2784 0.00498219
R6858 VDDD.n2790 VDDD.n2780 0.00498219
R6859 VDDD.n934 VDDD.n899 0.00409787
R6860 VDDD.n951 VDDD.n934 0.00409787
R6861 VDDD.n1010 VDDD.n900 0.00409787
R6862 VDDD.n950 VDDD.n900 0.00409787
R6863 VDDD.n1009 VDDD.n901 0.00409787
R6864 VDDD.n949 VDDD.n901 0.00409787
R6865 VDDD.n1008 VDDD.n902 0.00409787
R6866 VDDD.n948 VDDD.n902 0.00409787
R6867 VDDD.n1007 VDDD.n903 0.00409787
R6868 VDDD.n947 VDDD.n903 0.00409787
R6869 VDDD.n1006 VDDD.n904 0.00409787
R6870 VDDD.n946 VDDD.n904 0.00409787
R6871 VDDD.n1005 VDDD.n905 0.00409787
R6872 VDDD.n945 VDDD.n905 0.00409787
R6873 VDDD.n1004 VDDD.n906 0.00409787
R6874 VDDD.n944 VDDD.n906 0.00409787
R6875 VDDD.n1003 VDDD.n907 0.00409787
R6876 VDDD.n943 VDDD.n907 0.00409787
R6877 VDDD.n1002 VDDD.n908 0.00409787
R6878 VDDD.n942 VDDD.n908 0.00409787
R6879 VDDD.n1001 VDDD.n909 0.00409787
R6880 VDDD.n941 VDDD.n909 0.00409787
R6881 VDDD.n1000 VDDD.n910 0.00409787
R6882 VDDD.n939 VDDD.n910 0.00409787
R6883 VDDD.n1015 VDDD.n923 0.00409787
R6884 VDDD.n1015 VDDD.n929 0.00409787
R6885 VDDD.n2104 VDDD.n912 0.00409787
R6886 VDDD.n2105 VDDD.n2104 0.00409787
R6887 VDDD.n1010 VDDD.n898 0.00409787
R6888 VDDD.n1009 VDDD.n897 0.00409787
R6889 VDDD.n1008 VDDD.n896 0.00409787
R6890 VDDD.n1007 VDDD.n895 0.00409787
R6891 VDDD.n1006 VDDD.n894 0.00409787
R6892 VDDD.n1005 VDDD.n893 0.00409787
R6893 VDDD.n1004 VDDD.n892 0.00409787
R6894 VDDD.n1003 VDDD.n891 0.00409787
R6895 VDDD.n1002 VDDD.n890 0.00409787
R6896 VDDD.n1001 VDDD.n889 0.00409787
R6897 VDDD.n1000 VDDD.n888 0.00409787
R6898 VDDD.n951 VDDD.n898 0.00409787
R6899 VDDD.n950 VDDD.n897 0.00409787
R6900 VDDD.n949 VDDD.n896 0.00409787
R6901 VDDD.n948 VDDD.n895 0.00409787
R6902 VDDD.n947 VDDD.n894 0.00409787
R6903 VDDD.n946 VDDD.n893 0.00409787
R6904 VDDD.n945 VDDD.n892 0.00409787
R6905 VDDD.n944 VDDD.n891 0.00409787
R6906 VDDD.n943 VDDD.n890 0.00409787
R6907 VDDD.n942 VDDD.n889 0.00409787
R6908 VDDD.n941 VDDD.n888 0.00409787
R6909 VDDD.n923 VDDD.n887 0.00409787
R6910 VDDD.n939 VDDD.n887 0.00409787
R6911 VDDD.n929 VDDD.n886 0.00409787
R6912 VDDD.n912 VDDD.n886 0.00409787
R6913 VDDD.n2105 VDDD.n911 0.00409787
R6914 VDDD.n1012 VDDD.n899 0.00409787
R6915 VDDD.n2164 VDDD.n2131 0.00409787
R6916 VDDD.n2133 VDDD.n2131 0.00409787
R6917 VDDD.n2178 VDDD.n2130 0.00409787
R6918 VDDD.n2163 VDDD.n2130 0.00409787
R6919 VDDD.n2177 VDDD.n2129 0.00409787
R6920 VDDD.n2162 VDDD.n2129 0.00409787
R6921 VDDD.n2176 VDDD.n2128 0.00409787
R6922 VDDD.n2161 VDDD.n2128 0.00409787
R6923 VDDD.n2175 VDDD.n2127 0.00409787
R6924 VDDD.n2160 VDDD.n2127 0.00409787
R6925 VDDD.n2174 VDDD.n2126 0.00409787
R6926 VDDD.n2159 VDDD.n2126 0.00409787
R6927 VDDD.n2173 VDDD.n2125 0.00409787
R6928 VDDD.n2158 VDDD.n2125 0.00409787
R6929 VDDD.n2172 VDDD.n2124 0.00409787
R6930 VDDD.n2157 VDDD.n2124 0.00409787
R6931 VDDD.n2171 VDDD.n2123 0.00409787
R6932 VDDD.n2156 VDDD.n2123 0.00409787
R6933 VDDD.n2170 VDDD.n2122 0.00409787
R6934 VDDD.n2155 VDDD.n2122 0.00409787
R6935 VDDD.n2169 VDDD.n2121 0.00409787
R6936 VDDD.n2154 VDDD.n2121 0.00409787
R6937 VDDD.n2168 VDDD.n2120 0.00409787
R6938 VDDD.n2153 VDDD.n2120 0.00409787
R6939 VDDD.n2186 VDDD.n2181 0.00409787
R6940 VDDD.n2186 VDDD.n2166 0.00409787
R6941 VDDD.n2151 VDDD.n2146 0.00409787
R6942 VDDD.n2241 VDDD.n884 0.00409787
R6943 VDDD.n2178 VDDD.n2134 0.00409787
R6944 VDDD.n2177 VDDD.n2135 0.00409787
R6945 VDDD.n2176 VDDD.n2136 0.00409787
R6946 VDDD.n2175 VDDD.n2137 0.00409787
R6947 VDDD.n2174 VDDD.n2138 0.00409787
R6948 VDDD.n2173 VDDD.n2139 0.00409787
R6949 VDDD.n2172 VDDD.n2140 0.00409787
R6950 VDDD.n2171 VDDD.n2141 0.00409787
R6951 VDDD.n2170 VDDD.n2142 0.00409787
R6952 VDDD.n2169 VDDD.n2143 0.00409787
R6953 VDDD.n2168 VDDD.n2144 0.00409787
R6954 VDDD.n2181 VDDD.n2145 0.00409787
R6955 VDDD.n2239 VDDD.n2146 0.00409787
R6956 VDDD.n2164 VDDD.n2132 0.00409787
R6957 VDDD.n2163 VDDD.n2135 0.00409787
R6958 VDDD.n2162 VDDD.n2136 0.00409787
R6959 VDDD.n2161 VDDD.n2137 0.00409787
R6960 VDDD.n2160 VDDD.n2138 0.00409787
R6961 VDDD.n2159 VDDD.n2139 0.00409787
R6962 VDDD.n2158 VDDD.n2140 0.00409787
R6963 VDDD.n2157 VDDD.n2141 0.00409787
R6964 VDDD.n2156 VDDD.n2142 0.00409787
R6965 VDDD.n2155 VDDD.n2143 0.00409787
R6966 VDDD.n2154 VDDD.n2144 0.00409787
R6967 VDDD.n2153 VDDD.n2145 0.00409787
R6968 VDDD.n2239 VDDD.n2166 0.00409787
R6969 VDDD.n2134 VDDD.n2133 0.00409787
R6970 VDDD.n2151 VDDD.n884 0.00409787
R6971 VDDD.n999 VDDD.n954 0.00404422
R6972 VDDD.n2200 VDDD.n2199 0.00404422
R6973 VDDD.n2579 VDDD.n2578 0.00378827
R6974 VDDD.n2579 VDDD.n101 0.00378827
R6975 VDDD.n2614 VDDD.n2580 0.00378827
R6976 VDDD.n2580 VDDD.n102 0.00378827
R6977 VDDD.n2612 VDDD.n2581 0.00378827
R6978 VDDD.n2581 VDDD.n103 0.00378827
R6979 VDDD.n2610 VDDD.n2582 0.00378827
R6980 VDDD.n2582 VDDD.n104 0.00378827
R6981 VDDD.n2608 VDDD.n2583 0.00378827
R6982 VDDD.n2583 VDDD.n105 0.00378827
R6983 VDDD.n2606 VDDD.n2584 0.00378827
R6984 VDDD.n2584 VDDD.n106 0.00378827
R6985 VDDD.n2604 VDDD.n2585 0.00378827
R6986 VDDD.n2585 VDDD.n107 0.00378827
R6987 VDDD.n2602 VDDD.n2586 0.00378827
R6988 VDDD.n2586 VDDD.n108 0.00378827
R6989 VDDD.n2600 VDDD.n2587 0.00378827
R6990 VDDD.n2587 VDDD.n109 0.00378827
R6991 VDDD.n2598 VDDD.n2588 0.00378827
R6992 VDDD.n2588 VDDD.n110 0.00378827
R6993 VDDD.n2596 VDDD.n2589 0.00378827
R6994 VDDD.n2589 VDDD.n111 0.00378827
R6995 VDDD.n2594 VDDD.n2590 0.00378827
R6996 VDDD.n2590 VDDD.n112 0.00378827
R6997 VDDD.n2592 VDDD.n113 0.00378827
R6998 VDDD.n2591 VDDD.n114 0.00378827
R6999 VDDD.n2593 VDDD.n112 0.00378827
R7000 VDDD.n2595 VDDD.n111 0.00378827
R7001 VDDD.n2597 VDDD.n110 0.00378827
R7002 VDDD.n2599 VDDD.n109 0.00378827
R7003 VDDD.n2601 VDDD.n108 0.00378827
R7004 VDDD.n2603 VDDD.n107 0.00378827
R7005 VDDD.n2605 VDDD.n106 0.00378827
R7006 VDDD.n2607 VDDD.n105 0.00378827
R7007 VDDD.n2609 VDDD.n104 0.00378827
R7008 VDDD.n2611 VDDD.n103 0.00378827
R7009 VDDD.n2613 VDDD.n102 0.00378827
R7010 VDDD.n2615 VDDD.n101 0.00378827
R7011 VDDD.n2593 VDDD.n2592 0.00378827
R7012 VDDD.n2595 VDDD.n2594 0.00378827
R7013 VDDD.n2597 VDDD.n2596 0.00378827
R7014 VDDD.n2599 VDDD.n2598 0.00378827
R7015 VDDD.n2601 VDDD.n2600 0.00378827
R7016 VDDD.n2603 VDDD.n2602 0.00378827
R7017 VDDD.n2605 VDDD.n2604 0.00378827
R7018 VDDD.n2607 VDDD.n2606 0.00378827
R7019 VDDD.n2609 VDDD.n2608 0.00378827
R7020 VDDD.n2611 VDDD.n2610 0.00378827
R7021 VDDD.n2613 VDDD.n2612 0.00378827
R7022 VDDD.n2615 VDDD.n2614 0.00378827
R7023 VDDD.n2578 VDDD.n115 0.00378827
R7024 VDDD.n2591 VDDD.n113 0.00378827
R7025 VDDD.n99 VDDD.n77 0.00378827
R7026 VDDD.n2644 VDDD.n2619 0.00378827
R7027 VDDD.n2661 VDDD.n98 0.00378827
R7028 VDDD.n2643 VDDD.n2620 0.00378827
R7029 VDDD.n2660 VDDD.n97 0.00378827
R7030 VDDD.n2642 VDDD.n2621 0.00378827
R7031 VDDD.n2659 VDDD.n96 0.00378827
R7032 VDDD.n2641 VDDD.n2622 0.00378827
R7033 VDDD.n2658 VDDD.n95 0.00378827
R7034 VDDD.n2640 VDDD.n2623 0.00378827
R7035 VDDD.n2657 VDDD.n94 0.00378827
R7036 VDDD.n2639 VDDD.n2624 0.00378827
R7037 VDDD.n2656 VDDD.n93 0.00378827
R7038 VDDD.n2638 VDDD.n2625 0.00378827
R7039 VDDD.n2655 VDDD.n92 0.00378827
R7040 VDDD.n2637 VDDD.n2626 0.00378827
R7041 VDDD.n2654 VDDD.n91 0.00378827
R7042 VDDD.n2636 VDDD.n2627 0.00378827
R7043 VDDD.n2653 VDDD.n90 0.00378827
R7044 VDDD.n2635 VDDD.n2628 0.00378827
R7045 VDDD.n2652 VDDD.n89 0.00378827
R7046 VDDD.n2634 VDDD.n2629 0.00378827
R7047 VDDD.n2651 VDDD.n88 0.00378827
R7048 VDDD.n2633 VDDD.n2630 0.00378827
R7049 VDDD.n2650 VDDD.n87 0.00378827
R7050 VDDD.n2632 VDDD.n2631 0.00378827
R7051 VDDD.n2670 VDDD.n2631 0.00378827
R7052 VDDD.n2672 VDDD.n2646 0.00378827
R7053 VDDD.n2644 VDDD.n99 0.00378827
R7054 VDDD.n2643 VDDD.n98 0.00378827
R7055 VDDD.n2642 VDDD.n97 0.00378827
R7056 VDDD.n2641 VDDD.n96 0.00378827
R7057 VDDD.n2640 VDDD.n95 0.00378827
R7058 VDDD.n2639 VDDD.n94 0.00378827
R7059 VDDD.n2638 VDDD.n93 0.00378827
R7060 VDDD.n2637 VDDD.n92 0.00378827
R7061 VDDD.n2636 VDDD.n91 0.00378827
R7062 VDDD.n2635 VDDD.n90 0.00378827
R7063 VDDD.n2634 VDDD.n89 0.00378827
R7064 VDDD.n2633 VDDD.n88 0.00378827
R7065 VDDD.n2632 VDDD.n87 0.00378827
R7066 VDDD.n2669 VDDD.n2646 0.00378827
R7067 VDDD.n2661 VDDD.n2619 0.00378827
R7068 VDDD.n2660 VDDD.n2620 0.00378827
R7069 VDDD.n2659 VDDD.n2621 0.00378827
R7070 VDDD.n2658 VDDD.n2622 0.00378827
R7071 VDDD.n2657 VDDD.n2623 0.00378827
R7072 VDDD.n2656 VDDD.n2624 0.00378827
R7073 VDDD.n2655 VDDD.n2625 0.00378827
R7074 VDDD.n2654 VDDD.n2626 0.00378827
R7075 VDDD.n2653 VDDD.n2627 0.00378827
R7076 VDDD.n2652 VDDD.n2628 0.00378827
R7077 VDDD.n2651 VDDD.n2629 0.00378827
R7078 VDDD.n2650 VDDD.n2630 0.00378827
R7079 VDDD.n2674 VDDD.n77 0.00378827
R7080 VDDD.n2670 VDDD.n2669 0.00378827
R7081 VDDD.n1446 VDDD.n1394 0.00345681
R7082 VDDD.n1452 VDDD.n1387 0.00345681
R7083 VDDD.n1452 VDDD.n1390 0.00345681
R7084 VDDD.n1393 VDDD.n1386 0.00345681
R7085 VDDD.n1398 VDDD.n1386 0.00345681
R7086 VDDD.n1397 VDDD.n1396 0.00345681
R7087 VDDD.n1450 VDDD.n1384 0.00345681
R7088 VDDD.n1449 VDDD.n1385 0.00345681
R7089 VDDD.n1388 VDDD.n1385 0.00345681
R7090 VDDD.n1394 VDDD.n1381 0.00345681
R7091 VDDD.n1393 VDDD.n1382 0.00345681
R7092 VDDD.n1387 VDDD.n1381 0.00345681
R7093 VDDD.n1396 VDDD.n1383 0.00345681
R7094 VDDD.n1390 VDDD.n1382 0.00345681
R7095 VDDD.n1398 VDDD.n1383 0.00345681
R7096 VDDD.n1450 VDDD.n1449 0.00345681
R7097 VDDD.n1388 VDDD.n0 0.00345681
R7098 VDDD.n1397 VDDD.n1384 0.00345681
R7099 VDDD.n1592 VDDD.n1540 0.00345681
R7100 VDDD.n1598 VDDD.n1533 0.00345681
R7101 VDDD.n1598 VDDD.n1536 0.00345681
R7102 VDDD.n1539 VDDD.n1532 0.00345681
R7103 VDDD.n1544 VDDD.n1532 0.00345681
R7104 VDDD.n1543 VDDD.n1542 0.00345681
R7105 VDDD.n1596 VDDD.n1313 0.00345681
R7106 VDDD.n1595 VDDD.n1531 0.00345681
R7107 VDDD.n1534 VDDD.n1531 0.00345681
R7108 VDDD.n1540 VDDD.n1310 0.00345681
R7109 VDDD.n1539 VDDD.n1311 0.00345681
R7110 VDDD.n1533 VDDD.n1310 0.00345681
R7111 VDDD.n1542 VDDD.n1312 0.00345681
R7112 VDDD.n1536 VDDD.n1311 0.00345681
R7113 VDDD.n1544 VDDD.n1312 0.00345681
R7114 VDDD.n1596 VDDD.n1595 0.00345681
R7115 VDDD.n1534 VDDD.n1530 0.00345681
R7116 VDDD.n1543 VDDD.n1313 0.00345681
R7117 VDDD.n1738 VDDD.n1686 0.00345681
R7118 VDDD.n1744 VDDD.n1679 0.00345681
R7119 VDDD.n1744 VDDD.n1682 0.00345681
R7120 VDDD.n1685 VDDD.n1678 0.00345681
R7121 VDDD.n1690 VDDD.n1678 0.00345681
R7122 VDDD.n1689 VDDD.n1688 0.00345681
R7123 VDDD.n1742 VDDD.n1242 0.00345681
R7124 VDDD.n1741 VDDD.n1677 0.00345681
R7125 VDDD.n1680 VDDD.n1677 0.00345681
R7126 VDDD.n1686 VDDD.n1239 0.00345681
R7127 VDDD.n1685 VDDD.n1240 0.00345681
R7128 VDDD.n1679 VDDD.n1239 0.00345681
R7129 VDDD.n1688 VDDD.n1241 0.00345681
R7130 VDDD.n1682 VDDD.n1240 0.00345681
R7131 VDDD.n1690 VDDD.n1241 0.00345681
R7132 VDDD.n1742 VDDD.n1741 0.00345681
R7133 VDDD.n1680 VDDD.n1676 0.00345681
R7134 VDDD.n1689 VDDD.n1242 0.00345681
R7135 VDDD.n1884 VDDD.n1832 0.00345681
R7136 VDDD.n1890 VDDD.n1825 0.00345681
R7137 VDDD.n1890 VDDD.n1828 0.00345681
R7138 VDDD.n1831 VDDD.n1824 0.00345681
R7139 VDDD.n1836 VDDD.n1824 0.00345681
R7140 VDDD.n1835 VDDD.n1834 0.00345681
R7141 VDDD.n1888 VDDD.n1171 0.00345681
R7142 VDDD.n1887 VDDD.n1823 0.00345681
R7143 VDDD.n1826 VDDD.n1823 0.00345681
R7144 VDDD.n1832 VDDD.n1168 0.00345681
R7145 VDDD.n1831 VDDD.n1169 0.00345681
R7146 VDDD.n1825 VDDD.n1168 0.00345681
R7147 VDDD.n1834 VDDD.n1170 0.00345681
R7148 VDDD.n1828 VDDD.n1169 0.00345681
R7149 VDDD.n1836 VDDD.n1170 0.00345681
R7150 VDDD.n1888 VDDD.n1887 0.00345681
R7151 VDDD.n1826 VDDD.n1822 0.00345681
R7152 VDDD.n1835 VDDD.n1171 0.00345681
R7153 VDDD.n2014 VDDD.n1097 0.00345681
R7154 VDDD.n2023 VDDD.n1093 0.00345681
R7155 VDDD.n2023 VDDD.n1095 0.00345681
R7156 VDDD.n2019 VDDD.n1092 0.00345681
R7157 VDDD.n1099 VDDD.n1092 0.00345681
R7158 VDDD.n2018 VDDD.n1091 0.00345681
R7159 VDDD.n1098 VDDD.n1091 0.00345681
R7160 VDDD.n2021 VDDD.n1090 0.00345681
R7161 VDDD.n1093 VDDD.n1086 0.00345681
R7162 VDDD.n2019 VDDD.n1087 0.00345681
R7163 VDDD.n2018 VDDD.n1088 0.00345681
R7164 VDDD.n1095 VDDD.n1087 0.00345681
R7165 VDDD.n1099 VDDD.n1088 0.00345681
R7166 VDDD.n1098 VDDD.n1089 0.00345681
R7167 VDDD.n1097 VDDD.n1086 0.00345681
R7168 VDDD.n2016 VDDD.n1090 0.00345681
R7169 VDDD.n2249 VDDD.n2248 0.00345681
R7170 VDDD.n881 VDDD.n880 0.00345681
R7171 VDDD.n877 VDDD.n783 0.00345681
R7172 VDDD.n879 VDDD.n878 0.00345681
R7173 VDDD.n874 VDDD.n784 0.00345681
R7174 VDDD.n876 VDDD.n875 0.00345681
R7175 VDDD.n872 VDDD.n785 0.00345681
R7176 VDDD.n2251 VDDD.n778 0.00345681
R7177 VDDD.n875 VDDD.n785 0.00345681
R7178 VDDD.n878 VDDD.n784 0.00345681
R7179 VDDD.n880 VDDD.n783 0.00345681
R7180 VDDD.n2248 VDDD.n2247 0.00345681
R7181 VDDD.n876 VDDD.n874 0.00345681
R7182 VDDD.n879 VDDD.n877 0.00345681
R7183 VDDD.n873 VDDD.n872 0.00345681
R7184 VDDD.n873 VDDD.n778 0.00345681
R7185 VDDD.n2311 VDDD.n2305 0.00345681
R7186 VDDD.n727 VDDD.n726 0.00345681
R7187 VDDD.n2308 VDDD.n631 0.00345681
R7188 VDDD.n725 VDDD.n724 0.00345681
R7189 VDDD.n2307 VDDD.n632 0.00345681
R7190 VDDD.n723 VDDD.n721 0.00345681
R7191 VDDD.n2306 VDDD.n635 0.00345681
R7192 VDDD.n2313 VDDD.n625 0.00345681
R7193 VDDD.n2308 VDDD.n727 0.00345681
R7194 VDDD.n2307 VDDD.n725 0.00345681
R7195 VDDD.n2306 VDDD.n723 0.00345681
R7196 VDDD.n634 VDDD.n625 0.00345681
R7197 VDDD.n724 VDDD.n631 0.00345681
R7198 VDDD.n721 VDDD.n632 0.00345681
R7199 VDDD.n726 VDDD.n630 0.00345681
R7200 VDDD.n2305 VDDD.n630 0.00345681
R7201 VDDD.n2373 VDDD.n2367 0.00345681
R7202 VDDD.n574 VDDD.n573 0.00345681
R7203 VDDD.n2370 VDDD.n478 0.00345681
R7204 VDDD.n572 VDDD.n571 0.00345681
R7205 VDDD.n2369 VDDD.n479 0.00345681
R7206 VDDD.n570 VDDD.n568 0.00345681
R7207 VDDD.n2368 VDDD.n482 0.00345681
R7208 VDDD.n2375 VDDD.n472 0.00345681
R7209 VDDD.n2370 VDDD.n574 0.00345681
R7210 VDDD.n2369 VDDD.n572 0.00345681
R7211 VDDD.n2368 VDDD.n570 0.00345681
R7212 VDDD.n481 VDDD.n472 0.00345681
R7213 VDDD.n571 VDDD.n478 0.00345681
R7214 VDDD.n568 VDDD.n479 0.00345681
R7215 VDDD.n573 VDDD.n477 0.00345681
R7216 VDDD.n2367 VDDD.n477 0.00345681
R7217 VDDD.n2435 VDDD.n2429 0.00345681
R7218 VDDD.n421 VDDD.n420 0.00345681
R7219 VDDD.n2432 VDDD.n325 0.00345681
R7220 VDDD.n419 VDDD.n418 0.00345681
R7221 VDDD.n2431 VDDD.n326 0.00345681
R7222 VDDD.n417 VDDD.n415 0.00345681
R7223 VDDD.n2430 VDDD.n329 0.00345681
R7224 VDDD.n2437 VDDD.n319 0.00345681
R7225 VDDD.n2432 VDDD.n421 0.00345681
R7226 VDDD.n2431 VDDD.n419 0.00345681
R7227 VDDD.n2430 VDDD.n417 0.00345681
R7228 VDDD.n328 VDDD.n319 0.00345681
R7229 VDDD.n418 VDDD.n325 0.00345681
R7230 VDDD.n415 VDDD.n326 0.00345681
R7231 VDDD.n420 VDDD.n324 0.00345681
R7232 VDDD.n2429 VDDD.n324 0.00345681
R7233 VDDD.n2497 VDDD.n2491 0.00345681
R7234 VDDD.n268 VDDD.n267 0.00345681
R7235 VDDD.n2494 VDDD.n172 0.00345681
R7236 VDDD.n266 VDDD.n265 0.00345681
R7237 VDDD.n2493 VDDD.n173 0.00345681
R7238 VDDD.n264 VDDD.n262 0.00345681
R7239 VDDD.n2492 VDDD.n176 0.00345681
R7240 VDDD.n2499 VDDD.n166 0.00345681
R7241 VDDD.n2494 VDDD.n268 0.00345681
R7242 VDDD.n2493 VDDD.n266 0.00345681
R7243 VDDD.n2492 VDDD.n264 0.00345681
R7244 VDDD.n175 VDDD.n166 0.00345681
R7245 VDDD.n265 VDDD.n172 0.00345681
R7246 VDDD.n262 VDDD.n173 0.00345681
R7247 VDDD.n267 VDDD.n171 0.00345681
R7248 VDDD.n2491 VDDD.n171 0.00345681
R7249 VDDD.n2737 VDDD.n2685 0.00345681
R7250 VDDD.n2743 VDDD.n2678 0.00345681
R7251 VDDD.n2743 VDDD.n2681 0.00345681
R7252 VDDD.n2684 VDDD.n2677 0.00345681
R7253 VDDD.n2689 VDDD.n2677 0.00345681
R7254 VDDD.n2688 VDDD.n2687 0.00345681
R7255 VDDD.n2741 VDDD.n71 0.00345681
R7256 VDDD.n2740 VDDD.n2676 0.00345681
R7257 VDDD.n2679 VDDD.n2676 0.00345681
R7258 VDDD.n2685 VDDD.n68 0.00345681
R7259 VDDD.n2684 VDDD.n69 0.00345681
R7260 VDDD.n2678 VDDD.n68 0.00345681
R7261 VDDD.n2687 VDDD.n70 0.00345681
R7262 VDDD.n2681 VDDD.n69 0.00345681
R7263 VDDD.n2689 VDDD.n70 0.00345681
R7264 VDDD.n2741 VDDD.n2740 0.00345681
R7265 VDDD.n2679 VDDD.n2675 0.00345681
R7266 VDDD.n2688 VDDD.n71 0.00345681
R7267 VDDD.n1522 VDDD.n1320 0.00329
R7268 VDDD.n1518 VDDD.n1320 0.00329
R7269 VDDD.n1668 VDDD.n1249 0.00329
R7270 VDDD.n1664 VDDD.n1249 0.00329
R7271 VDDD.n1814 VDDD.n1178 0.00329
R7272 VDDD.n1810 VDDD.n1178 0.00329
R7273 VDDD.n1960 VDDD.n1107 0.00329
R7274 VDDD.n1956 VDDD.n1107 0.00329
R7275 VDDD.n2093 VDDD.n1025 0.00329
R7276 VDDD.n2089 VDDD.n1025 0.00329
R7277 VDDD.n2295 VDDD.n2294 0.00329
R7278 VDDD.n2296 VDDD.n2295 0.00329
R7279 VDDD.n2357 VDDD.n2356 0.00329
R7280 VDDD.n2358 VDDD.n2357 0.00329
R7281 VDDD.n2419 VDDD.n2418 0.00329
R7282 VDDD.n2420 VDDD.n2419 0.00329
R7283 VDDD.n2481 VDDD.n2480 0.00329
R7284 VDDD.n2482 VDDD.n2481 0.00329
R7285 VDDD.n2543 VDDD.n2542 0.00329
R7286 VDDD.n2544 VDDD.n2543 0.00329
R7287 VDDD.n2813 VDDD.n7 0.00329
R7288 VDDD.n2809 VDDD.n7 0.00329
R7289 VDDD.n1013 VDDD.n924 0.00239457
R7290 VDDD.n925 VDDD.n913 0.00239457
R7291 VDDD.n935 VDDD.n925 0.00239457
R7292 VDDD.n926 VDDD.n914 0.00239457
R7293 VDDD.n936 VDDD.n926 0.00239457
R7294 VDDD.n927 VDDD.n915 0.00239457
R7295 VDDD.n937 VDDD.n927 0.00239457
R7296 VDDD.n928 VDDD.n916 0.00239457
R7297 VDDD.n938 VDDD.n928 0.00239457
R7298 VDDD.n940 VDDD.n917 0.00239457
R7299 VDDD.n953 VDDD.n940 0.00239457
R7300 VDDD.n1011 VDDD.n918 0.00239457
R7301 VDDD.n2106 VDDD.n885 0.00239457
R7302 VDDD.n2240 VDDD.n2118 0.00239457
R7303 VDDD.n2119 VDDD.n2108 0.00239457
R7304 VDDD.n2150 VDDD.n2117 0.00239457
R7305 VDDD.n2182 VDDD.n2109 0.00239457
R7306 VDDD.n2149 VDDD.n2116 0.00239457
R7307 VDDD.n2183 VDDD.n2110 0.00239457
R7308 VDDD.n2148 VDDD.n2115 0.00239457
R7309 VDDD.n2184 VDDD.n2111 0.00239457
R7310 VDDD.n2147 VDDD.n2114 0.00239457
R7311 VDDD.n2185 VDDD.n2112 0.00239457
R7312 VDDD.n2165 VDDD.n2152 0.00239457
R7313 VDDD.n2180 VDDD.n2113 0.00239457
R7314 VDDD.n2179 VDDD.n2167 0.00239457
R7315 VDDD.n1011 VDDD.n885 0.00239457
R7316 VDDD.n953 VDDD.n952 0.00239457
R7317 VDDD.n952 VDDD.n918 0.00239457
R7318 VDDD.n938 VDDD.n930 0.00239457
R7319 VDDD.n930 VDDD.n917 0.00239457
R7320 VDDD.n937 VDDD.n931 0.00239457
R7321 VDDD.n931 VDDD.n916 0.00239457
R7322 VDDD.n936 VDDD.n932 0.00239457
R7323 VDDD.n932 VDDD.n915 0.00239457
R7324 VDDD.n935 VDDD.n933 0.00239457
R7325 VDDD.n933 VDDD.n914 0.00239457
R7326 VDDD.n1014 VDDD.n1013 0.00239457
R7327 VDDD.n1014 VDDD.n913 0.00239457
R7328 VDDD.n2180 VDDD.n2179 0.00239457
R7329 VDDD.n2165 VDDD.n2113 0.00239457
R7330 VDDD.n2152 VDDD.n2112 0.00239457
R7331 VDDD.n2185 VDDD.n2114 0.00239457
R7332 VDDD.n2147 VDDD.n2111 0.00239457
R7333 VDDD.n2184 VDDD.n2115 0.00239457
R7334 VDDD.n2148 VDDD.n2110 0.00239457
R7335 VDDD.n2183 VDDD.n2116 0.00239457
R7336 VDDD.n2149 VDDD.n2109 0.00239457
R7337 VDDD.n2182 VDDD.n2117 0.00239457
R7338 VDDD.n2150 VDDD.n2108 0.00239457
R7339 VDDD.n2240 VDDD.n2119 0.00239457
R7340 VDDD.n2118 VDDD.n2107 0.00239457
R7341 VDDD.n2645 VDDD.n78 0.00239457
R7342 VDDD.n2668 VDDD.n2649 0.00239457
R7343 VDDD.n2648 VDDD.n79 0.00239457
R7344 VDDD.n2667 VDDD.n76 0.00239457
R7345 VDDD.n84 VDDD.n80 0.00239457
R7346 VDDD.n2666 VDDD.n75 0.00239457
R7347 VDDD.n85 VDDD.n81 0.00239457
R7348 VDDD.n2665 VDDD.n74 0.00239457
R7349 VDDD.n86 VDDD.n82 0.00239457
R7350 VDDD.n2664 VDDD.n73 0.00239457
R7351 VDDD.n2671 VDDD.n2663 0.00239457
R7352 VDDD.n2647 VDDD.n72 0.00239457
R7353 VDDD.n2673 VDDD.n83 0.00239457
R7354 VDDD.n2561 VDDD.n100 0.00239457
R7355 VDDD.n2560 VDDD.n2558 0.00239457
R7356 VDDD.n2564 VDDD.n2562 0.00239457
R7357 VDDD.n2563 VDDD.n2557 0.00239457
R7358 VDDD.n2567 VDDD.n2565 0.00239457
R7359 VDDD.n2566 VDDD.n2556 0.00239457
R7360 VDDD.n2570 VDDD.n2568 0.00239457
R7361 VDDD.n2569 VDDD.n2555 0.00239457
R7362 VDDD.n2573 VDDD.n2571 0.00239457
R7363 VDDD.n2572 VDDD.n2554 0.00239457
R7364 VDDD.n2576 VDDD.n2574 0.00239457
R7365 VDDD.n2575 VDDD.n2553 0.00239457
R7366 VDDD.n2616 VDDD.n2577 0.00239457
R7367 VDDD.n2618 VDDD.n100 0.00239457
R7368 VDDD.n2561 VDDD.n2560 0.00239457
R7369 VDDD.n2562 VDDD.n2558 0.00239457
R7370 VDDD.n2564 VDDD.n2563 0.00239457
R7371 VDDD.n2565 VDDD.n2557 0.00239457
R7372 VDDD.n2567 VDDD.n2566 0.00239457
R7373 VDDD.n2568 VDDD.n2556 0.00239457
R7374 VDDD.n2570 VDDD.n2569 0.00239457
R7375 VDDD.n2571 VDDD.n2555 0.00239457
R7376 VDDD.n2573 VDDD.n2572 0.00239457
R7377 VDDD.n2574 VDDD.n2554 0.00239457
R7378 VDDD.n2576 VDDD.n2575 0.00239457
R7379 VDDD.n2577 VDDD.n2553 0.00239457
R7380 VDDD.n2662 VDDD.n78 0.00239457
R7381 VDDD.n2668 VDDD.n2662 0.00239457
R7382 VDDD.n2649 VDDD.n2648 0.00239457
R7383 VDDD.n2667 VDDD.n79 0.00239457
R7384 VDDD.n84 VDDD.n76 0.00239457
R7385 VDDD.n2666 VDDD.n80 0.00239457
R7386 VDDD.n85 VDDD.n75 0.00239457
R7387 VDDD.n2665 VDDD.n81 0.00239457
R7388 VDDD.n86 VDDD.n74 0.00239457
R7389 VDDD.n2664 VDDD.n82 0.00239457
R7390 VDDD.n2663 VDDD.n73 0.00239457
R7391 VDDD.n2671 VDDD.n72 0.00239457
R7392 VDDD.n2647 VDDD.n83 0.00239457
R7393 a_6822_n13946.n2 a_6822_n13946.t4 82.7757
R7394 a_6822_n13946.n3 a_6822_n13946.t2 82.6414
R7395 a_6822_n13946.n1 a_6822_n13946.t3 70.3153
R7396 a_6822_n13946.n2 a_6822_n13946.t6 55.8254
R7397 a_6822_n13946.n4 a_6822_n13946.t7 51.5648
R7398 a_6822_n13946.n1 a_6822_n13946.t5 39.8548
R7399 a_6822_n13946.n0 a_6822_n13946.t0 6.02308
R7400 a_6822_n13946.n4 a_6822_n13946.n3 3.9695
R7401 a_6822_n13946.n0 a_6822_n13946.n4 3.3953
R7402 a_6822_n13946.n0 a_6822_n13946.n1 2.70724
R7403 a_6822_n13946.t1 a_6822_n13946.n0 2.47188
R7404 a_6822_n13946.n3 a_6822_n13946.n2 1.3073
R7405 a_12732_n13054.n1 a_12732_n13054.t4 75.0252
R7406 a_12732_n13054.n1 a_12732_n13054.t5 44.0697
R7407 a_12732_n13054.n2 a_12732_n13054.t0 10.6055
R7408 a_12732_n13054.n0 a_12732_n13054.t3 10.6055
R7409 a_12732_n13054.n0 a_12732_n13054.n2 8.89791
R7410 a_12732_n13054.n0 a_12732_n13054.n1 5.7951
R7411 a_12732_n13054.t1 a_12732_n13054.n0 4.53176
R7412 a_12732_n13054.n2 a_12732_n13054.t2 4.53041
R7413 a_12918_n14314.n2 a_12918_n14314.t1 11.0083
R7414 a_12918_n14314.n2 a_12918_n14314.n1 7.51324
R7415 a_12918_n14314.n1 a_12918_n14314.n0 5.39574
R7416 a_12918_n14314.n1 a_12918_n14314.t4 4.91281
R7417 a_12918_n14314.t2 a_12918_n14314.n2 4.12501
R7418 a_12918_n14314.n0 a_12918_n14314.t0 3.7821
R7419 a_12918_n14314.n0 a_12918_n14314.t3 3.77824
R7420 a_98110_n80.n3 a_98110_n80.t6 81.0083
R7421 a_98110_n80.n3 a_98110_n80.t7 80.9469
R7422 a_98110_n80.n2 a_98110_n80.t2 70.3153
R7423 a_98110_n80.n0 a_98110_n80.t5 54.8886
R7424 a_98110_n80.n2 a_98110_n80.t4 39.854
R7425 a_98110_n80.n0 a_98110_n80.t3 16.7884
R7426 a_98110_n80.n1 a_98110_n80.n0 9.8148
R7427 a_98110_n80.n1 a_98110_n80.t1 5.96645
R7428 a_98110_n80.n1 a_98110_n80.n2 2.69789
R7429 a_98110_n80.t0 a_98110_n80.n1 2.52942
R7430 a_98110_n80.n0 a_98110_n80.n3 1.30877
R7431 a_99002_n80.n0 a_99002_n80.t6 85.7557
R7432 a_99002_n80.n3 a_99002_n80.t2 70.3153
R7433 a_99002_n80.n2 a_99002_n80.t3 51.5037
R7434 a_99002_n80.n2 a_99002_n80.t7 51.1583
R7435 a_99002_n80.n3 a_99002_n80.t5 39.854
R7436 a_99002_n80.n0 a_99002_n80.t4 24.4279
R7437 a_99002_n80.n1 a_99002_n80.n0 7.82327
R7438 a_99002_n80.n1 a_99002_n80.t0 5.96645
R7439 a_99002_n80.n1 a_99002_n80.n3 2.73367
R7440 a_99002_n80.t1 a_99002_n80.n1 2.52942
R7441 a_99002_n80.n0 a_99002_n80.n2 1.30714
R7442 a_n21368_n3162.n1 a_n21368_n3162.t4 75.0252
R7443 a_n21368_n3162.n1 a_n21368_n3162.t5 44.0697
R7444 a_n21368_n3162.n2 a_n21368_n3162.t2 10.6055
R7445 a_n21368_n3162.n0 a_n21368_n3162.t1 10.6055
R7446 a_n21368_n3162.n2 a_n21368_n3162.n0 8.89791
R7447 a_n21368_n3162.n0 a_n21368_n3162.n1 5.7951
R7448 a_n21368_n3162.t0 a_n21368_n3162.n2 4.53176
R7449 a_n21368_n3162.n0 a_n21368_n3162.t3 4.53041
R7450 a_n22658_n4422.n0 a_n22658_n4422.t5 74.8588
R7451 a_n22658_n4422.n0 a_n22658_n4422.t6 44.2362
R7452 a_n22658_n4422.n0 a_n22658_n4422.n2 14.5242
R7453 a_n22658_n4422.n2 a_n22658_n4422.t4 11.0089
R7454 a_n22658_n4422.n3 a_n22658_n4422.n1 5.39574
R7455 a_n22658_n4422.t2 a_n22658_n4422.n3 4.91281
R7456 a_n22658_n4422.n2 a_n22658_n4422.t3 4.12461
R7457 a_n22658_n4422.n1 a_n22658_n4422.t1 3.7821
R7458 a_n22658_n4422.n1 a_n22658_n4422.t0 3.77824
R7459 a_n22658_n4422.n3 a_n22658_n4422.n0 1.83141
R7460 SAR_Asynchronous_Logic_0/D_reset_FF_0.Q.n1 SAR_Asynchronous_Logic_0/D_reset_FF_0.Q.t6 74.8588
R7461 SAR_Asynchronous_Logic_0/D_reset_FF_0.Q.n3 SAR_Asynchronous_Logic_0/D_reset_FF_0.Q.t5 70.3153
R7462 SAR_Asynchronous_Logic_0/D_reset_FF_0.Q.n1 SAR_Asynchronous_Logic_0/D_reset_FF_0.Q.t3 44.2362
R7463 SAR_Asynchronous_Logic_0/D_reset_FF_0.Q.n3 SAR_Asynchronous_Logic_0/D_reset_FF_0.Q.t4 39.8548
R7464 SAR_Asynchronous_Logic_0/D_reset_FF_0.Q.n4 SAR_Asynchronous_Logic_0/D_reset_FF_0.Q.n0 11.62
R7465 SAR_Asynchronous_Logic_0/D_reset_FF_0.Q.n0 SAR_Asynchronous_Logic_0/D_reset_FF_0.Q.n2 5.39574
R7466 SAR_Asynchronous_Logic_0/D_reset_FF_0.Q.n0 SAR_Asynchronous_Logic_0/D_reset_FF_0.Q.t0 4.91281
R7467 SAR_Asynchronous_Logic_0/D_reset_FF_0.Q.n2 SAR_Asynchronous_Logic_0/D_reset_FF_0.Q.t1 3.7821
R7468 SAR_Asynchronous_Logic_0/D_reset_FF_0.Q.n2 SAR_Asynchronous_Logic_0/D_reset_FF_0.Q.t2 3.77824
R7469 SAR_Asynchronous_Logic_0/D_reset_FF_0.Q.n0 SAR_Asynchronous_Logic_0/D_reset_FF_0.Q.n1 3.04186
R7470 SAR_Asynchronous_Logic_0/D_reset_FF_0.Q SAR_Asynchronous_Logic_0/D_reset_FF_0.Q.n4 2.86313
R7471 SAR_Asynchronous_Logic_0/D_reset_FF_0.Q.n4 SAR_Asynchronous_Logic_0/D_reset_FF_0.Q.n3 2.84345
R7472 a_n27210_n4422.n1 a_n27210_n4422.t2 11.0089
R7473 a_n27210_n4422.n2 a_n27210_n4422.n1 7.28488
R7474 a_n27210_n4422.n2 a_n27210_n4422.n0 5.39574
R7475 a_n27210_n4422.t3 a_n27210_n4422.n2 4.91281
R7476 a_n27210_n4422.n1 a_n27210_n4422.t4 4.12461
R7477 a_n27210_n4422.n0 a_n27210_n4422.t0 3.7821
R7478 a_n27210_n4422.n0 a_n27210_n4422.t1 3.77824
R7479 VSSD.n2546 VSSD.n2545 1.36185e+06
R7480 VSSD.n1770 VSSD.n1769 1.32723e+06
R7481 VSSD.n3158 VSSD.n332 1.32438e+06
R7482 VSSD.n2167 VSSD.n2166 1.32438e+06
R7483 VSSD.n2838 VSSD.n2837 1.32438e+06
R7484 VSSD.n2977 VSSD.n498 1.32438e+06
R7485 VSSD.n498 VSSD.t490 131481
R7486 VSSD.n2837 VSSD.t440 131481
R7487 VSSD.t111 VSSD.n332 131481
R7488 VSSD.n2167 VSSD.t486 131481
R7489 VSSD.n1786 VSSD.n1783 84017.2
R7490 VSSD.n2600 VSSD.n2599 84017.2
R7491 VSSD.n2432 VSSD.n2431 84017.2
R7492 VSSD.n2363 VSSD.n2362 84017.2
R7493 VSSD.n2224 VSSD.n2223 84017.2
R7494 VSSD.n2483 VSSD.n7 58383.9
R7495 VSSD.n1732 VSSD.n1099 38559.2
R7496 VSSD.n2599 VSSD.t244 37203
R7497 VSSD.t200 VSSD.n2432 37203
R7498 VSSD.t269 VSSD.n2224 37203
R7499 VSSD.t252 VSSD.n1786 37203
R7500 VSSD.n2362 VSSD.t204 37203
R7501 VSSD.n2482 VSSD.n2481 35999.1
R7502 VSSD.n2416 VSSD.n733 35999.1
R7503 VSSD.n2170 VSSD.n2169 35999.1
R7504 VSSD.n2548 VSSD.n2547 34750.2
R7505 VSSD.n2549 VSSD.n332 26374.5
R7506 VSSD.n2168 VSSD.n2167 26374.5
R7507 VSSD.n2837 VSSD.n2836 26374.5
R7508 VSSD.n2480 VSSD.n498 26374.5
R7509 VSSD.n3166 VSSD.t323 21832.5
R7510 VSSD.n2483 VSSD.n8 12361.5
R7511 VSSD.n980 VSSD.t75 11328.9
R7512 VSSD.n2464 VSSD.t401 11328.9
R7513 VSSD.n2226 VSSD.t86 11328.9
R7514 VSSD.n1788 VSSD.t279 11328.9
R7515 VSSD.n2820 VSSD.t326 11328.9
R7516 VSSD.n2557 VSSD.t291 11219.9
R7517 VSSD.n2428 VSSD.t692 11219.9
R7518 VSSD.n1664 VSSD.t414 11219.9
R7519 VSSD.n1781 VSSD.t285 11219.9
R7520 VSSD.n999 VSSD.t409 11219.9
R7521 VSSD.n2547 VSSD.n8 7528.07
R7522 VSSD.n2545 VSSD.n2486 7355.09
R7523 VSSD.n3664 VSSD.n8 6646.12
R7524 VSSD.n3665 VSSD.n3664 4839.67
R7525 VSSD.n2165 VSSD.n1102 4623.28
R7526 VSSD.n732 VSSD.n731 4623.28
R7527 VSSD.n2976 VSSD.n571 4623.28
R7528 VSSD.n3160 VSSD.n3159 4623.28
R7529 VSSD.n2483 VSSD.t303 4490.97
R7530 VSSD.n2166 VSSD.t584 4217.03
R7531 VSSD.t15 VSSD.n2838 4217.03
R7532 VSSD.t477 VSSD.n2977 4217.03
R7533 VSSD.n3158 VSSD.t114 4217.03
R7534 VSSD.t303 VSSD.t485 3027.17
R7535 VSSD.t485 VSSD.t20 3004.16
R7536 VSSD.t481 VSSD.t480 1839.34
R7537 VSSD.t330 VSSD.t218 1839.34
R7538 VSSD.t247 VSSD.t246 1839.34
R7539 VSSD.t29 VSSD.t28 1839.34
R7540 VSSD.t304 VSSD.t8 1839.34
R7541 VSSD.t463 VSSD.t462 1839.34
R7542 VSSD.t583 VSSD.t638 1839.34
R7543 VSSD.t23 VSSD.t22 1839.34
R7544 VSSD.t405 VSSD.t406 1839.34
R7545 VSSD.t635 VSSD.t634 1839.34
R7546 VSSD.t466 VSSD.t183 1839.34
R7547 VSSD.t480 VSSD.t434 1699.77
R7548 VSSD.t218 VSSD.t458 1699.77
R7549 VSSD.t246 VSSD.t430 1699.77
R7550 VSSD.t450 VSSD.t29 1699.77
R7551 VSSD.t605 VSSD.t304 1699.77
R7552 VSSD.t680 VSSD.t463 1699.77
R7553 VSSD.t638 VSSD.t599 1699.77
R7554 VSSD.t656 VSSD.t23 1699.77
R7555 VSSD.t406 VSSD.t454 1699.77
R7556 VSSD.t634 VSSD.t674 1699.77
R7557 VSSD.t183 VSSD.t138 1699.77
R7558 VSSD.n2027 VSSD.t584 1623.41
R7559 VSSD.n2839 VSSD.t15 1623.41
R7560 VSSD.n2978 VSSD.t477 1623.41
R7561 VSSD.t114 VSSD.n3157 1623.41
R7562 VSSD.t338 VSSD.t340 1568.87
R7563 VSSD.t333 VSSD.t334 1568.87
R7564 VSSD.t537 VSSD.t9 1568.87
R7565 VSSD.t632 VSSD.t190 1568.87
R7566 VSSD.t208 VSSD.t210 1568.87
R7567 VSSD.t58 VSSD.t56 1568.87
R7568 VSSD.t260 VSSD.t258 1568.87
R7569 VSSD.t540 VSSD.t543 1568.87
R7570 VSSD.t53 VSSD.t51 1568.87
R7571 VSSD.t352 VSSD.t350 1568.87
R7572 VSSD.t372 VSSD.t374 1568.87
R7573 VSSD.n1875 VSSD.t339 1547.62
R7574 VSSD.n3549 VSSD.t332 1547.62
R7575 VSSD.n989 VSSD.t534 1547.62
R7576 VSSD.n2841 VSSD.t191 1547.62
R7577 VSSD.n2980 VSSD.t211 1547.62
R7578 VSSD.n333 VSSD.t57 1547.62
R7579 VSSD.n2719 VSSD.t74 1547.62
R7580 VSSD.n2358 VSSD.t542 1547.62
R7581 VSSD.n1667 VSSD.t311 1547.62
R7582 VSSD.n2026 VSSD.t347 1547.62
R7583 VSSD.n3164 VSSD.t373 1547.62
R7584 VSSD.n2546 VSSD.n2483 1513.58
R7585 VSSD.t426 VSSD.t481 1400.69
R7586 VSSD.t422 VSSD.t330 1400.69
R7587 VSSD.t460 VSSD.t247 1400.69
R7588 VSSD.t28 VSSD.t688 1400.69
R7589 VSSD.t8 VSSD.t670 1400.69
R7590 VSSD.t462 VSSD.t140 1400.69
R7591 VSSD.t607 VSSD.t583 1400.69
R7592 VSSD.t22 VSSD.t682 1400.69
R7593 VSSD.t658 VSSD.t405 1400.69
R7594 VSSD.t617 VSSD.t635 1400.69
R7595 VSSD.t587 VSSD.t466 1400.69
R7596 VSSD.n2157 VSSD.n2156 1319.68
R7597 VSSD.n2129 VSSD.n2128 1319.68
R7598 VSSD.n2967 VSSD.n2966 1319.68
R7599 VSSD.n3111 VSSD.n3110 1319.68
R7600 VSSD.t148 VSSD.t495 1276.07
R7601 VSSD.t45 VSSD.t589 1276.07
R7602 VSSD.t212 VSSD.t18 1276.07
R7603 VSSD.t80 VSSD.t415 1276.07
R7604 VSSD.t503 VSSD.t41 1276.07
R7605 VSSD.t6 VSSD.t62 1276.07
R7606 VSSD.t161 VSSD.t497 1276.07
R7607 VSSD.t94 VSSD.t624 1276.07
R7608 VSSD.t501 VSSD.t16 1276.07
R7609 VSSD.t163 VSSD.t98 1276.07
R7610 VSSD.t184 VSSD.t39 1276.07
R7611 VSSD.t370 VSSD.t106 1261.12
R7612 VSSD.t30 VSSD.t102 1261.12
R7613 VSSD.t309 VSSD.t487 1261.12
R7614 VSSD.t593 VSSD.t275 1261.12
R7615 VSSD.t32 VSSD.t186 1261.12
R7616 VSSD.t636 VSSD.t446 1261.12
R7617 VSSD.t376 VSSD.t236 1261.12
R7618 VSSD.t271 VSSD.t96 1261.12
R7619 VSSD.t54 VSSD.t37 1261.12
R7620 VSSD.t649 VSSD.t242 1261.12
R7621 VSSD.t382 VSSD.t68 1261.12
R7622 VSSD.t572 VSSD.t338 1226.23
R7623 VSSD.t122 VSSD.t333 1226.23
R7624 VSSD.t570 VSSD.t537 1226.23
R7625 VSSD.t190 VSSD.t645 1226.23
R7626 VSSD.t210 VSSD.t544 1226.23
R7627 VSSD.t56 VSSD.t564 1226.23
R7628 VSSD.t219 VSSD.t260 1226.23
R7629 VSSD.t543 VSSD.t124 1226.23
R7630 VSSD.t179 VSSD.t53 1226.23
R7631 VSSD.t662 VSSD.t352 1226.23
R7632 VSSD.t47 VSSD.t372 1226.23
R7633 VSSD.n2545 VSSD.t315 1193.41
R7634 VSSD.n2547 VSSD.n2546 1183.92
R7635 VSSD.n2482 VSSD.n994 1175.64
R7636 VSSD.n2171 VSSD.n2170 1175.64
R7637 VSSD.n1784 VSSD.n1099 1175.64
R7638 VSSD.n2416 VSSD.n2415 1175.64
R7639 VSSD.t331 VSSD.n2549 1129.09
R7640 VSSD.n2168 VSSD.t88 1129.09
R7641 VSSD.n2836 VSSD.t327 1129.09
R7642 VSSD.n2480 VSSD.t666 1129.09
R7643 VSSD.n1770 VSSD.n1732 964.745
R7644 VSSD.n2978 VSSD.t490 888.524
R7645 VSSD.n2839 VSSD.t440 888.524
R7646 VSSD.n3157 VSSD.t111 888.524
R7647 VSSD.n2027 VSSD.t486 888.524
R7648 VSSD.n1781 VSSD.t282 792.307
R7649 VSSD.n3166 VSSD.t344 792.307
R7650 VSSD.n2557 VSSD.t290 792.307
R7651 VSSD.n2428 VSSD.t691 792.307
R7652 VSSD.n999 VSSD.t410 792.307
R7653 VSSD.n1664 VSSD.t411 792.307
R7654 VSSD.t49 VSSD.t148 767.639
R7655 VSSD.t495 VSSD.t426 767.639
R7656 VSSD.t434 VSSD.t370 767.639
R7657 VSSD.t106 VSSD.t572 767.639
R7658 VSSD.t548 VSSD.t45 767.639
R7659 VSSD.t589 VSSD.t422 767.639
R7660 VSSD.t458 VSSD.t30 767.639
R7661 VSSD.t102 VSSD.t122 767.639
R7662 VSSD.t130 VSSD.t212 767.639
R7663 VSSD.t18 VSSD.t460 767.639
R7664 VSSD.t430 VSSD.t309 767.639
R7665 VSSD.t487 VSSD.t570 767.639
R7666 VSSD.t645 VSSD.t593 767.639
R7667 VSSD.t275 VSSD.t450 767.639
R7668 VSSD.t688 VSSD.t80 767.639
R7669 VSSD.t415 VSSD.t552 767.639
R7670 VSSD.t544 VSSD.t32 767.639
R7671 VSSD.t186 VSSD.t605 767.639
R7672 VSSD.t670 VSSD.t503 767.639
R7673 VSSD.t41 VSSD.t556 767.639
R7674 VSSD.t564 VSSD.t636 767.639
R7675 VSSD.t446 VSSD.t680 767.639
R7676 VSSD.t140 VSSD.t6 767.639
R7677 VSSD.t62 VSSD.t227 767.639
R7678 VSSD.t171 VSSD.t161 767.639
R7679 VSSD.t497 VSSD.t607 767.639
R7680 VSSD.t599 VSSD.t376 767.639
R7681 VSSD.t236 VSSD.t219 767.639
R7682 VSSD.t624 VSSD.t562 767.639
R7683 VSSD.t682 VSSD.t94 767.639
R7684 VSSD.t96 VSSD.t656 767.639
R7685 VSSD.t124 VSSD.t271 767.639
R7686 VSSD.t202 VSSD.t501 767.639
R7687 VSSD.t16 VSSD.t658 767.639
R7688 VSSD.t454 VSSD.t54 767.639
R7689 VSSD.t37 VSSD.t179 767.639
R7690 VSSD.t242 VSSD.t662 767.639
R7691 VSSD.t674 VSSD.t649 767.639
R7692 VSSD.t98 VSSD.t617 767.639
R7693 VSSD.t169 VSSD.t163 767.639
R7694 VSSD.t68 VSSD.t47 767.639
R7695 VSSD.t138 VSSD.t382 767.639
R7696 VSSD.t39 VSSD.t587 767.639
R7697 VSSD.t128 VSSD.t184 767.639
R7698 VSSD.n3665 VSSD.n7 711.951
R7699 VSSD.t643 VSSD.n2484 692.169
R7700 VSSD.t359 VSSD.n2485 683.65
R7701 VSSD.n1874 VSSD.t283 635.181
R7702 VSSD.n3548 VSSD.t483 635.181
R7703 VSSD.n988 VSSD.t292 635.181
R7704 VSSD.t438 VSSD.n2842 635.181
R7705 VSSD.t493 VSSD.n2981 635.181
R7706 VSSD.t108 VSSD.n564 635.181
R7707 VSSD.n2718 VSSD.t668 635.181
R7708 VSSD.t448 VSSD.n2360 635.181
R7709 VSSD.n1666 VSSD.t412 635.181
R7710 VSSD.n2025 VSSD.t34 635.181
R7711 VSSD.n3163 VSSD.t342 635.181
R7712 VSSD.n1875 VSSD.t49 605.636
R7713 VSSD.n3549 VSSD.t548 605.636
R7714 VSSD.n989 VSSD.t130 605.636
R7715 VSSD.t552 VSSD.n2841 605.636
R7716 VSSD.t556 VSSD.n2980 605.636
R7717 VSSD.t227 VSSD.n333 605.636
R7718 VSSD.n2719 VSSD.t171 605.636
R7719 VSSD.t562 VSSD.n2358 605.636
R7720 VSSD.n1667 VSSD.t202 605.636
R7721 VSSD.n2026 VSSD.t169 605.636
R7722 VSSD.n3164 VSSD.t128 605.636
R7723 VSSD.t399 VSSD.t400 571.616
R7724 VSSD.t361 VSSD.t421 571.616
R7725 VSSD.t379 VSSD.t378 571.616
R7726 VSSD.t281 VSSD.t199 571.616
R7727 VSSD.t531 VSSD.t198 571.616
R7728 VSSD.n2843 VSSD.t13 564.456
R7729 VSSD.n2982 VSSD.t478 564.456
R7730 VSSD.n565 VSSD.t115 564.456
R7731 VSSD.n3162 VSSD.t154 564.456
R7732 VSSD.t144 VSSD.t399 528.241
R7733 VSSD.t615 VSSD.t361 528.241
R7734 VSSD.t611 VSSD.t379 528.241
R7735 VSSD.t609 VSSD.t281 528.241
R7736 VSSD.t652 VSSD.t531 528.241
R7737 VSSD.t391 VSSD.n1101 511.397
R7738 VSSD.t348 VSSD.n682 511.397
R7739 VSSD.n562 VSSD.t264 511.397
R7740 VSSD.n3161 VSSD.t117 511.397
R7741 VSSD.t76 VSSD.t651 483.538
R7742 VSSD.t403 VSSD.t402 483.538
R7743 VSSD.t84 VSSD.t87 483.538
R7744 VSSD.t277 VSSD.t280 483.538
R7745 VSSD.t324 VSSD.t419 483.538
R7746 VSSD.n2497 VSSD.n7 474.634
R7747 VSSD.n1781 VSSD.t150 469.086
R7748 VSSD.n3166 VSSD.t188 469.086
R7749 VSSD.n2557 VSSD.t214 469.086
R7750 VSSD.n2428 VSSD.t120 469.086
R7751 VSSD.t273 VSSD.n999 469.086
R7752 VSSD.t499 VSSD.n1664 469.086
R7753 VSSD.t400 VSSD.t456 435.296
R7754 VSSD.t421 VSSD.t136 435.296
R7755 VSSD.t378 VSSD.t436 435.296
R7756 VSSD.t199 VSSD.t601 435.296
R7757 VSSD.t198 VSSD.t603 435.296
R7758 VSSD.t580 VSSD.t72 396.568
R7759 VSSD.t146 VSSD.t475 396.568
R7760 VSSD.t591 VSSD.t229 396.568
R7761 VSSD.t78 VSSD.t250 396.568
R7762 VSSD.t321 VSSD.t206 396.568
R7763 VSSD.t296 VSSD.t538 391.921
R7764 VSSD.t678 VSSD.t576 391.921
R7765 VSSD.t380 VSSD.t368 391.921
R7766 VSSD.t240 VSSD.t254 391.921
R7767 VSSD.t389 VSSD.t357 391.921
R7768 VSSD.t651 VSSD.t256 381.077
R7769 VSSD.t402 VSSD.t181 381.077
R7770 VSSD.t87 VSSD.t469 381.077
R7771 VSSD.t280 VSSD.t175 381.077
R7772 VSSD.t419 VSSD.t554 381.077
R7773 VSSD.n1876 VSSD.n1875 375.988
R7774 VSSD.n3550 VSSD.n3549 375.988
R7775 VSSD.n990 VSSD.n989 375.988
R7776 VSSD.n2841 VSSD.n2840 375.988
R7777 VSSD.n2980 VSSD.n2979 375.988
R7778 VSSD.n3156 VSSD.n333 375.988
R7779 VSSD.n2720 VSSD.n2719 375.988
R7780 VSSD.n2358 VSSD.n2357 375.988
R7781 VSSD.n1668 VSSD.n1667 375.988
R7782 VSSD.n2028 VSSD.n2026 375.988
R7783 VSSD.n3165 VSSD.n3164 375.988
R7784 VSSD.t417 VSSD.n2839 372.868
R7785 VSSD.t4 VSSD.n2978 372.868
R7786 VSSD.n3157 VSSD.t64 372.868
R7787 VSSD.t165 VSSD.n2027 372.868
R7788 VSSD.n2562 VSSD.n2561 343.502
R7789 VSSD.n2469 VSSD.n2468 343.502
R7790 VSSD.n2229 VSSD.n2228 343.502
R7791 VSSD.n1791 VSSD.n1790 343.502
R7792 VSSD.n2825 VSSD.n2824 343.502
R7793 VSSD.t160 VSSD.t248 322.034
R7794 VSSD.t489 VSSD.t690 322.034
R7795 VSSD.t420 VSSD.t93 322.034
R7796 VSSD.t263 VSSD.t667 322.034
R7797 VSSD.t623 VSSD.t582 322.034
R7798 VSSD.t340 VSSD.n1874 319.63
R7799 VSSD.t334 VSSD.n3548 319.63
R7800 VSSD.t9 VSSD.n988 319.63
R7801 VSSD.n2842 VSSD.t632 319.63
R7802 VSSD.n2981 VSSD.t208 319.63
R7803 VSSD.n564 VSSD.t58 319.63
R7804 VSSD.t258 VSSD.n2718 319.63
R7805 VSSD.n2360 VSSD.t540 319.63
R7806 VSSD.t51 VSSD.n1666 319.63
R7807 VSSD.t350 VSSD.n2025 319.63
R7808 VSSD.t374 VSSD.n3163 319.63
R7809 VSSD.n1876 VSSD.t150 314.923
R7810 VSSD.n3550 VSSD.t20 314.923
R7811 VSSD.t214 VSSD.n990 314.923
R7812 VSSD.n2840 VSSD.t417 314.923
R7813 VSSD.n2979 VSSD.t4 314.923
R7814 VSSD.t64 VSSD.n3156 314.923
R7815 VSSD.n2720 VSSD.t120 314.923
R7816 VSSD.n2357 VSSD.t273 314.923
R7817 VSSD.n1668 VSSD.t499 314.923
R7818 VSSD.n2028 VSSD.t165 314.923
R7819 VSSD.t188 VSSD.n3165 314.923
R7820 VSSD.t654 VSSD.t160 297.598
R7821 VSSD.t428 VSSD.t489 297.598
R7822 VSSD.t93 VSSD.t432 297.598
R7823 VSSD.t667 VSSD.t613 297.598
R7824 VSSD.t582 VSSD.t686 297.598
R7825 VSSD.t660 VSSD.n980 293.553
R7826 VSSD.t132 VSSD.n2464 293.553
R7827 VSSD.t550 VSSD.n2226 293.553
R7828 VSSD.t126 VSSD.n1788 293.553
R7829 VSSD.t568 VSSD.n2820 293.553
R7830 VSSD.t232 VSSD.t234 271.416
R7831 VSSD.t620 VSSD.t622 271.416
R7832 VSSD.t27 VSSD.t25 271.416
R7833 VSSD.t314 VSSD.t312 271.416
R7834 VSSD.t235 VSSD.t298 271.416
R7835 VSSD.n1783 VSSD.t283 266.219
R7836 VSSD.n2484 VSSD.t483 266.219
R7837 VSSD.n2485 VSSD.t643 266.219
R7838 VSSD.n2486 VSSD.t359 266.219
R7839 VSSD.n2600 VSSD.t292 266.219
R7840 VSSD.n2843 VSSD.t438 266.219
R7841 VSSD.n2982 VSSD.t493 266.219
R7842 VSSD.n565 VSSD.t108 266.219
R7843 VSSD.n2431 VSSD.t668 266.219
R7844 VSSD.n2363 VSSD.t448 266.219
R7845 VSSD.n2223 VSSD.t412 266.219
R7846 VSSD.n1733 VSSD.t34 266.219
R7847 VSSD.t342 VSSD.n3162 266.219
R7848 VSSD.t664 VSSD.t231 255.707
R7849 VSSD.t647 VSSD.t619 255.707
R7850 VSSD.t24 VSSD.t546 255.707
R7851 VSSD.t249 VSSD.t566 255.707
R7852 VSSD.t300 VSSD.t221 255.707
R7853 VSSD.t248 VSSD.t672 245.234
R7854 VSSD.t690 VSSD.t142 245.234
R7855 VSSD.t597 VSSD.t420 245.234
R7856 VSSD.t452 VSSD.t263 245.234
R7857 VSSD.t424 VSSD.t623 245.234
R7858 VSSD.n2550 VSSD.t331 240.989
R7859 VSSD.n1657 VSSD.t88 240.989
R7860 VSSD.t327 VSSD.n2835 240.989
R7861 VSSD.t666 VSSD.n2479 240.989
R7862 VSSD.t256 VSSD.t296 238.561
R7863 VSSD.t538 VSSD.t144 238.561
R7864 VSSD.t456 VSSD.t580 238.561
R7865 VSSD.t72 VSSD.t660 238.561
R7866 VSSD.t181 VSSD.t678 238.561
R7867 VSSD.t576 VSSD.t615 238.561
R7868 VSSD.t136 VSSD.t146 238.561
R7869 VSSD.t475 VSSD.t132 238.561
R7870 VSSD.t469 VSSD.t380 238.561
R7871 VSSD.t368 VSSD.t611 238.561
R7872 VSSD.t436 VSSD.t591 238.561
R7873 VSSD.t229 VSSD.t550 238.561
R7874 VSSD.t175 VSSD.t240 238.561
R7875 VSSD.t254 VSSD.t609 238.561
R7876 VSSD.t601 VSSD.t78 238.561
R7877 VSSD.t250 VSSD.t126 238.561
R7878 VSSD.t554 VSSD.t389 238.561
R7879 VSSD.t357 VSSD.t652 238.561
R7880 VSSD.t603 VSSD.t321 238.561
R7881 VSSD.t206 VSSD.t568 238.561
R7882 VSSD.t639 VSSD.t0 223.417
R7883 VSSD.t397 VSSD.t626 223.417
R7884 VSSD.t336 VSSD.t104 223.417
R7885 VSSD.t641 VSSD.t301 223.417
R7886 VSSD.t305 VSSD.t366 223.417
R7887 VSSD.t523 VSSD.n2560 222.496
R7888 VSSD.t515 VSSD.n2466 222.496
R7889 VSSD.t521 VSSD.n2227 222.496
R7890 VSSD.t511 VSSD.n1789 222.496
R7891 VSSD.t513 VSSD.n2822 222.496
R7892 VSSD.t407 VSSD.t70 220.798
R7893 VSSD.t362 VSSD.t491 220.798
R7894 VSSD.t473 VSSD.t393 220.798
R7895 VSSD.t225 VSSD.t395 220.798
R7896 VSSD.t630 VSSD.t507 220.798
R7897 VSSD.t234 VSSD.t173 214.69
R7898 VSSD.t622 VSSD.t558 214.69
R7899 VSSD.t560 VSSD.t27 214.69
R7900 VSSD.t223 VSSD.t314 214.69
R7901 VSSD.t307 VSSD.t235 214.69
R7902 VSSD.n1102 VSSD.t391 199.143
R7903 VSSD.n1101 VSSD.t13 199.143
R7904 VSSD.n731 VSSD.t348 199.143
R7905 VSSD.n682 VSSD.t478 199.143
R7906 VSSD.n571 VSSD.t264 199.143
R7907 VSSD.t115 VSSD.n562 199.143
R7908 VSSD.t117 VSSD.n3160 199.143
R7909 VSSD.t154 VSSD.n3161 199.143
R7910 VSSD.n1745 VSSD.n1744 191.999
R7911 VSSD.n2111 VSSD.n2110 191.999
R7912 VSSD.n2115 VSSD.n2114 191.999
R7913 VSSD.n3101 VSSD.n3100 191.999
R7914 VSSD.n3175 VSSD.n3174 191.999
R7915 VSSD.n1767 VSSD.n1733 185.288
R7916 VSSD.n2598 VSSD.n980 184.374
R7917 VSSD.n2464 VSSD.n2463 184.374
R7918 VSSD.n2226 VSSD.n2225 184.374
R7919 VSSD.n1788 VSSD.n1787 184.374
R7920 VSSD.n2820 VSSD.n2819 184.374
R7921 VSSD.n2548 VSSD.n2482 180.575
R7922 VSSD.n2169 VSSD.n1099 180.575
R7923 VSSD.n2170 VSSD.n733 180.575
R7924 VSSD.n2481 VSSD.n2416 180.575
R7925 VSSD.n2549 VSSD.n2548 178.034
R7926 VSSD.n2169 VSSD.n2168 178.034
R7927 VSSD.n2836 VSSD.n733 178.034
R7928 VSSD.n2481 VSSD.n2480 178.034
R7929 VSSD.n979 VSSD.t238 169.084
R7930 VSSD.n2430 VSSD.t676 169.084
R7931 VSSD.t444 VSSD.n1098 169.084
R7932 VSSD.n1785 VSSD.t364 169.084
R7933 VSSD.n2361 VSSD.t294 169.084
R7934 VSSD.n1766 VSSD.t231 167.125
R7935 VSSD.n2155 VSSD.t619 167.125
R7936 VSSD.n2117 VSSD.t24 167.125
R7937 VSSD.n2965 VSSD.t249 167.125
R7938 VSSD.n3109 VSSD.t300 167.125
R7939 VSSD.t574 VSSD.t575 166.01
R7940 VSSD.n2559 VSSD.n2557 159.209
R7941 VSSD.n2429 VSSD.n2428 159.209
R7942 VSSD.n1664 VSSD.n1095 159.209
R7943 VSSD.n1782 VSSD.n1781 159.209
R7944 VSSD.n999 VSSD.n744 159.209
R7945 VSSD.n3666 VSSD.t119 158.38
R7946 VSSD.t684 VSSD.t574 153.412
R7947 VSSD.t505 VSSD.n2559 142.867
R7948 VSSD.n2562 VSSD.t505 142.867
R7949 VSSD.t192 VSSD.n2429 142.867
R7950 VSSD.t192 VSSD.n2469 142.867
R7951 VSSD.t91 VSSD.n1095 142.867
R7952 VSSD.t91 VSSD.n2229 142.867
R7953 VSSD.t387 VSSD.n1782 142.867
R7954 VSSD.t387 VSSD.n1791 142.867
R7955 VSSD.t328 VSSD.n744 142.867
R7956 VSSD.t328 VSSD.n2825 142.867
R7957 VSSD.t353 VSSD.t355 139.917
R7958 VSSD.t0 VSSD.t664 134.399
R7959 VSSD.t672 VSSD.t639 134.399
R7960 VSSD.t70 VSSD.t654 134.399
R7961 VSSD.t173 VSSD.t407 134.399
R7962 VSSD.t626 VSSD.t647 134.399
R7963 VSSD.t142 VSSD.t397 134.399
R7964 VSSD.t491 VSSD.t428 134.399
R7965 VSSD.t558 VSSD.t362 134.399
R7966 VSSD.t546 VSSD.t336 134.399
R7967 VSSD.t104 VSSD.t597 134.399
R7968 VSSD.t432 VSSD.t473 134.399
R7969 VSSD.t393 VSSD.t560 134.399
R7970 VSSD.t566 VSSD.t641 134.399
R7971 VSSD.t301 VSSD.t452 134.399
R7972 VSSD.t613 VSSD.t225 134.399
R7973 VSSD.t395 VSSD.t223 134.399
R7974 VSSD.t221 VSSD.t305 134.399
R7975 VSSD.t366 VSSD.t424 134.399
R7976 VSSD.t686 VSSD.t630 134.399
R7977 VSSD.t507 VSSD.t307 134.399
R7978 VSSD.t167 VSSD.t356 131.819
R7979 VSSD.t575 VSSD.t595 126.419
R7980 VSSD.t519 VSSD.n1735 124.362
R7981 VSSD.t517 VSSD.n2109 124.362
R7982 VSSD.n2116 VSSD.t525 124.362
R7983 VSSD.n2964 VSSD.t527 124.362
R7984 VSSD.n3108 VSSD.t509 124.362
R7985 VSSD.t532 VSSD.t317 115.172
R7986 VSSD.t319 VSSD.t467 113.823
R7987 VSSD.t355 VSSD.t177 110.674
R7988 VSSD.t152 VSSD.n1768 109.793
R7989 VSSD.n3167 VSSD.n3166 108.938
R7990 VSSD.t482 VSSD.n2503 99.8759
R7991 VSSD.n2507 VSSD.n2506 98.9761
R7992 VSSD.t244 VSSD.n2598 98.7247
R7993 VSSD.n2463 VSSD.t200 98.7247
R7994 VSSD.n2225 VSSD.t269 98.7247
R7995 VSSD.n1787 VSSD.t252 98.7247
R7996 VSSD.n2819 VSSD.t204 98.7247
R7997 VSSD.n2561 VSSD.t523 97.5864
R7998 VSSD.n2560 VSSD.t76 97.5864
R7999 VSSD.n2468 VSSD.t515 97.5864
R8000 VSSD.n2466 VSSD.t403 97.5864
R8001 VSSD.n2228 VSSD.t521 97.5864
R8002 VSSD.n2227 VSSD.t84 97.5864
R8003 VSSD.n1790 VSSD.t511 97.5864
R8004 VSSD.n1789 VSSD.t277 97.5864
R8005 VSSD.n2824 VSSD.t513 97.5864
R8006 VSSD.n2822 VSSD.t324 97.5864
R8007 VSSD.n2557 VSSD.n2556 95.9833
R8008 VSSD.n1664 VSSD.n1663 95.9833
R8009 VSSD.n999 VSSD.n998 95.9833
R8010 VSSD.n2428 VSSD.n2427 95.9833
R8011 VSSD.n1781 VSSD.n1780 95.4378
R8012 VSSD.n2550 VSSD.t535 94.4352
R8013 VSSD.n2556 VSSD.t535 94.4352
R8014 VSSD.n1657 VSSD.t100 94.4352
R8015 VSSD.n1663 VSSD.t100 94.4352
R8016 VSSD.n2835 VSSD.t66 94.4352
R8017 VSSD.n998 VSSD.t66 94.4352
R8018 VSSD.n2479 VSSD.t464 94.4352
R8019 VSSD.n2427 VSSD.t464 94.4352
R8020 VSSD.n1771 VSSD.t60 93.8985
R8021 VSSD.n1780 VSSD.t60 93.8985
R8022 VSSD.n2504 VSSD.t482 87.9538
R8023 VSSD.t119 VSSD.n3665 87.4992
R8024 VSSD.n2544 VSSD.t356 86.1543
R8025 VSSD.t134 VSSD.n1767 81.4044
R8026 VSSD.n1744 VSSD.t585 79.8542
R8027 VSSD.t585 VSSD.n1109 79.8542
R8028 VSSD.t11 VSSD.n2111 79.8542
R8029 VSSD.t11 VSSD.n2130 79.8542
R8030 VSSD.n2114 VSSD.t261 79.8542
R8031 VSSD.n2963 VSSD.t261 79.8542
R8032 VSSD.n3101 VSSD.t112 79.8542
R8033 VSSD.n3107 VSSD.t112 79.8542
R8034 VSSD.n3174 VSSD.t156 79.8542
R8035 VSSD.n3167 VSSD.t156 79.8542
R8036 VSSD.n2599 VSSD.t345 77.9584
R8037 VSSD.n2432 VSSD.t194 77.9584
R8038 VSSD.n2224 VSSD.t89 77.9584
R8039 VSSD.n1786 VSSD.t385 77.9584
R8040 VSSD.n2362 VSSD.t43 77.9584
R8041 VSSD.n2164 VSSD.n1103 72.3822
R8042 VSSD.n2125 VSSD.n2124 72.3822
R8043 VSSD.n2975 VSSD.n572 72.3822
R8044 VSSD.n392 VSSD.n331 72.3822
R8045 VSSD.n2166 VSSD.n2165 71.6917
R8046 VSSD.n2838 VSSD.n732 71.6917
R8047 VSSD.n2977 VSSD.n2976 71.6917
R8048 VSSD.n3159 VSSD.n3158 71.6917
R8049 VSSD.t177 VSSD.t319 69.2834
R8050 VSSD.t467 VSSD.t684 69.2834
R8051 VSSD.t595 VSSD.t532 69.2834
R8052 VSSD.t317 VSSD.t167 69.2834
R8053 VSSD.n2165 VSSD.n2164 68.4863
R8054 VSSD.n2124 VSSD.n732 68.4863
R8055 VSSD.n2976 VSSD.n2975 68.4863
R8056 VSSD.n3159 VSSD.n331 68.4863
R8057 VSSD.t345 VSSD.n979 65.8433
R8058 VSSD.n3663 VSSD.t238 65.8433
R8059 VSSD.t194 VSSD.n2430 65.8433
R8060 VSSD.t676 VSSD.n994 65.8433
R8061 VSSD.n1098 VSSD.t89 65.8433
R8062 VSSD.n2171 VSSD.t444 65.8433
R8063 VSSD.t385 VSSD.n1785 65.8433
R8064 VSSD.t364 VSSD.n1784 65.8433
R8065 VSSD.t43 VSSD.n2361 65.8433
R8066 VSSD.n2415 VSSD.t294 65.8433
R8067 VSSD.n2157 VSSD.t471 64.7955
R8068 VSSD.n2128 VSSD.t216 64.7955
R8069 VSSD.n2967 VSSD.t82 64.7955
R8070 VSSD.n3111 VSSD.t288 64.7955
R8071 VSSD.n1767 VSSD.t2 64.5816
R8072 VSSD.n2156 VSSD.t628 64.5816
R8073 VSSD.n2129 VSSD.t196 64.5816
R8074 VSSD.n2966 VSSD.t286 64.5816
R8075 VSSD.n3110 VSSD.t266 64.5816
R8076 VSSD.t529 VSSD.n2505 64.1097
R8077 VSSD.n2156 VSSD.n1109 63.7089
R8078 VSSD.n2130 VSSD.n2129 63.7089
R8079 VSSD.n2966 VSSD.n2963 63.7089
R8080 VSSD.n3110 VSSD.n3107 63.7089
R8081 VSSD.n3166 VSSD.n6 63.081
R8082 VSSD.n391 VSSD.n388 62.7242
R8083 VSSD.n3112 VSSD.n391 62.7242
R8084 VSSD.n3112 VSSD.n387 62.7242
R8085 VSSD.n388 VSSD.n387 62.7242
R8086 VSSD.n3168 VSSD.n329 62.7242
R8087 VSSD.n3168 VSSD.n330 62.7242
R8088 VSSD.n3173 VSSD.n330 62.7242
R8089 VSSD.n3173 VSSD.n329 62.7242
R8090 VSSD.n3106 VSSD.n393 62.7242
R8091 VSSD.n3106 VSSD.n394 62.7242
R8092 VSSD.n3102 VSSD.n394 62.7242
R8093 VSSD.n3102 VSSD.n393 62.7242
R8094 VSSD.n2974 VSSD.n2969 62.7242
R8095 VSSD.n2969 VSSD.n2968 62.7242
R8096 VSSD.n2968 VSSD.n573 62.7242
R8097 VSSD.n2974 VSSD.n573 62.7242
R8098 VSSD.n2426 VSSD.n2417 62.7242
R8099 VSSD.n2426 VSSD.n2418 62.7242
R8100 VSSD.n2478 VSSD.n2418 62.7242
R8101 VSSD.n2478 VSSD.n2417 62.7242
R8102 VSSD.n2828 VSSD.n743 62.7242
R8103 VSSD.n2829 VSSD.n743 62.7242
R8104 VSSD.n2829 VSSD.n742 62.7242
R8105 VSSD.n2828 VSSD.n742 62.7242
R8106 VSSD.n997 VSSD.n734 62.7242
R8107 VSSD.n997 VSSD.n735 62.7242
R8108 VSSD.n2834 VSSD.n735 62.7242
R8109 VSSD.n2834 VSSD.n734 62.7242
R8110 VSSD.n2126 VSSD.n2119 62.7242
R8111 VSSD.n2127 VSSD.n2126 62.7242
R8112 VSSD.n2127 VSSD.n2118 62.7242
R8113 VSSD.n2119 VSSD.n2118 62.7242
R8114 VSSD.n2962 VSSD.n574 62.7242
R8115 VSSD.n2962 VSSD.n575 62.7242
R8116 VSSD.n2113 VSSD.n575 62.7242
R8117 VSSD.n2113 VSSD.n574 62.7242
R8118 VSSD.n2133 VSSD.n2108 62.7242
R8119 VSSD.n2134 VSSD.n2108 62.7242
R8120 VSSD.n2134 VSSD.n2107 62.7242
R8121 VSSD.n2133 VSSD.n2107 62.7242
R8122 VSSD.n2163 VSSD.n1105 62.7242
R8123 VSSD.n2158 VSSD.n1105 62.7242
R8124 VSSD.n2158 VSSD.n1104 62.7242
R8125 VSSD.n2163 VSSD.n1104 62.7242
R8126 VSSD.n1662 VSSD.n1654 62.7242
R8127 VSSD.n1662 VSSD.n1655 62.7242
R8128 VSSD.n1658 VSSD.n1655 62.7242
R8129 VSSD.n1658 VSSD.n1654 62.7242
R8130 VSSD.n1795 VSSD.n1728 62.7242
R8131 VSSD.n1796 VSSD.n1728 62.7242
R8132 VSSD.n1796 VSSD.n1727 62.7242
R8133 VSSD.n1795 VSSD.n1727 62.7242
R8134 VSSD.n1779 VSSD.n1729 62.7242
R8135 VSSD.n1779 VSSD.n1730 62.7242
R8136 VSSD.n1772 VSSD.n1730 62.7242
R8137 VSSD.n1772 VSSD.n1729 62.7242
R8138 VSSD.n1738 VSSD.n1736 62.7242
R8139 VSSD.n1738 VSSD.n1737 62.7242
R8140 VSSD.n1743 VSSD.n1737 62.7242
R8141 VSSD.n1743 VSSD.n1736 62.7242
R8142 VSSD.n2232 VSSD.n1094 62.7242
R8143 VSSD.n2233 VSSD.n1094 62.7242
R8144 VSSD.n2233 VSSD.n1093 62.7242
R8145 VSSD.n2232 VSSD.n1093 62.7242
R8146 VSSD.n2472 VSSD.n2425 62.7242
R8147 VSSD.n2473 VSSD.n2425 62.7242
R8148 VSSD.n2473 VSSD.n2424 62.7242
R8149 VSSD.n2472 VSSD.n2424 62.7242
R8150 VSSD.n2555 VSSD.n991 62.7242
R8151 VSSD.n2555 VSSD.n992 62.7242
R8152 VSSD.n2551 VSSD.n992 62.7242
R8153 VSSD.n2551 VSSD.n991 62.7242
R8154 VSSD.n2563 VSSD.n987 62.7242
R8155 VSSD.n2563 VSSD.n984 62.7242
R8156 VSSD.n2558 VSSD.n984 62.7242
R8157 VSSD.n2558 VSSD.n987 62.7242
R8158 VSSD.n3669 VSSD.n5 62.7242
R8159 VSSD.n3670 VSSD.n5 62.7242
R8160 VSSD.n3670 VSSD.n4 62.7242
R8161 VSSD.n3669 VSSD.n4 62.7242
R8162 VSSD.n2510 VSSD.n2493 62.7242
R8163 VSSD.n2511 VSSD.n2493 62.7242
R8164 VSSD.n2511 VSSD.n2492 62.7242
R8165 VSSD.n2510 VSSD.n2492 62.7242
R8166 VSSD.n2502 VSSD.n2494 62.7242
R8167 VSSD.n2502 VSSD.n2495 62.7242
R8168 VSSD.n2498 VSSD.n2495 62.7242
R8169 VSSD.n2498 VSSD.n2494 62.7242
R8170 VSSD.t442 VSSD.n6 62.0635
R8171 VSSD.t442 VSSD.n3666 62.0635
R8172 VSSD.t2 VSSD.n1766 54.5453
R8173 VSSD.n1735 VSSD.t232 54.5453
R8174 VSSD.n1745 VSSD.t519 54.5453
R8175 VSSD.t628 VSSD.n2155 54.5453
R8176 VSSD.n2109 VSSD.t620 54.5453
R8177 VSSD.n2110 VSSD.t517 54.5453
R8178 VSSD.t196 VSSD.n2117 54.5453
R8179 VSSD.t25 VSSD.n2116 54.5453
R8180 VSSD.t525 VSSD.n2115 54.5453
R8181 VSSD.t286 VSSD.n2965 54.5453
R8182 VSSD.t312 VSSD.n2964 54.5453
R8183 VSSD.n3100 VSSD.t527 54.5453
R8184 VSSD.t266 VSSD.n3109 54.5453
R8185 VSSD.t298 VSSD.n3108 54.5453
R8186 VSSD.n3175 VSSD.t509 54.5453
R8187 VSSD.n3664 VSSD.n3663 50.5678
R8188 VSSD.n1769 VSSD.t152 42.7547
R8189 VSSD.n1768 VSSD.t134 42.7547
R8190 VSSD.n2497 VSSD.t158 41.1654
R8191 VSSD.n2503 VSSD.t158 41.1654
R8192 VSSD.t578 VSSD.n2504 41.1654
R8193 VSSD.t578 VSSD.n2507 41.1654
R8194 VSSD.n2506 VSSD.t529 28.1186
R8195 VSSD.n2505 VSSD.t353 28.1186
R8196 VSSD.t315 VSSD.n2544 28.1186
R8197 VSSD.n1771 VSSD.n1770 17.9591
R8198 VSSD.n3113 VSSD.n384 16.8435
R8199 VSSD.n2970 VSSD.n454 16.8435
R8200 VSSD.n2475 VSSD.n2420 16.8435
R8201 VSSD.n2831 VSSD.n737 16.8435
R8202 VSSD.n2120 VSSD.n637 16.8435
R8203 VSSD.n2159 VSSD.n1106 16.8435
R8204 VSSD.n1661 VSSD.n1092 16.8435
R8205 VSSD.n2554 VSSD.n983 16.8435
R8206 VSSD.n3671 VSSD.n1 16.8435
R8207 VSSD.n2501 VSSD.n2491 16.8435
R8208 VSSD.n1732 VSSD.t384 15.9268
R8209 VSSD.n3113 VSSD.n385 12.6098
R8210 VSSD.n2971 VSSD.n454 12.6098
R8211 VSSD.n2476 VSSD.n2475 12.6098
R8212 VSSD.n2832 VSSD.n2831 12.6098
R8213 VSSD.n2122 VSSD.n637 12.6098
R8214 VSSD.n2160 VSSD.n2159 12.6098
R8215 VSSD.n1656 VSSD.n1092 12.6098
R8216 VSSD.n993 VSSD.n983 12.6098
R8217 VSSD.n3671 VSSD.n2 12.6098
R8218 VSSD.n2496 VSSD.n2491 12.6098
R8219 VSSD.n1893 VSSD.n1879 4.5005
R8220 VSSD.n1888 VSSD.n1879 4.5005
R8221 VSSD.n1888 VSSD.n1500 4.5005
R8222 VSSD.n1888 VSSD.n1884 4.5005
R8223 VSSD.n1888 VSSD.n1498 4.5005
R8224 VSSD.n1888 VSSD.n1885 4.5005
R8225 VSSD.n1900 VSSD.n1888 4.5005
R8226 VSSD.n1899 VSSD.n1879 4.5005
R8227 VSSD.n1899 VSSD.n1881 4.5005
R8228 VSSD.n1899 VSSD.n1499 4.5005
R8229 VSSD.n1899 VSSD.n1884 4.5005
R8230 VSSD.n1899 VSSD.n1885 4.5005
R8231 VSSD.n1900 VSSD.n1899 4.5005
R8232 VSSD.n1886 VSSD.n1879 4.5005
R8233 VSSD.n1886 VSSD.n1880 4.5005
R8234 VSSD.n1886 VSSD.n1500 4.5005
R8235 VSSD.n1886 VSSD.n1881 4.5005
R8236 VSSD.n1886 VSSD.n1499 4.5005
R8237 VSSD.n1886 VSSD.n1884 4.5005
R8238 VSSD.n1886 VSSD.n1885 4.5005
R8239 VSSD.n1900 VSSD.n1886 4.5005
R8240 VSSD.n1901 VSSD.n1879 4.5005
R8241 VSSD.n1901 VSSD.n1880 4.5005
R8242 VSSD.n1901 VSSD.n1500 4.5005
R8243 VSSD.n1901 VSSD.n1881 4.5005
R8244 VSSD.n1901 VSSD.n1499 4.5005
R8245 VSSD.n1901 VSSD.n1884 4.5005
R8246 VSSD.n1901 VSSD.n1498 4.5005
R8247 VSSD.n1901 VSSD.n1885 4.5005
R8248 VSSD.n1901 VSSD.n1900 4.5005
R8249 VSSD.n1864 VSSD.n1529 4.5005
R8250 VSSD.n1864 VSSD.n1863 4.5005
R8251 VSSD.n1535 VSSD.n1524 4.5005
R8252 VSSD.n1863 VSSD.n1524 4.5005
R8253 VSSD.n1536 VSSD.n1535 4.5005
R8254 VSSD.n1844 VSSD.n1536 4.5005
R8255 VSSD.n1538 VSSD.n1536 4.5005
R8256 VSSD.n1846 VSSD.n1536 4.5005
R8257 VSSD.n1537 VSSD.n1536 4.5005
R8258 VSSD.n1861 VSSD.n1536 4.5005
R8259 VSSD.n1536 VSSD.n1529 4.5005
R8260 VSSD.n1863 VSSD.n1536 4.5005
R8261 VSSD.n1535 VSSD.n1532 4.5005
R8262 VSSD.n1844 VSSD.n1532 4.5005
R8263 VSSD.n1538 VSSD.n1532 4.5005
R8264 VSSD.n1846 VSSD.n1532 4.5005
R8265 VSSD.n1537 VSSD.n1532 4.5005
R8266 VSSD.n1861 VSSD.n1532 4.5005
R8267 VSSD.n1863 VSSD.n1532 4.5005
R8268 VSSD.n1862 VSSD.n1844 4.5005
R8269 VSSD.n1862 VSSD.n1538 4.5005
R8270 VSSD.n1862 VSSD.n1846 4.5005
R8271 VSSD.n1862 VSSD.n1537 4.5005
R8272 VSSD.n1862 VSSD.n1861 4.5005
R8273 VSSD.n1862 VSSD.n1529 4.5005
R8274 VSSD.n1863 VSSD.n1862 4.5005
R8275 VSSD.n1548 VSSD.n1543 4.5005
R8276 VSSD.n1548 VSSD.n1544 4.5005
R8277 VSSD.n1548 VSSD.n1542 4.5005
R8278 VSSD.n1548 VSSD.n1545 4.5005
R8279 VSSD.n1548 VSSD.n1541 4.5005
R8280 VSSD.n1548 VSSD.n1546 4.5005
R8281 VSSD.n1841 VSSD.n1548 4.5005
R8282 VSSD.n1716 VSSD.n1548 4.5005
R8283 VSSD.n1842 VSSD.n1543 4.5005
R8284 VSSD.n1842 VSSD.n1544 4.5005
R8285 VSSD.n1842 VSSD.n1542 4.5005
R8286 VSSD.n1842 VSSD.n1545 4.5005
R8287 VSSD.n1842 VSSD.n1541 4.5005
R8288 VSSD.n1842 VSSD.n1546 4.5005
R8289 VSSD.n1842 VSSD.n1841 4.5005
R8290 VSSD.n1547 VSSD.n1544 4.5005
R8291 VSSD.n1547 VSSD.n1542 4.5005
R8292 VSSD.n1547 VSSD.n1545 4.5005
R8293 VSSD.n1547 VSSD.n1541 4.5005
R8294 VSSD.n1547 VSSD.n1546 4.5005
R8295 VSSD.n1709 VSSD.n1547 4.5005
R8296 VSSD.n1841 VSSD.n1547 4.5005
R8297 VSSD.n1703 VSSD.n1547 4.5005
R8298 VSSD.n1716 VSSD.n1547 4.5005
R8299 VSSD.n2708 VSSD.n869 4.5005
R8300 VSSD.n2708 VSSD.n2707 4.5005
R8301 VSSD.n875 VSSD.n864 4.5005
R8302 VSSD.n2707 VSSD.n864 4.5005
R8303 VSSD.n876 VSSD.n875 4.5005
R8304 VSSD.n2688 VSSD.n876 4.5005
R8305 VSSD.n878 VSSD.n876 4.5005
R8306 VSSD.n2690 VSSD.n876 4.5005
R8307 VSSD.n877 VSSD.n876 4.5005
R8308 VSSD.n2705 VSSD.n876 4.5005
R8309 VSSD.n876 VSSD.n869 4.5005
R8310 VSSD.n2707 VSSD.n876 4.5005
R8311 VSSD.n875 VSSD.n872 4.5005
R8312 VSSD.n2688 VSSD.n872 4.5005
R8313 VSSD.n878 VSSD.n872 4.5005
R8314 VSSD.n2690 VSSD.n872 4.5005
R8315 VSSD.n877 VSSD.n872 4.5005
R8316 VSSD.n2705 VSSD.n872 4.5005
R8317 VSSD.n2707 VSSD.n872 4.5005
R8318 VSSD.n2706 VSSD.n2688 4.5005
R8319 VSSD.n2706 VSSD.n878 4.5005
R8320 VSSD.n2706 VSSD.n2690 4.5005
R8321 VSSD.n2706 VSSD.n877 4.5005
R8322 VSSD.n2706 VSSD.n2705 4.5005
R8323 VSSD.n2706 VSSD.n869 4.5005
R8324 VSSD.n2707 VSSD.n2706 4.5005
R8325 VSSD.n888 VSSD.n883 4.5005
R8326 VSSD.n888 VSSD.n884 4.5005
R8327 VSSD.n888 VSSD.n882 4.5005
R8328 VSSD.n888 VSSD.n885 4.5005
R8329 VSSD.n888 VSSD.n881 4.5005
R8330 VSSD.n888 VSSD.n886 4.5005
R8331 VSSD.n2685 VSSD.n888 4.5005
R8332 VSSD.n2651 VSSD.n888 4.5005
R8333 VSSD.n2686 VSSD.n883 4.5005
R8334 VSSD.n2686 VSSD.n884 4.5005
R8335 VSSD.n2686 VSSD.n882 4.5005
R8336 VSSD.n2686 VSSD.n885 4.5005
R8337 VSSD.n2686 VSSD.n881 4.5005
R8338 VSSD.n2686 VSSD.n886 4.5005
R8339 VSSD.n2686 VSSD.n2685 4.5005
R8340 VSSD.n887 VSSD.n884 4.5005
R8341 VSSD.n887 VSSD.n882 4.5005
R8342 VSSD.n887 VSSD.n885 4.5005
R8343 VSSD.n887 VSSD.n881 4.5005
R8344 VSSD.n887 VSSD.n886 4.5005
R8345 VSSD.n2644 VSSD.n887 4.5005
R8346 VSSD.n2685 VSSD.n887 4.5005
R8347 VSSD.n2638 VSSD.n887 4.5005
R8348 VSSD.n2651 VSSD.n887 4.5005
R8349 VSSD.n2654 VSSD.n908 4.5005
R8350 VSSD.n2654 VSSD.n907 4.5005
R8351 VSSD.n2654 VSSD.n906 4.5005
R8352 VSSD.n2654 VSSD.n905 4.5005
R8353 VSSD.n2654 VSSD.n904 4.5005
R8354 VSSD.n2654 VSSD.n903 4.5005
R8355 VSSD.n2654 VSSD.n893 4.5005
R8356 VSSD.n2673 VSSD.n2654 4.5005
R8357 VSSD.n915 VSSD.n908 4.5005
R8358 VSSD.n915 VSSD.n907 4.5005
R8359 VSSD.n915 VSSD.n906 4.5005
R8360 VSSD.n915 VSSD.n905 4.5005
R8361 VSSD.n915 VSSD.n904 4.5005
R8362 VSSD.n915 VSSD.n893 4.5005
R8363 VSSD.n2673 VSSD.n915 4.5005
R8364 VSSD.n2656 VSSD.n908 4.5005
R8365 VSSD.n2656 VSSD.n907 4.5005
R8366 VSSD.n2656 VSSD.n906 4.5005
R8367 VSSD.n2656 VSSD.n905 4.5005
R8368 VSSD.n2656 VSSD.n904 4.5005
R8369 VSSD.n2656 VSSD.n893 4.5005
R8370 VSSD.n2673 VSSD.n2656 4.5005
R8371 VSSD.n914 VSSD.n908 4.5005
R8372 VSSD.n914 VSSD.n907 4.5005
R8373 VSSD.n914 VSSD.n906 4.5005
R8374 VSSD.n914 VSSD.n905 4.5005
R8375 VSSD.n914 VSSD.n904 4.5005
R8376 VSSD.n914 VSSD.n893 4.5005
R8377 VSSD.n2673 VSSD.n914 4.5005
R8378 VSSD.n2670 VSSD.n908 4.5005
R8379 VSSD.n2670 VSSD.n907 4.5005
R8380 VSSD.n2670 VSSD.n906 4.5005
R8381 VSSD.n2670 VSSD.n905 4.5005
R8382 VSSD.n2670 VSSD.n904 4.5005
R8383 VSSD.n2670 VSSD.n893 4.5005
R8384 VSSD.n2673 VSSD.n2670 4.5005
R8385 VSSD.n913 VSSD.n908 4.5005
R8386 VSSD.n913 VSSD.n907 4.5005
R8387 VSSD.n913 VSSD.n906 4.5005
R8388 VSSD.n913 VSSD.n905 4.5005
R8389 VSSD.n913 VSSD.n904 4.5005
R8390 VSSD.n913 VSSD.n893 4.5005
R8391 VSSD.n2673 VSSD.n913 4.5005
R8392 VSSD.n2672 VSSD.n908 4.5005
R8393 VSSD.n2672 VSSD.n907 4.5005
R8394 VSSD.n2672 VSSD.n906 4.5005
R8395 VSSD.n2672 VSSD.n905 4.5005
R8396 VSSD.n2672 VSSD.n904 4.5005
R8397 VSSD.n2672 VSSD.n893 4.5005
R8398 VSSD.n2673 VSSD.n2672 4.5005
R8399 VSSD.n2674 VSSD.n908 4.5005
R8400 VSSD.n2674 VSSD.n907 4.5005
R8401 VSSD.n2674 VSSD.n906 4.5005
R8402 VSSD.n2674 VSSD.n905 4.5005
R8403 VSSD.n2674 VSSD.n904 4.5005
R8404 VSSD.n2674 VSSD.n893 4.5005
R8405 VSSD.n2674 VSSD.n2673 4.5005
R8406 VSSD.n908 VSSD.n899 4.5005
R8407 VSSD.n907 VSSD.n899 4.5005
R8408 VSSD.n906 VSSD.n899 4.5005
R8409 VSSD.n905 VSSD.n899 4.5005
R8410 VSSD.n904 VSSD.n899 4.5005
R8411 VSSD.n899 VSSD.n893 4.5005
R8412 VSSD.n2682 VSSD.n899 4.5005
R8413 VSSD.n2680 VSSD.n908 4.5005
R8414 VSSD.n2680 VSSD.n907 4.5005
R8415 VSSD.n2680 VSSD.n906 4.5005
R8416 VSSD.n2680 VSSD.n905 4.5005
R8417 VSSD.n2680 VSSD.n904 4.5005
R8418 VSSD.n2680 VSSD.n903 4.5005
R8419 VSSD.n2680 VSSD.n893 4.5005
R8420 VSSD.n908 VSSD.n900 4.5005
R8421 VSSD.n907 VSSD.n900 4.5005
R8422 VSSD.n906 VSSD.n900 4.5005
R8423 VSSD.n905 VSSD.n900 4.5005
R8424 VSSD.n904 VSSD.n900 4.5005
R8425 VSSD.n903 VSSD.n900 4.5005
R8426 VSSD.n900 VSSD.n893 4.5005
R8427 VSSD.n2673 VSSD.n900 4.5005
R8428 VSSD.n3538 VSSD.n114 4.5005
R8429 VSSD.n3538 VSSD.n3537 4.5005
R8430 VSSD.n120 VSSD.n109 4.5005
R8431 VSSD.n3537 VSSD.n109 4.5005
R8432 VSSD.n121 VSSD.n120 4.5005
R8433 VSSD.n3518 VSSD.n121 4.5005
R8434 VSSD.n123 VSSD.n121 4.5005
R8435 VSSD.n3520 VSSD.n121 4.5005
R8436 VSSD.n122 VSSD.n121 4.5005
R8437 VSSD.n3535 VSSD.n121 4.5005
R8438 VSSD.n121 VSSD.n114 4.5005
R8439 VSSD.n3537 VSSD.n121 4.5005
R8440 VSSD.n120 VSSD.n117 4.5005
R8441 VSSD.n3518 VSSD.n117 4.5005
R8442 VSSD.n123 VSSD.n117 4.5005
R8443 VSSD.n3520 VSSD.n117 4.5005
R8444 VSSD.n122 VSSD.n117 4.5005
R8445 VSSD.n3535 VSSD.n117 4.5005
R8446 VSSD.n3537 VSSD.n117 4.5005
R8447 VSSD.n3536 VSSD.n3518 4.5005
R8448 VSSD.n3536 VSSD.n123 4.5005
R8449 VSSD.n3536 VSSD.n3520 4.5005
R8450 VSSD.n3536 VSSD.n122 4.5005
R8451 VSSD.n3536 VSSD.n3535 4.5005
R8452 VSSD.n3536 VSSD.n114 4.5005
R8453 VSSD.n3537 VSSD.n3536 4.5005
R8454 VSSD.n133 VSSD.n128 4.5005
R8455 VSSD.n133 VSSD.n129 4.5005
R8456 VSSD.n133 VSSD.n127 4.5005
R8457 VSSD.n133 VSSD.n130 4.5005
R8458 VSSD.n133 VSSD.n126 4.5005
R8459 VSSD.n133 VSSD.n131 4.5005
R8460 VSSD.n3515 VSSD.n133 4.5005
R8461 VSSD.n3509 VSSD.n133 4.5005
R8462 VSSD.n3516 VSSD.n128 4.5005
R8463 VSSD.n3516 VSSD.n129 4.5005
R8464 VSSD.n3516 VSSD.n127 4.5005
R8465 VSSD.n3516 VSSD.n130 4.5005
R8466 VSSD.n3516 VSSD.n126 4.5005
R8467 VSSD.n3516 VSSD.n131 4.5005
R8468 VSSD.n3516 VSSD.n3515 4.5005
R8469 VSSD.n132 VSSD.n129 4.5005
R8470 VSSD.n132 VSSD.n127 4.5005
R8471 VSSD.n132 VSSD.n130 4.5005
R8472 VSSD.n132 VSSD.n126 4.5005
R8473 VSSD.n132 VSSD.n131 4.5005
R8474 VSSD.n3502 VSSD.n132 4.5005
R8475 VSSD.n3515 VSSD.n132 4.5005
R8476 VSSD.n3496 VSSD.n132 4.5005
R8477 VSSD.n3509 VSSD.n132 4.5005
R8478 VSSD.n3324 VSSD.n198 4.5005
R8479 VSSD.n198 VSSD.n167 4.5005
R8480 VSSD.n198 VSSD.n180 4.5005
R8481 VSSD.n228 VSSD.n198 4.5005
R8482 VSSD.n3369 VSSD.n198 4.5005
R8483 VSSD.n212 VSSD.n156 4.5005
R8484 VSSD.n228 VSSD.n212 4.5005
R8485 VSSD.n3369 VSSD.n212 4.5005
R8486 VSSD.n186 VSSD.n167 4.5005
R8487 VSSD.n186 VSSD.n169 4.5005
R8488 VSSD.n186 VSSD.n166 4.5005
R8489 VSSD.n186 VSSD.n170 4.5005
R8490 VSSD.n186 VSSD.n165 4.5005
R8491 VSSD.n186 VSSD.n171 4.5005
R8492 VSSD.n186 VSSD.n164 4.5005
R8493 VSSD.n186 VSSD.n172 4.5005
R8494 VSSD.n186 VSSD.n163 4.5005
R8495 VSSD.n186 VSSD.n173 4.5005
R8496 VSSD.n186 VSSD.n162 4.5005
R8497 VSSD.n186 VSSD.n174 4.5005
R8498 VSSD.n186 VSSD.n161 4.5005
R8499 VSSD.n186 VSSD.n175 4.5005
R8500 VSSD.n186 VSSD.n160 4.5005
R8501 VSSD.n186 VSSD.n176 4.5005
R8502 VSSD.n186 VSSD.n159 4.5005
R8503 VSSD.n186 VSSD.n177 4.5005
R8504 VSSD.n186 VSSD.n158 4.5005
R8505 VSSD.n186 VSSD.n178 4.5005
R8506 VSSD.n186 VSSD.n157 4.5005
R8507 VSSD.n186 VSSD.n179 4.5005
R8508 VSSD.n3369 VSSD.n186 4.5005
R8509 VSSD.n213 VSSD.n167 4.5005
R8510 VSSD.n213 VSSD.n169 4.5005
R8511 VSSD.n213 VSSD.n166 4.5005
R8512 VSSD.n213 VSSD.n170 4.5005
R8513 VSSD.n213 VSSD.n165 4.5005
R8514 VSSD.n213 VSSD.n171 4.5005
R8515 VSSD.n213 VSSD.n164 4.5005
R8516 VSSD.n213 VSSD.n172 4.5005
R8517 VSSD.n213 VSSD.n163 4.5005
R8518 VSSD.n213 VSSD.n173 4.5005
R8519 VSSD.n213 VSSD.n162 4.5005
R8520 VSSD.n213 VSSD.n174 4.5005
R8521 VSSD.n213 VSSD.n161 4.5005
R8522 VSSD.n213 VSSD.n175 4.5005
R8523 VSSD.n213 VSSD.n160 4.5005
R8524 VSSD.n213 VSSD.n176 4.5005
R8525 VSSD.n213 VSSD.n159 4.5005
R8526 VSSD.n213 VSSD.n177 4.5005
R8527 VSSD.n213 VSSD.n158 4.5005
R8528 VSSD.n213 VSSD.n178 4.5005
R8529 VSSD.n213 VSSD.n157 4.5005
R8530 VSSD.n213 VSSD.n179 4.5005
R8531 VSSD.n213 VSSD.n156 4.5005
R8532 VSSD.n213 VSSD.n180 4.5005
R8533 VSSD.n213 VSSD.n155 4.5005
R8534 VSSD.n228 VSSD.n213 4.5005
R8535 VSSD.n3369 VSSD.n213 4.5005
R8536 VSSD.n184 VSSD.n167 4.5005
R8537 VSSD.n184 VSSD.n169 4.5005
R8538 VSSD.n184 VSSD.n166 4.5005
R8539 VSSD.n184 VSSD.n170 4.5005
R8540 VSSD.n184 VSSD.n165 4.5005
R8541 VSSD.n184 VSSD.n171 4.5005
R8542 VSSD.n184 VSSD.n164 4.5005
R8543 VSSD.n184 VSSD.n172 4.5005
R8544 VSSD.n184 VSSD.n163 4.5005
R8545 VSSD.n184 VSSD.n173 4.5005
R8546 VSSD.n184 VSSD.n162 4.5005
R8547 VSSD.n184 VSSD.n174 4.5005
R8548 VSSD.n184 VSSD.n161 4.5005
R8549 VSSD.n184 VSSD.n175 4.5005
R8550 VSSD.n184 VSSD.n160 4.5005
R8551 VSSD.n184 VSSD.n176 4.5005
R8552 VSSD.n184 VSSD.n159 4.5005
R8553 VSSD.n184 VSSD.n177 4.5005
R8554 VSSD.n184 VSSD.n158 4.5005
R8555 VSSD.n184 VSSD.n178 4.5005
R8556 VSSD.n184 VSSD.n157 4.5005
R8557 VSSD.n184 VSSD.n179 4.5005
R8558 VSSD.n184 VSSD.n156 4.5005
R8559 VSSD.n184 VSSD.n180 4.5005
R8560 VSSD.n184 VSSD.n155 4.5005
R8561 VSSD.n228 VSSD.n184 4.5005
R8562 VSSD.n3369 VSSD.n184 4.5005
R8563 VSSD.n214 VSSD.n167 4.5005
R8564 VSSD.n214 VSSD.n169 4.5005
R8565 VSSD.n214 VSSD.n166 4.5005
R8566 VSSD.n214 VSSD.n170 4.5005
R8567 VSSD.n214 VSSD.n165 4.5005
R8568 VSSD.n214 VSSD.n171 4.5005
R8569 VSSD.n214 VSSD.n164 4.5005
R8570 VSSD.n214 VSSD.n172 4.5005
R8571 VSSD.n214 VSSD.n163 4.5005
R8572 VSSD.n214 VSSD.n173 4.5005
R8573 VSSD.n214 VSSD.n162 4.5005
R8574 VSSD.n214 VSSD.n174 4.5005
R8575 VSSD.n214 VSSD.n161 4.5005
R8576 VSSD.n214 VSSD.n175 4.5005
R8577 VSSD.n214 VSSD.n160 4.5005
R8578 VSSD.n214 VSSD.n176 4.5005
R8579 VSSD.n214 VSSD.n159 4.5005
R8580 VSSD.n214 VSSD.n177 4.5005
R8581 VSSD.n214 VSSD.n158 4.5005
R8582 VSSD.n214 VSSD.n178 4.5005
R8583 VSSD.n214 VSSD.n157 4.5005
R8584 VSSD.n214 VSSD.n179 4.5005
R8585 VSSD.n214 VSSD.n156 4.5005
R8586 VSSD.n214 VSSD.n180 4.5005
R8587 VSSD.n214 VSSD.n155 4.5005
R8588 VSSD.n228 VSSD.n214 4.5005
R8589 VSSD.n3369 VSSD.n214 4.5005
R8590 VSSD.n183 VSSD.n167 4.5005
R8591 VSSD.n183 VSSD.n169 4.5005
R8592 VSSD.n183 VSSD.n166 4.5005
R8593 VSSD.n183 VSSD.n170 4.5005
R8594 VSSD.n183 VSSD.n165 4.5005
R8595 VSSD.n183 VSSD.n171 4.5005
R8596 VSSD.n183 VSSD.n164 4.5005
R8597 VSSD.n183 VSSD.n172 4.5005
R8598 VSSD.n183 VSSD.n163 4.5005
R8599 VSSD.n183 VSSD.n173 4.5005
R8600 VSSD.n183 VSSD.n162 4.5005
R8601 VSSD.n183 VSSD.n174 4.5005
R8602 VSSD.n183 VSSD.n161 4.5005
R8603 VSSD.n183 VSSD.n175 4.5005
R8604 VSSD.n183 VSSD.n160 4.5005
R8605 VSSD.n183 VSSD.n176 4.5005
R8606 VSSD.n183 VSSD.n159 4.5005
R8607 VSSD.n183 VSSD.n177 4.5005
R8608 VSSD.n183 VSSD.n158 4.5005
R8609 VSSD.n183 VSSD.n178 4.5005
R8610 VSSD.n183 VSSD.n157 4.5005
R8611 VSSD.n183 VSSD.n179 4.5005
R8612 VSSD.n183 VSSD.n156 4.5005
R8613 VSSD.n183 VSSD.n180 4.5005
R8614 VSSD.n183 VSSD.n155 4.5005
R8615 VSSD.n228 VSSD.n183 4.5005
R8616 VSSD.n3369 VSSD.n183 4.5005
R8617 VSSD.n215 VSSD.n167 4.5005
R8618 VSSD.n215 VSSD.n169 4.5005
R8619 VSSD.n215 VSSD.n166 4.5005
R8620 VSSD.n215 VSSD.n170 4.5005
R8621 VSSD.n215 VSSD.n165 4.5005
R8622 VSSD.n215 VSSD.n171 4.5005
R8623 VSSD.n215 VSSD.n164 4.5005
R8624 VSSD.n215 VSSD.n172 4.5005
R8625 VSSD.n215 VSSD.n163 4.5005
R8626 VSSD.n215 VSSD.n173 4.5005
R8627 VSSD.n215 VSSD.n162 4.5005
R8628 VSSD.n215 VSSD.n174 4.5005
R8629 VSSD.n215 VSSD.n161 4.5005
R8630 VSSD.n215 VSSD.n175 4.5005
R8631 VSSD.n215 VSSD.n160 4.5005
R8632 VSSD.n215 VSSD.n176 4.5005
R8633 VSSD.n215 VSSD.n159 4.5005
R8634 VSSD.n215 VSSD.n177 4.5005
R8635 VSSD.n215 VSSD.n158 4.5005
R8636 VSSD.n215 VSSD.n178 4.5005
R8637 VSSD.n215 VSSD.n157 4.5005
R8638 VSSD.n215 VSSD.n179 4.5005
R8639 VSSD.n215 VSSD.n156 4.5005
R8640 VSSD.n215 VSSD.n180 4.5005
R8641 VSSD.n215 VSSD.n155 4.5005
R8642 VSSD.n228 VSSD.n215 4.5005
R8643 VSSD.n3369 VSSD.n215 4.5005
R8644 VSSD.n182 VSSD.n167 4.5005
R8645 VSSD.n182 VSSD.n169 4.5005
R8646 VSSD.n182 VSSD.n166 4.5005
R8647 VSSD.n182 VSSD.n170 4.5005
R8648 VSSD.n182 VSSD.n165 4.5005
R8649 VSSD.n182 VSSD.n171 4.5005
R8650 VSSD.n182 VSSD.n164 4.5005
R8651 VSSD.n182 VSSD.n172 4.5005
R8652 VSSD.n182 VSSD.n163 4.5005
R8653 VSSD.n182 VSSD.n173 4.5005
R8654 VSSD.n182 VSSD.n162 4.5005
R8655 VSSD.n182 VSSD.n174 4.5005
R8656 VSSD.n182 VSSD.n161 4.5005
R8657 VSSD.n182 VSSD.n175 4.5005
R8658 VSSD.n182 VSSD.n160 4.5005
R8659 VSSD.n182 VSSD.n176 4.5005
R8660 VSSD.n182 VSSD.n159 4.5005
R8661 VSSD.n182 VSSD.n177 4.5005
R8662 VSSD.n182 VSSD.n158 4.5005
R8663 VSSD.n182 VSSD.n178 4.5005
R8664 VSSD.n182 VSSD.n157 4.5005
R8665 VSSD.n182 VSSD.n179 4.5005
R8666 VSSD.n182 VSSD.n156 4.5005
R8667 VSSD.n182 VSSD.n180 4.5005
R8668 VSSD.n182 VSSD.n155 4.5005
R8669 VSSD.n228 VSSD.n182 4.5005
R8670 VSSD.n3369 VSSD.n182 4.5005
R8671 VSSD.n216 VSSD.n167 4.5005
R8672 VSSD.n216 VSSD.n169 4.5005
R8673 VSSD.n216 VSSD.n166 4.5005
R8674 VSSD.n216 VSSD.n170 4.5005
R8675 VSSD.n216 VSSD.n165 4.5005
R8676 VSSD.n216 VSSD.n171 4.5005
R8677 VSSD.n216 VSSD.n164 4.5005
R8678 VSSD.n216 VSSD.n172 4.5005
R8679 VSSD.n216 VSSD.n163 4.5005
R8680 VSSD.n216 VSSD.n173 4.5005
R8681 VSSD.n216 VSSD.n162 4.5005
R8682 VSSD.n216 VSSD.n174 4.5005
R8683 VSSD.n216 VSSD.n161 4.5005
R8684 VSSD.n216 VSSD.n175 4.5005
R8685 VSSD.n216 VSSD.n160 4.5005
R8686 VSSD.n216 VSSD.n176 4.5005
R8687 VSSD.n216 VSSD.n159 4.5005
R8688 VSSD.n216 VSSD.n177 4.5005
R8689 VSSD.n216 VSSD.n158 4.5005
R8690 VSSD.n216 VSSD.n178 4.5005
R8691 VSSD.n216 VSSD.n157 4.5005
R8692 VSSD.n216 VSSD.n179 4.5005
R8693 VSSD.n216 VSSD.n156 4.5005
R8694 VSSD.n216 VSSD.n180 4.5005
R8695 VSSD.n216 VSSD.n155 4.5005
R8696 VSSD.n228 VSSD.n216 4.5005
R8697 VSSD.n3369 VSSD.n216 4.5005
R8698 VSSD.n181 VSSD.n167 4.5005
R8699 VSSD.n181 VSSD.n169 4.5005
R8700 VSSD.n181 VSSD.n166 4.5005
R8701 VSSD.n181 VSSD.n170 4.5005
R8702 VSSD.n181 VSSD.n165 4.5005
R8703 VSSD.n181 VSSD.n171 4.5005
R8704 VSSD.n181 VSSD.n164 4.5005
R8705 VSSD.n181 VSSD.n172 4.5005
R8706 VSSD.n181 VSSD.n163 4.5005
R8707 VSSD.n181 VSSD.n173 4.5005
R8708 VSSD.n181 VSSD.n162 4.5005
R8709 VSSD.n181 VSSD.n174 4.5005
R8710 VSSD.n181 VSSD.n161 4.5005
R8711 VSSD.n181 VSSD.n175 4.5005
R8712 VSSD.n181 VSSD.n160 4.5005
R8713 VSSD.n181 VSSD.n176 4.5005
R8714 VSSD.n181 VSSD.n159 4.5005
R8715 VSSD.n181 VSSD.n177 4.5005
R8716 VSSD.n181 VSSD.n158 4.5005
R8717 VSSD.n181 VSSD.n178 4.5005
R8718 VSSD.n181 VSSD.n157 4.5005
R8719 VSSD.n181 VSSD.n179 4.5005
R8720 VSSD.n181 VSSD.n156 4.5005
R8721 VSSD.n181 VSSD.n180 4.5005
R8722 VSSD.n181 VSSD.n155 4.5005
R8723 VSSD.n228 VSSD.n181 4.5005
R8724 VSSD.n3369 VSSD.n181 4.5005
R8725 VSSD.n217 VSSD.n167 4.5005
R8726 VSSD.n217 VSSD.n169 4.5005
R8727 VSSD.n217 VSSD.n166 4.5005
R8728 VSSD.n217 VSSD.n170 4.5005
R8729 VSSD.n217 VSSD.n165 4.5005
R8730 VSSD.n217 VSSD.n171 4.5005
R8731 VSSD.n217 VSSD.n164 4.5005
R8732 VSSD.n217 VSSD.n172 4.5005
R8733 VSSD.n217 VSSD.n163 4.5005
R8734 VSSD.n217 VSSD.n173 4.5005
R8735 VSSD.n217 VSSD.n162 4.5005
R8736 VSSD.n217 VSSD.n174 4.5005
R8737 VSSD.n217 VSSD.n161 4.5005
R8738 VSSD.n217 VSSD.n175 4.5005
R8739 VSSD.n217 VSSD.n160 4.5005
R8740 VSSD.n217 VSSD.n176 4.5005
R8741 VSSD.n217 VSSD.n159 4.5005
R8742 VSSD.n217 VSSD.n177 4.5005
R8743 VSSD.n217 VSSD.n158 4.5005
R8744 VSSD.n217 VSSD.n178 4.5005
R8745 VSSD.n217 VSSD.n157 4.5005
R8746 VSSD.n217 VSSD.n179 4.5005
R8747 VSSD.n217 VSSD.n156 4.5005
R8748 VSSD.n217 VSSD.n180 4.5005
R8749 VSSD.n217 VSSD.n155 4.5005
R8750 VSSD.n228 VSSD.n217 4.5005
R8751 VSSD.n3369 VSSD.n217 4.5005
R8752 VSSD.n3370 VSSD.n167 4.5005
R8753 VSSD.n3370 VSSD.n169 4.5005
R8754 VSSD.n3370 VSSD.n166 4.5005
R8755 VSSD.n3370 VSSD.n170 4.5005
R8756 VSSD.n3370 VSSD.n165 4.5005
R8757 VSSD.n3370 VSSD.n171 4.5005
R8758 VSSD.n3370 VSSD.n164 4.5005
R8759 VSSD.n3370 VSSD.n172 4.5005
R8760 VSSD.n3370 VSSD.n163 4.5005
R8761 VSSD.n3370 VSSD.n173 4.5005
R8762 VSSD.n3370 VSSD.n162 4.5005
R8763 VSSD.n3370 VSSD.n174 4.5005
R8764 VSSD.n3370 VSSD.n161 4.5005
R8765 VSSD.n3370 VSSD.n175 4.5005
R8766 VSSD.n3370 VSSD.n160 4.5005
R8767 VSSD.n3370 VSSD.n176 4.5005
R8768 VSSD.n3370 VSSD.n159 4.5005
R8769 VSSD.n3370 VSSD.n177 4.5005
R8770 VSSD.n3370 VSSD.n158 4.5005
R8771 VSSD.n3370 VSSD.n178 4.5005
R8772 VSSD.n3370 VSSD.n157 4.5005
R8773 VSSD.n3370 VSSD.n179 4.5005
R8774 VSSD.n3370 VSSD.n156 4.5005
R8775 VSSD.n3370 VSSD.n180 4.5005
R8776 VSSD.n3370 VSSD.n155 4.5005
R8777 VSSD.n3370 VSSD.n3369 4.5005
R8778 VSSD.n219 VSSD.n169 4.5005
R8779 VSSD.n219 VSSD.n166 4.5005
R8780 VSSD.n219 VSSD.n170 4.5005
R8781 VSSD.n219 VSSD.n165 4.5005
R8782 VSSD.n219 VSSD.n171 4.5005
R8783 VSSD.n219 VSSD.n164 4.5005
R8784 VSSD.n219 VSSD.n172 4.5005
R8785 VSSD.n219 VSSD.n163 4.5005
R8786 VSSD.n219 VSSD.n173 4.5005
R8787 VSSD.n219 VSSD.n162 4.5005
R8788 VSSD.n219 VSSD.n174 4.5005
R8789 VSSD.n219 VSSD.n161 4.5005
R8790 VSSD.n219 VSSD.n175 4.5005
R8791 VSSD.n219 VSSD.n160 4.5005
R8792 VSSD.n219 VSSD.n176 4.5005
R8793 VSSD.n219 VSSD.n159 4.5005
R8794 VSSD.n219 VSSD.n177 4.5005
R8795 VSSD.n219 VSSD.n158 4.5005
R8796 VSSD.n219 VSSD.n178 4.5005
R8797 VSSD.n219 VSSD.n157 4.5005
R8798 VSSD.n219 VSSD.n179 4.5005
R8799 VSSD.n219 VSSD.n156 4.5005
R8800 VSSD.n219 VSSD.n180 4.5005
R8801 VSSD.n228 VSSD.n219 4.5005
R8802 VSSD.n3490 VSSD.n140 4.5005
R8803 VSSD.n3488 VSSD.n3487 4.5005
R8804 VSSD.n3398 VSSD.n140 4.5005
R8805 VSSD.n3398 VSSD.n3385 4.5005
R8806 VSSD.n3485 VSSD.n3398 4.5005
R8807 VSSD.n3400 VSSD.n3398 4.5005
R8808 VSSD.n3479 VSSD.n3398 4.5005
R8809 VSSD.n3477 VSSD.n3398 4.5005
R8810 VSSD.n3407 VSSD.n3398 4.5005
R8811 VSSD.n3405 VSSD.n3398 4.5005
R8812 VSSD.n3471 VSSD.n3398 4.5005
R8813 VSSD.n3469 VSSD.n3398 4.5005
R8814 VSSD.n3411 VSSD.n3398 4.5005
R8815 VSSD.n3409 VSSD.n3398 4.5005
R8816 VSSD.n3463 VSSD.n3398 4.5005
R8817 VSSD.n3461 VSSD.n3398 4.5005
R8818 VSSD.n3415 VSSD.n3398 4.5005
R8819 VSSD.n3413 VSSD.n3398 4.5005
R8820 VSSD.n3455 VSSD.n3398 4.5005
R8821 VSSD.n3453 VSSD.n3398 4.5005
R8822 VSSD.n3419 VSSD.n3398 4.5005
R8823 VSSD.n3417 VSSD.n3398 4.5005
R8824 VSSD.n3447 VSSD.n3398 4.5005
R8825 VSSD.n3445 VSSD.n3398 4.5005
R8826 VSSD.n3428 VSSD.n3398 4.5005
R8827 VSSD.n3439 VSSD.n3398 4.5005
R8828 VSSD.n3435 VSSD.n3398 4.5005
R8829 VSSD.n149 VSSD.n140 4.5005
R8830 VSSD.n3492 VSSD.n149 4.5005
R8831 VSSD.n3488 VSSD.n149 4.5005
R8832 VSSD.n3385 VSSD.n149 4.5005
R8833 VSSD.n3485 VSSD.n149 4.5005
R8834 VSSD.n3400 VSSD.n149 4.5005
R8835 VSSD.n3479 VSSD.n149 4.5005
R8836 VSSD.n3477 VSSD.n149 4.5005
R8837 VSSD.n3407 VSSD.n149 4.5005
R8838 VSSD.n3405 VSSD.n149 4.5005
R8839 VSSD.n3471 VSSD.n149 4.5005
R8840 VSSD.n3469 VSSD.n149 4.5005
R8841 VSSD.n3411 VSSD.n149 4.5005
R8842 VSSD.n3409 VSSD.n149 4.5005
R8843 VSSD.n3463 VSSD.n149 4.5005
R8844 VSSD.n3461 VSSD.n149 4.5005
R8845 VSSD.n3415 VSSD.n149 4.5005
R8846 VSSD.n3413 VSSD.n149 4.5005
R8847 VSSD.n3455 VSSD.n149 4.5005
R8848 VSSD.n3453 VSSD.n149 4.5005
R8849 VSSD.n3419 VSSD.n149 4.5005
R8850 VSSD.n3417 VSSD.n149 4.5005
R8851 VSSD.n3447 VSSD.n149 4.5005
R8852 VSSD.n3445 VSSD.n149 4.5005
R8853 VSSD.n3428 VSSD.n149 4.5005
R8854 VSSD.n3439 VSSD.n149 4.5005
R8855 VSSD.n3435 VSSD.n149 4.5005
R8856 VSSD.n147 VSSD.n140 4.5005
R8857 VSSD.n3492 VSSD.n147 4.5005
R8858 VSSD.n3488 VSSD.n147 4.5005
R8859 VSSD.n3385 VSSD.n147 4.5005
R8860 VSSD.n3485 VSSD.n147 4.5005
R8861 VSSD.n3400 VSSD.n147 4.5005
R8862 VSSD.n3479 VSSD.n147 4.5005
R8863 VSSD.n3477 VSSD.n147 4.5005
R8864 VSSD.n3407 VSSD.n147 4.5005
R8865 VSSD.n3405 VSSD.n147 4.5005
R8866 VSSD.n3471 VSSD.n147 4.5005
R8867 VSSD.n3469 VSSD.n147 4.5005
R8868 VSSD.n3411 VSSD.n147 4.5005
R8869 VSSD.n3409 VSSD.n147 4.5005
R8870 VSSD.n3463 VSSD.n147 4.5005
R8871 VSSD.n3461 VSSD.n147 4.5005
R8872 VSSD.n3415 VSSD.n147 4.5005
R8873 VSSD.n3413 VSSD.n147 4.5005
R8874 VSSD.n3455 VSSD.n147 4.5005
R8875 VSSD.n3453 VSSD.n147 4.5005
R8876 VSSD.n3419 VSSD.n147 4.5005
R8877 VSSD.n3417 VSSD.n147 4.5005
R8878 VSSD.n3447 VSSD.n147 4.5005
R8879 VSSD.n3445 VSSD.n147 4.5005
R8880 VSSD.n3428 VSSD.n147 4.5005
R8881 VSSD.n3439 VSSD.n147 4.5005
R8882 VSSD.n3435 VSSD.n147 4.5005
R8883 VSSD.n150 VSSD.n140 4.5005
R8884 VSSD.n3492 VSSD.n150 4.5005
R8885 VSSD.n3488 VSSD.n150 4.5005
R8886 VSSD.n3385 VSSD.n150 4.5005
R8887 VSSD.n3485 VSSD.n150 4.5005
R8888 VSSD.n3400 VSSD.n150 4.5005
R8889 VSSD.n3479 VSSD.n150 4.5005
R8890 VSSD.n3477 VSSD.n150 4.5005
R8891 VSSD.n3407 VSSD.n150 4.5005
R8892 VSSD.n3405 VSSD.n150 4.5005
R8893 VSSD.n3471 VSSD.n150 4.5005
R8894 VSSD.n3469 VSSD.n150 4.5005
R8895 VSSD.n3411 VSSD.n150 4.5005
R8896 VSSD.n3409 VSSD.n150 4.5005
R8897 VSSD.n3463 VSSD.n150 4.5005
R8898 VSSD.n3461 VSSD.n150 4.5005
R8899 VSSD.n3415 VSSD.n150 4.5005
R8900 VSSD.n3413 VSSD.n150 4.5005
R8901 VSSD.n3455 VSSD.n150 4.5005
R8902 VSSD.n3453 VSSD.n150 4.5005
R8903 VSSD.n3419 VSSD.n150 4.5005
R8904 VSSD.n3417 VSSD.n150 4.5005
R8905 VSSD.n3447 VSSD.n150 4.5005
R8906 VSSD.n3445 VSSD.n150 4.5005
R8907 VSSD.n3428 VSSD.n150 4.5005
R8908 VSSD.n3439 VSSD.n150 4.5005
R8909 VSSD.n3435 VSSD.n150 4.5005
R8910 VSSD.n146 VSSD.n140 4.5005
R8911 VSSD.n3492 VSSD.n146 4.5005
R8912 VSSD.n3488 VSSD.n146 4.5005
R8913 VSSD.n3385 VSSD.n146 4.5005
R8914 VSSD.n3485 VSSD.n146 4.5005
R8915 VSSD.n3400 VSSD.n146 4.5005
R8916 VSSD.n3479 VSSD.n146 4.5005
R8917 VSSD.n3477 VSSD.n146 4.5005
R8918 VSSD.n3407 VSSD.n146 4.5005
R8919 VSSD.n3405 VSSD.n146 4.5005
R8920 VSSD.n3471 VSSD.n146 4.5005
R8921 VSSD.n3469 VSSD.n146 4.5005
R8922 VSSD.n3411 VSSD.n146 4.5005
R8923 VSSD.n3409 VSSD.n146 4.5005
R8924 VSSD.n3463 VSSD.n146 4.5005
R8925 VSSD.n3461 VSSD.n146 4.5005
R8926 VSSD.n3415 VSSD.n146 4.5005
R8927 VSSD.n3413 VSSD.n146 4.5005
R8928 VSSD.n3455 VSSD.n146 4.5005
R8929 VSSD.n3453 VSSD.n146 4.5005
R8930 VSSD.n3419 VSSD.n146 4.5005
R8931 VSSD.n3417 VSSD.n146 4.5005
R8932 VSSD.n3447 VSSD.n146 4.5005
R8933 VSSD.n3445 VSSD.n146 4.5005
R8934 VSSD.n3428 VSSD.n146 4.5005
R8935 VSSD.n3439 VSSD.n146 4.5005
R8936 VSSD.n3435 VSSD.n146 4.5005
R8937 VSSD.n151 VSSD.n140 4.5005
R8938 VSSD.n3492 VSSD.n151 4.5005
R8939 VSSD.n3488 VSSD.n151 4.5005
R8940 VSSD.n3385 VSSD.n151 4.5005
R8941 VSSD.n3485 VSSD.n151 4.5005
R8942 VSSD.n3400 VSSD.n151 4.5005
R8943 VSSD.n3479 VSSD.n151 4.5005
R8944 VSSD.n3477 VSSD.n151 4.5005
R8945 VSSD.n3407 VSSD.n151 4.5005
R8946 VSSD.n3405 VSSD.n151 4.5005
R8947 VSSD.n3471 VSSD.n151 4.5005
R8948 VSSD.n3469 VSSD.n151 4.5005
R8949 VSSD.n3411 VSSD.n151 4.5005
R8950 VSSD.n3409 VSSD.n151 4.5005
R8951 VSSD.n3463 VSSD.n151 4.5005
R8952 VSSD.n3461 VSSD.n151 4.5005
R8953 VSSD.n3415 VSSD.n151 4.5005
R8954 VSSD.n3413 VSSD.n151 4.5005
R8955 VSSD.n3455 VSSD.n151 4.5005
R8956 VSSD.n3453 VSSD.n151 4.5005
R8957 VSSD.n3419 VSSD.n151 4.5005
R8958 VSSD.n3417 VSSD.n151 4.5005
R8959 VSSD.n3447 VSSD.n151 4.5005
R8960 VSSD.n3445 VSSD.n151 4.5005
R8961 VSSD.n3428 VSSD.n151 4.5005
R8962 VSSD.n3439 VSSD.n151 4.5005
R8963 VSSD.n3435 VSSD.n151 4.5005
R8964 VSSD.n145 VSSD.n140 4.5005
R8965 VSSD.n3492 VSSD.n145 4.5005
R8966 VSSD.n3488 VSSD.n145 4.5005
R8967 VSSD.n3385 VSSD.n145 4.5005
R8968 VSSD.n3485 VSSD.n145 4.5005
R8969 VSSD.n3400 VSSD.n145 4.5005
R8970 VSSD.n3479 VSSD.n145 4.5005
R8971 VSSD.n3477 VSSD.n145 4.5005
R8972 VSSD.n3407 VSSD.n145 4.5005
R8973 VSSD.n3405 VSSD.n145 4.5005
R8974 VSSD.n3471 VSSD.n145 4.5005
R8975 VSSD.n3469 VSSD.n145 4.5005
R8976 VSSD.n3411 VSSD.n145 4.5005
R8977 VSSD.n3409 VSSD.n145 4.5005
R8978 VSSD.n3463 VSSD.n145 4.5005
R8979 VSSD.n3461 VSSD.n145 4.5005
R8980 VSSD.n3415 VSSD.n145 4.5005
R8981 VSSD.n3413 VSSD.n145 4.5005
R8982 VSSD.n3455 VSSD.n145 4.5005
R8983 VSSD.n3453 VSSD.n145 4.5005
R8984 VSSD.n3419 VSSD.n145 4.5005
R8985 VSSD.n3417 VSSD.n145 4.5005
R8986 VSSD.n3447 VSSD.n145 4.5005
R8987 VSSD.n3445 VSSD.n145 4.5005
R8988 VSSD.n3428 VSSD.n145 4.5005
R8989 VSSD.n3439 VSSD.n145 4.5005
R8990 VSSD.n3435 VSSD.n145 4.5005
R8991 VSSD.n152 VSSD.n140 4.5005
R8992 VSSD.n3492 VSSD.n152 4.5005
R8993 VSSD.n3488 VSSD.n152 4.5005
R8994 VSSD.n3385 VSSD.n152 4.5005
R8995 VSSD.n3485 VSSD.n152 4.5005
R8996 VSSD.n3400 VSSD.n152 4.5005
R8997 VSSD.n3479 VSSD.n152 4.5005
R8998 VSSD.n3477 VSSD.n152 4.5005
R8999 VSSD.n3407 VSSD.n152 4.5005
R9000 VSSD.n3405 VSSD.n152 4.5005
R9001 VSSD.n3471 VSSD.n152 4.5005
R9002 VSSD.n3469 VSSD.n152 4.5005
R9003 VSSD.n3411 VSSD.n152 4.5005
R9004 VSSD.n3409 VSSD.n152 4.5005
R9005 VSSD.n3463 VSSD.n152 4.5005
R9006 VSSD.n3461 VSSD.n152 4.5005
R9007 VSSD.n3415 VSSD.n152 4.5005
R9008 VSSD.n3413 VSSD.n152 4.5005
R9009 VSSD.n3455 VSSD.n152 4.5005
R9010 VSSD.n3453 VSSD.n152 4.5005
R9011 VSSD.n3419 VSSD.n152 4.5005
R9012 VSSD.n3417 VSSD.n152 4.5005
R9013 VSSD.n3447 VSSD.n152 4.5005
R9014 VSSD.n3445 VSSD.n152 4.5005
R9015 VSSD.n3428 VSSD.n152 4.5005
R9016 VSSD.n3439 VSSD.n152 4.5005
R9017 VSSD.n3435 VSSD.n152 4.5005
R9018 VSSD.n144 VSSD.n140 4.5005
R9019 VSSD.n3492 VSSD.n144 4.5005
R9020 VSSD.n3488 VSSD.n144 4.5005
R9021 VSSD.n3385 VSSD.n144 4.5005
R9022 VSSD.n3485 VSSD.n144 4.5005
R9023 VSSD.n3400 VSSD.n144 4.5005
R9024 VSSD.n3479 VSSD.n144 4.5005
R9025 VSSD.n3477 VSSD.n144 4.5005
R9026 VSSD.n3407 VSSD.n144 4.5005
R9027 VSSD.n3405 VSSD.n144 4.5005
R9028 VSSD.n3471 VSSD.n144 4.5005
R9029 VSSD.n3469 VSSD.n144 4.5005
R9030 VSSD.n3411 VSSD.n144 4.5005
R9031 VSSD.n3409 VSSD.n144 4.5005
R9032 VSSD.n3463 VSSD.n144 4.5005
R9033 VSSD.n3461 VSSD.n144 4.5005
R9034 VSSD.n3415 VSSD.n144 4.5005
R9035 VSSD.n3413 VSSD.n144 4.5005
R9036 VSSD.n3455 VSSD.n144 4.5005
R9037 VSSD.n3453 VSSD.n144 4.5005
R9038 VSSD.n3419 VSSD.n144 4.5005
R9039 VSSD.n3417 VSSD.n144 4.5005
R9040 VSSD.n3447 VSSD.n144 4.5005
R9041 VSSD.n3445 VSSD.n144 4.5005
R9042 VSSD.n3428 VSSD.n144 4.5005
R9043 VSSD.n3439 VSSD.n144 4.5005
R9044 VSSD.n3435 VSSD.n144 4.5005
R9045 VSSD.n153 VSSD.n140 4.5005
R9046 VSSD.n3492 VSSD.n153 4.5005
R9047 VSSD.n3488 VSSD.n153 4.5005
R9048 VSSD.n3385 VSSD.n153 4.5005
R9049 VSSD.n3485 VSSD.n153 4.5005
R9050 VSSD.n3400 VSSD.n153 4.5005
R9051 VSSD.n3479 VSSD.n153 4.5005
R9052 VSSD.n3477 VSSD.n153 4.5005
R9053 VSSD.n3407 VSSD.n153 4.5005
R9054 VSSD.n3405 VSSD.n153 4.5005
R9055 VSSD.n3471 VSSD.n153 4.5005
R9056 VSSD.n3469 VSSD.n153 4.5005
R9057 VSSD.n3411 VSSD.n153 4.5005
R9058 VSSD.n3409 VSSD.n153 4.5005
R9059 VSSD.n3463 VSSD.n153 4.5005
R9060 VSSD.n3461 VSSD.n153 4.5005
R9061 VSSD.n3415 VSSD.n153 4.5005
R9062 VSSD.n3413 VSSD.n153 4.5005
R9063 VSSD.n3455 VSSD.n153 4.5005
R9064 VSSD.n3453 VSSD.n153 4.5005
R9065 VSSD.n3419 VSSD.n153 4.5005
R9066 VSSD.n3417 VSSD.n153 4.5005
R9067 VSSD.n3447 VSSD.n153 4.5005
R9068 VSSD.n3445 VSSD.n153 4.5005
R9069 VSSD.n3428 VSSD.n153 4.5005
R9070 VSSD.n3439 VSSD.n153 4.5005
R9071 VSSD.n3435 VSSD.n153 4.5005
R9072 VSSD.n143 VSSD.n140 4.5005
R9073 VSSD.n3492 VSSD.n143 4.5005
R9074 VSSD.n3488 VSSD.n143 4.5005
R9075 VSSD.n3385 VSSD.n143 4.5005
R9076 VSSD.n3485 VSSD.n143 4.5005
R9077 VSSD.n3400 VSSD.n143 4.5005
R9078 VSSD.n3479 VSSD.n143 4.5005
R9079 VSSD.n3477 VSSD.n143 4.5005
R9080 VSSD.n3407 VSSD.n143 4.5005
R9081 VSSD.n3405 VSSD.n143 4.5005
R9082 VSSD.n3471 VSSD.n143 4.5005
R9083 VSSD.n3469 VSSD.n143 4.5005
R9084 VSSD.n3411 VSSD.n143 4.5005
R9085 VSSD.n3409 VSSD.n143 4.5005
R9086 VSSD.n3463 VSSD.n143 4.5005
R9087 VSSD.n3461 VSSD.n143 4.5005
R9088 VSSD.n3415 VSSD.n143 4.5005
R9089 VSSD.n3413 VSSD.n143 4.5005
R9090 VSSD.n3455 VSSD.n143 4.5005
R9091 VSSD.n3453 VSSD.n143 4.5005
R9092 VSSD.n3419 VSSD.n143 4.5005
R9093 VSSD.n3417 VSSD.n143 4.5005
R9094 VSSD.n3447 VSSD.n143 4.5005
R9095 VSSD.n3445 VSSD.n143 4.5005
R9096 VSSD.n3428 VSSD.n143 4.5005
R9097 VSSD.n3426 VSSD.n143 4.5005
R9098 VSSD.n3439 VSSD.n143 4.5005
R9099 VSSD.n3435 VSSD.n143 4.5005
R9100 VSSD.n3488 VSSD.n3371 4.5005
R9101 VSSD.n3385 VSSD.n3371 4.5005
R9102 VSSD.n3485 VSSD.n3371 4.5005
R9103 VSSD.n3400 VSSD.n3371 4.5005
R9104 VSSD.n3479 VSSD.n3371 4.5005
R9105 VSSD.n3477 VSSD.n3371 4.5005
R9106 VSSD.n3407 VSSD.n3371 4.5005
R9107 VSSD.n3405 VSSD.n3371 4.5005
R9108 VSSD.n3471 VSSD.n3371 4.5005
R9109 VSSD.n3469 VSSD.n3371 4.5005
R9110 VSSD.n3411 VSSD.n3371 4.5005
R9111 VSSD.n3409 VSSD.n3371 4.5005
R9112 VSSD.n3463 VSSD.n3371 4.5005
R9113 VSSD.n3461 VSSD.n3371 4.5005
R9114 VSSD.n3415 VSSD.n3371 4.5005
R9115 VSSD.n3413 VSSD.n3371 4.5005
R9116 VSSD.n3455 VSSD.n3371 4.5005
R9117 VSSD.n3453 VSSD.n3371 4.5005
R9118 VSSD.n3419 VSSD.n3371 4.5005
R9119 VSSD.n3417 VSSD.n3371 4.5005
R9120 VSSD.n3447 VSSD.n3371 4.5005
R9121 VSSD.n3445 VSSD.n3371 4.5005
R9122 VSSD.n3428 VSSD.n3371 4.5005
R9123 VSSD.n3426 VSSD.n3371 4.5005
R9124 VSSD.n3439 VSSD.n3371 4.5005
R9125 VSSD.n3371 VSSD.n140 4.5005
R9126 VSSD.n3656 VSSD.n19 4.5005
R9127 VSSD.n3656 VSSD.n3655 4.5005
R9128 VSSD.n25 VSSD.n14 4.5005
R9129 VSSD.n3655 VSSD.n14 4.5005
R9130 VSSD.n26 VSSD.n25 4.5005
R9131 VSSD.n3636 VSSD.n26 4.5005
R9132 VSSD.n28 VSSD.n26 4.5005
R9133 VSSD.n3638 VSSD.n26 4.5005
R9134 VSSD.n27 VSSD.n26 4.5005
R9135 VSSD.n3653 VSSD.n26 4.5005
R9136 VSSD.n26 VSSD.n19 4.5005
R9137 VSSD.n3655 VSSD.n26 4.5005
R9138 VSSD.n25 VSSD.n22 4.5005
R9139 VSSD.n3636 VSSD.n22 4.5005
R9140 VSSD.n28 VSSD.n22 4.5005
R9141 VSSD.n3638 VSSD.n22 4.5005
R9142 VSSD.n27 VSSD.n22 4.5005
R9143 VSSD.n3653 VSSD.n22 4.5005
R9144 VSSD.n3655 VSSD.n22 4.5005
R9145 VSSD.n3654 VSSD.n3636 4.5005
R9146 VSSD.n3654 VSSD.n28 4.5005
R9147 VSSD.n3654 VSSD.n3638 4.5005
R9148 VSSD.n3654 VSSD.n27 4.5005
R9149 VSSD.n3654 VSSD.n3653 4.5005
R9150 VSSD.n3654 VSSD.n19 4.5005
R9151 VSSD.n3655 VSSD.n3654 4.5005
R9152 VSSD.n38 VSSD.n33 4.5005
R9153 VSSD.n38 VSSD.n34 4.5005
R9154 VSSD.n38 VSSD.n32 4.5005
R9155 VSSD.n38 VSSD.n35 4.5005
R9156 VSSD.n38 VSSD.n31 4.5005
R9157 VSSD.n38 VSSD.n36 4.5005
R9158 VSSD.n3633 VSSD.n38 4.5005
R9159 VSSD.n3599 VSSD.n38 4.5005
R9160 VSSD.n3634 VSSD.n33 4.5005
R9161 VSSD.n3634 VSSD.n34 4.5005
R9162 VSSD.n3634 VSSD.n32 4.5005
R9163 VSSD.n3634 VSSD.n35 4.5005
R9164 VSSD.n3634 VSSD.n31 4.5005
R9165 VSSD.n3634 VSSD.n36 4.5005
R9166 VSSD.n3634 VSSD.n3633 4.5005
R9167 VSSD.n37 VSSD.n34 4.5005
R9168 VSSD.n37 VSSD.n32 4.5005
R9169 VSSD.n37 VSSD.n35 4.5005
R9170 VSSD.n37 VSSD.n31 4.5005
R9171 VSSD.n37 VSSD.n36 4.5005
R9172 VSSD.n3592 VSSD.n37 4.5005
R9173 VSSD.n3633 VSSD.n37 4.5005
R9174 VSSD.n3586 VSSD.n37 4.5005
R9175 VSSD.n3599 VSSD.n37 4.5005
R9176 VSSD.n3602 VSSD.n58 4.5005
R9177 VSSD.n3602 VSSD.n57 4.5005
R9178 VSSD.n3602 VSSD.n56 4.5005
R9179 VSSD.n3602 VSSD.n55 4.5005
R9180 VSSD.n3602 VSSD.n54 4.5005
R9181 VSSD.n3602 VSSD.n53 4.5005
R9182 VSSD.n3602 VSSD.n43 4.5005
R9183 VSSD.n3621 VSSD.n3602 4.5005
R9184 VSSD.n65 VSSD.n58 4.5005
R9185 VSSD.n65 VSSD.n57 4.5005
R9186 VSSD.n65 VSSD.n56 4.5005
R9187 VSSD.n65 VSSD.n55 4.5005
R9188 VSSD.n65 VSSD.n54 4.5005
R9189 VSSD.n65 VSSD.n43 4.5005
R9190 VSSD.n3621 VSSD.n65 4.5005
R9191 VSSD.n3604 VSSD.n58 4.5005
R9192 VSSD.n3604 VSSD.n57 4.5005
R9193 VSSD.n3604 VSSD.n56 4.5005
R9194 VSSD.n3604 VSSD.n55 4.5005
R9195 VSSD.n3604 VSSD.n54 4.5005
R9196 VSSD.n3604 VSSD.n43 4.5005
R9197 VSSD.n3621 VSSD.n3604 4.5005
R9198 VSSD.n64 VSSD.n58 4.5005
R9199 VSSD.n64 VSSD.n57 4.5005
R9200 VSSD.n64 VSSD.n56 4.5005
R9201 VSSD.n64 VSSD.n55 4.5005
R9202 VSSD.n64 VSSD.n54 4.5005
R9203 VSSD.n64 VSSD.n43 4.5005
R9204 VSSD.n3621 VSSD.n64 4.5005
R9205 VSSD.n3618 VSSD.n58 4.5005
R9206 VSSD.n3618 VSSD.n57 4.5005
R9207 VSSD.n3618 VSSD.n56 4.5005
R9208 VSSD.n3618 VSSD.n55 4.5005
R9209 VSSD.n3618 VSSD.n54 4.5005
R9210 VSSD.n3618 VSSD.n43 4.5005
R9211 VSSD.n3621 VSSD.n3618 4.5005
R9212 VSSD.n63 VSSD.n58 4.5005
R9213 VSSD.n63 VSSD.n57 4.5005
R9214 VSSD.n63 VSSD.n56 4.5005
R9215 VSSD.n63 VSSD.n55 4.5005
R9216 VSSD.n63 VSSD.n54 4.5005
R9217 VSSD.n63 VSSD.n43 4.5005
R9218 VSSD.n3621 VSSD.n63 4.5005
R9219 VSSD.n3620 VSSD.n58 4.5005
R9220 VSSD.n3620 VSSD.n57 4.5005
R9221 VSSD.n3620 VSSD.n56 4.5005
R9222 VSSD.n3620 VSSD.n55 4.5005
R9223 VSSD.n3620 VSSD.n54 4.5005
R9224 VSSD.n3620 VSSD.n43 4.5005
R9225 VSSD.n3621 VSSD.n3620 4.5005
R9226 VSSD.n3622 VSSD.n58 4.5005
R9227 VSSD.n3622 VSSD.n57 4.5005
R9228 VSSD.n3622 VSSD.n56 4.5005
R9229 VSSD.n3622 VSSD.n55 4.5005
R9230 VSSD.n3622 VSSD.n54 4.5005
R9231 VSSD.n3622 VSSD.n43 4.5005
R9232 VSSD.n3622 VSSD.n3621 4.5005
R9233 VSSD.n58 VSSD.n49 4.5005
R9234 VSSD.n57 VSSD.n49 4.5005
R9235 VSSD.n56 VSSD.n49 4.5005
R9236 VSSD.n55 VSSD.n49 4.5005
R9237 VSSD.n54 VSSD.n49 4.5005
R9238 VSSD.n49 VSSD.n43 4.5005
R9239 VSSD.n3630 VSSD.n49 4.5005
R9240 VSSD.n3628 VSSD.n58 4.5005
R9241 VSSD.n3628 VSSD.n57 4.5005
R9242 VSSD.n3628 VSSD.n56 4.5005
R9243 VSSD.n3628 VSSD.n55 4.5005
R9244 VSSD.n3628 VSSD.n54 4.5005
R9245 VSSD.n3628 VSSD.n53 4.5005
R9246 VSSD.n3628 VSSD.n43 4.5005
R9247 VSSD.n58 VSSD.n50 4.5005
R9248 VSSD.n57 VSSD.n50 4.5005
R9249 VSSD.n56 VSSD.n50 4.5005
R9250 VSSD.n55 VSSD.n50 4.5005
R9251 VSSD.n54 VSSD.n50 4.5005
R9252 VSSD.n53 VSSD.n50 4.5005
R9253 VSSD.n50 VSSD.n43 4.5005
R9254 VSSD.n3621 VSSD.n50 4.5005
R9255 VSSD.n73 VSSD.n69 4.5005
R9256 VSSD.n3582 VSSD.n69 4.5005
R9257 VSSD.n3585 VSSD.n69 4.5005
R9258 VSSD.n71 VSSD.n66 4.5005
R9259 VSSD.n3579 VSSD.n66 4.5005
R9260 VSSD.n3582 VSSD.n66 4.5005
R9261 VSSD.n3585 VSSD.n66 4.5005
R9262 VSSD.n3584 VSSD.n73 4.5005
R9263 VSSD.n3584 VSSD.n76 4.5005
R9264 VSSD.n3584 VSSD.n72 4.5005
R9265 VSSD.n3584 VSSD.n79 4.5005
R9266 VSSD.n3584 VSSD.n71 4.5005
R9267 VSSD.n3584 VSSD.n3579 4.5005
R9268 VSSD.n3585 VSSD.n3584 4.5005
R9269 VSSD.n3567 VSSD.n3553 4.5005
R9270 VSSD.n3562 VSSD.n3553 4.5005
R9271 VSSD.n3562 VSSD.n85 4.5005
R9272 VSSD.n3562 VSSD.n3558 4.5005
R9273 VSSD.n3562 VSSD.n83 4.5005
R9274 VSSD.n3562 VSSD.n3559 4.5005
R9275 VSSD.n3574 VSSD.n3562 4.5005
R9276 VSSD.n3573 VSSD.n3553 4.5005
R9277 VSSD.n3573 VSSD.n3555 4.5005
R9278 VSSD.n3573 VSSD.n84 4.5005
R9279 VSSD.n3573 VSSD.n3558 4.5005
R9280 VSSD.n3573 VSSD.n3559 4.5005
R9281 VSSD.n3574 VSSD.n3573 4.5005
R9282 VSSD.n3560 VSSD.n3553 4.5005
R9283 VSSD.n3560 VSSD.n3554 4.5005
R9284 VSSD.n3560 VSSD.n85 4.5005
R9285 VSSD.n3560 VSSD.n3555 4.5005
R9286 VSSD.n3560 VSSD.n84 4.5005
R9287 VSSD.n3560 VSSD.n3558 4.5005
R9288 VSSD.n3560 VSSD.n3559 4.5005
R9289 VSSD.n3574 VSSD.n3560 4.5005
R9290 VSSD.n3575 VSSD.n3553 4.5005
R9291 VSSD.n3575 VSSD.n3554 4.5005
R9292 VSSD.n3575 VSSD.n85 4.5005
R9293 VSSD.n3575 VSSD.n3555 4.5005
R9294 VSSD.n3575 VSSD.n84 4.5005
R9295 VSSD.n3575 VSSD.n3558 4.5005
R9296 VSSD.n3575 VSSD.n83 4.5005
R9297 VSSD.n3575 VSSD.n3559 4.5005
R9298 VSSD.n3575 VSSD.n3574 4.5005
R9299 VSSD.n2621 VSSD.n973 4.5005
R9300 VSSD.n973 VSSD.n963 4.5005
R9301 VSSD.n2627 VSSD.n973 4.5005
R9302 VSSD.n968 VSSD.n961 4.5005
R9303 VSSD.n968 VSSD.n958 4.5005
R9304 VSSD.n2625 VSSD.n968 4.5005
R9305 VSSD.n2627 VSSD.n968 4.5005
R9306 VSSD.n2626 VSSD.n961 4.5005
R9307 VSSD.n2626 VSSD.n960 4.5005
R9308 VSSD.n2626 VSSD.n962 4.5005
R9309 VSSD.n2626 VSSD.n959 4.5005
R9310 VSSD.n2626 VSSD.n963 4.5005
R9311 VSSD.n2626 VSSD.n958 4.5005
R9312 VSSD.n2626 VSSD.n2625 4.5005
R9313 VSSD.n2627 VSSD.n2626 4.5005
R9314 VSSD.n965 VSSD.n961 4.5005
R9315 VSSD.n965 VSSD.n960 4.5005
R9316 VSSD.n965 VSSD.n962 4.5005
R9317 VSSD.n965 VSSD.n959 4.5005
R9318 VSSD.n965 VSSD.n963 4.5005
R9319 VSSD.n965 VSSD.n958 4.5005
R9320 VSSD.n2625 VSSD.n965 4.5005
R9321 VSSD.n2627 VSSD.n965 4.5005
R9322 VSSD.n2628 VSSD.n961 4.5005
R9323 VSSD.n2628 VSSD.n960 4.5005
R9324 VSSD.n2628 VSSD.n962 4.5005
R9325 VSSD.n2628 VSSD.n959 4.5005
R9326 VSSD.n2628 VSSD.n963 4.5005
R9327 VSSD.n2628 VSSD.n958 4.5005
R9328 VSSD.n2628 VSSD.n2627 4.5005
R9329 VSSD.n924 VSSD.n918 4.5005
R9330 VSSD.n926 VSSD.n918 4.5005
R9331 VSSD.n923 VSSD.n918 4.5005
R9332 VSSD.n927 VSSD.n918 4.5005
R9333 VSSD.n922 VSSD.n918 4.5005
R9334 VSSD.n928 VSSD.n918 4.5005
R9335 VSSD.n936 VSSD.n918 4.5005
R9336 VSSD.n2635 VSSD.n918 4.5005
R9337 VSSD.n2637 VSSD.n918 4.5005
R9338 VSSD.n924 VSSD.n916 4.5005
R9339 VSSD.n926 VSSD.n916 4.5005
R9340 VSSD.n923 VSSD.n916 4.5005
R9341 VSSD.n927 VSSD.n916 4.5005
R9342 VSSD.n922 VSSD.n916 4.5005
R9343 VSSD.n928 VSSD.n916 4.5005
R9344 VSSD.n2635 VSSD.n916 4.5005
R9345 VSSD.n2637 VSSD.n916 4.5005
R9346 VSSD.n2636 VSSD.n924 4.5005
R9347 VSSD.n2636 VSSD.n926 4.5005
R9348 VSSD.n2636 VSSD.n923 4.5005
R9349 VSSD.n2636 VSSD.n927 4.5005
R9350 VSSD.n2636 VSSD.n922 4.5005
R9351 VSSD.n2636 VSSD.n928 4.5005
R9352 VSSD.n2636 VSSD.n2635 4.5005
R9353 VSSD.n2636 VSSD.n921 4.5005
R9354 VSSD.n2637 VSSD.n2636 4.5005
R9355 VSSD.n953 VSSD.n925 4.5005
R9356 VSSD.n952 VSSD.n925 4.5005
R9357 VSSD.n954 VSSD.n925 4.5005
R9358 VSSD.n951 VSSD.n925 4.5005
R9359 VSSD.n2632 VSSD.n925 4.5005
R9360 VSSD.n949 VSSD.n925 4.5005
R9361 VSSD.n2634 VSSD.n925 4.5005
R9362 VSSD.n925 VSSD.n917 4.5005
R9363 VSSD.n953 VSSD.n935 4.5005
R9364 VSSD.n952 VSSD.n935 4.5005
R9365 VSSD.n954 VSSD.n935 4.5005
R9366 VSSD.n951 VSSD.n935 4.5005
R9367 VSSD.n2632 VSSD.n935 4.5005
R9368 VSSD.n2634 VSSD.n935 4.5005
R9369 VSSD.n935 VSSD.n917 4.5005
R9370 VSSD.n953 VSSD.n938 4.5005
R9371 VSSD.n952 VSSD.n938 4.5005
R9372 VSSD.n954 VSSD.n938 4.5005
R9373 VSSD.n951 VSSD.n938 4.5005
R9374 VSSD.n2632 VSSD.n938 4.5005
R9375 VSSD.n2634 VSSD.n938 4.5005
R9376 VSSD.n938 VSSD.n917 4.5005
R9377 VSSD.n953 VSSD.n933 4.5005
R9378 VSSD.n952 VSSD.n933 4.5005
R9379 VSSD.n954 VSSD.n933 4.5005
R9380 VSSD.n951 VSSD.n933 4.5005
R9381 VSSD.n2632 VSSD.n933 4.5005
R9382 VSSD.n2634 VSSD.n933 4.5005
R9383 VSSD.n933 VSSD.n917 4.5005
R9384 VSSD.n953 VSSD.n940 4.5005
R9385 VSSD.n952 VSSD.n940 4.5005
R9386 VSSD.n954 VSSD.n940 4.5005
R9387 VSSD.n951 VSSD.n940 4.5005
R9388 VSSD.n2632 VSSD.n940 4.5005
R9389 VSSD.n2634 VSSD.n940 4.5005
R9390 VSSD.n940 VSSD.n917 4.5005
R9391 VSSD.n953 VSSD.n932 4.5005
R9392 VSSD.n952 VSSD.n932 4.5005
R9393 VSSD.n954 VSSD.n932 4.5005
R9394 VSSD.n951 VSSD.n932 4.5005
R9395 VSSD.n2632 VSSD.n932 4.5005
R9396 VSSD.n2634 VSSD.n932 4.5005
R9397 VSSD.n932 VSSD.n917 4.5005
R9398 VSSD.n953 VSSD.n942 4.5005
R9399 VSSD.n952 VSSD.n942 4.5005
R9400 VSSD.n954 VSSD.n942 4.5005
R9401 VSSD.n951 VSSD.n942 4.5005
R9402 VSSD.n2632 VSSD.n942 4.5005
R9403 VSSD.n2634 VSSD.n942 4.5005
R9404 VSSD.n942 VSSD.n917 4.5005
R9405 VSSD.n953 VSSD.n931 4.5005
R9406 VSSD.n952 VSSD.n931 4.5005
R9407 VSSD.n954 VSSD.n931 4.5005
R9408 VSSD.n951 VSSD.n931 4.5005
R9409 VSSD.n2632 VSSD.n931 4.5005
R9410 VSSD.n2634 VSSD.n931 4.5005
R9411 VSSD.n931 VSSD.n917 4.5005
R9412 VSSD.n953 VSSD.n944 4.5005
R9413 VSSD.n952 VSSD.n944 4.5005
R9414 VSSD.n954 VSSD.n944 4.5005
R9415 VSSD.n951 VSSD.n944 4.5005
R9416 VSSD.n2632 VSSD.n944 4.5005
R9417 VSSD.n2634 VSSD.n944 4.5005
R9418 VSSD.n944 VSSD.n917 4.5005
R9419 VSSD.n953 VSSD.n930 4.5005
R9420 VSSD.n952 VSSD.n930 4.5005
R9421 VSSD.n954 VSSD.n930 4.5005
R9422 VSSD.n951 VSSD.n930 4.5005
R9423 VSSD.n2632 VSSD.n930 4.5005
R9424 VSSD.n2634 VSSD.n930 4.5005
R9425 VSSD.n930 VSSD.n917 4.5005
R9426 VSSD.n2633 VSSD.n953 4.5005
R9427 VSSD.n2633 VSSD.n952 4.5005
R9428 VSSD.n2633 VSSD.n954 4.5005
R9429 VSSD.n2633 VSSD.n951 4.5005
R9430 VSSD.n2633 VSSD.n2632 4.5005
R9431 VSSD.n2634 VSSD.n2633 4.5005
R9432 VSSD.n2633 VSSD.n929 4.5005
R9433 VSSD.n2633 VSSD.n917 4.5005
R9434 VSSD.n286 VSSD.n281 4.5005
R9435 VSSD.n3272 VSSD.n281 4.5005
R9436 VSSD.n3253 VSSD.n280 4.5005
R9437 VSSD.n3272 VSSD.n280 4.5005
R9438 VSSD.n3253 VSSD.n283 4.5005
R9439 VSSD.n3245 VSSD.n283 4.5005
R9440 VSSD.n288 VSSD.n283 4.5005
R9441 VSSD.n3248 VSSD.n283 4.5005
R9442 VSSD.n287 VSSD.n283 4.5005
R9443 VSSD.n3270 VSSD.n283 4.5005
R9444 VSSD.n286 VSSD.n283 4.5005
R9445 VSSD.n3272 VSSD.n283 4.5005
R9446 VSSD.n3253 VSSD.n279 4.5005
R9447 VSSD.n3245 VSSD.n279 4.5005
R9448 VSSD.n288 VSSD.n279 4.5005
R9449 VSSD.n3248 VSSD.n279 4.5005
R9450 VSSD.n287 VSSD.n279 4.5005
R9451 VSSD.n3270 VSSD.n279 4.5005
R9452 VSSD.n3272 VSSD.n279 4.5005
R9453 VSSD.n3271 VSSD.n3245 4.5005
R9454 VSSD.n3271 VSSD.n288 4.5005
R9455 VSSD.n3271 VSSD.n3248 4.5005
R9456 VSSD.n3271 VSSD.n287 4.5005
R9457 VSSD.n3271 VSSD.n3270 4.5005
R9458 VSSD.n3271 VSSD.n286 4.5005
R9459 VSSD.n3272 VSSD.n3271 4.5005
R9460 VSSD.n299 VSSD.n294 4.5005
R9461 VSSD.n299 VSSD.n295 4.5005
R9462 VSSD.n299 VSSD.n293 4.5005
R9463 VSSD.n299 VSSD.n296 4.5005
R9464 VSSD.n299 VSSD.n292 4.5005
R9465 VSSD.n299 VSSD.n297 4.5005
R9466 VSSD.n3242 VSSD.n299 4.5005
R9467 VSSD.n3208 VSSD.n299 4.5005
R9468 VSSD.n3243 VSSD.n294 4.5005
R9469 VSSD.n3243 VSSD.n295 4.5005
R9470 VSSD.n3243 VSSD.n293 4.5005
R9471 VSSD.n3243 VSSD.n296 4.5005
R9472 VSSD.n3243 VSSD.n292 4.5005
R9473 VSSD.n3243 VSSD.n297 4.5005
R9474 VSSD.n3243 VSSD.n3242 4.5005
R9475 VSSD.n298 VSSD.n295 4.5005
R9476 VSSD.n298 VSSD.n293 4.5005
R9477 VSSD.n298 VSSD.n296 4.5005
R9478 VSSD.n298 VSSD.n292 4.5005
R9479 VSSD.n298 VSSD.n297 4.5005
R9480 VSSD.n3201 VSSD.n298 4.5005
R9481 VSSD.n3242 VSSD.n298 4.5005
R9482 VSSD.n3195 VSSD.n298 4.5005
R9483 VSSD.n3208 VSSD.n298 4.5005
R9484 VSSD.n3211 VSSD.n319 4.5005
R9485 VSSD.n3211 VSSD.n318 4.5005
R9486 VSSD.n3211 VSSD.n317 4.5005
R9487 VSSD.n3211 VSSD.n316 4.5005
R9488 VSSD.n3211 VSSD.n315 4.5005
R9489 VSSD.n3211 VSSD.n314 4.5005
R9490 VSSD.n3211 VSSD.n304 4.5005
R9491 VSSD.n3230 VSSD.n3211 4.5005
R9492 VSSD.n326 VSSD.n319 4.5005
R9493 VSSD.n326 VSSD.n318 4.5005
R9494 VSSD.n326 VSSD.n317 4.5005
R9495 VSSD.n326 VSSD.n316 4.5005
R9496 VSSD.n326 VSSD.n315 4.5005
R9497 VSSD.n326 VSSD.n304 4.5005
R9498 VSSD.n3230 VSSD.n326 4.5005
R9499 VSSD.n3213 VSSD.n319 4.5005
R9500 VSSD.n3213 VSSD.n318 4.5005
R9501 VSSD.n3213 VSSD.n317 4.5005
R9502 VSSD.n3213 VSSD.n316 4.5005
R9503 VSSD.n3213 VSSD.n315 4.5005
R9504 VSSD.n3213 VSSD.n304 4.5005
R9505 VSSD.n3230 VSSD.n3213 4.5005
R9506 VSSD.n325 VSSD.n319 4.5005
R9507 VSSD.n325 VSSD.n318 4.5005
R9508 VSSD.n325 VSSD.n317 4.5005
R9509 VSSD.n325 VSSD.n316 4.5005
R9510 VSSD.n325 VSSD.n315 4.5005
R9511 VSSD.n325 VSSD.n304 4.5005
R9512 VSSD.n3230 VSSD.n325 4.5005
R9513 VSSD.n3227 VSSD.n319 4.5005
R9514 VSSD.n3227 VSSD.n318 4.5005
R9515 VSSD.n3227 VSSD.n317 4.5005
R9516 VSSD.n3227 VSSD.n316 4.5005
R9517 VSSD.n3227 VSSD.n315 4.5005
R9518 VSSD.n3227 VSSD.n304 4.5005
R9519 VSSD.n3230 VSSD.n3227 4.5005
R9520 VSSD.n324 VSSD.n319 4.5005
R9521 VSSD.n324 VSSD.n318 4.5005
R9522 VSSD.n324 VSSD.n317 4.5005
R9523 VSSD.n324 VSSD.n316 4.5005
R9524 VSSD.n324 VSSD.n315 4.5005
R9525 VSSD.n324 VSSD.n304 4.5005
R9526 VSSD.n3230 VSSD.n324 4.5005
R9527 VSSD.n3229 VSSD.n319 4.5005
R9528 VSSD.n3229 VSSD.n318 4.5005
R9529 VSSD.n3229 VSSD.n317 4.5005
R9530 VSSD.n3229 VSSD.n316 4.5005
R9531 VSSD.n3229 VSSD.n315 4.5005
R9532 VSSD.n3229 VSSD.n304 4.5005
R9533 VSSD.n3230 VSSD.n3229 4.5005
R9534 VSSD.n3231 VSSD.n319 4.5005
R9535 VSSD.n3231 VSSD.n318 4.5005
R9536 VSSD.n3231 VSSD.n317 4.5005
R9537 VSSD.n3231 VSSD.n316 4.5005
R9538 VSSD.n3231 VSSD.n315 4.5005
R9539 VSSD.n3231 VSSD.n304 4.5005
R9540 VSSD.n3231 VSSD.n3230 4.5005
R9541 VSSD.n319 VSSD.n310 4.5005
R9542 VSSD.n318 VSSD.n310 4.5005
R9543 VSSD.n317 VSSD.n310 4.5005
R9544 VSSD.n316 VSSD.n310 4.5005
R9545 VSSD.n315 VSSD.n310 4.5005
R9546 VSSD.n310 VSSD.n304 4.5005
R9547 VSSD.n3239 VSSD.n310 4.5005
R9548 VSSD.n3237 VSSD.n319 4.5005
R9549 VSSD.n3237 VSSD.n318 4.5005
R9550 VSSD.n3237 VSSD.n317 4.5005
R9551 VSSD.n3237 VSSD.n316 4.5005
R9552 VSSD.n3237 VSSD.n315 4.5005
R9553 VSSD.n3237 VSSD.n314 4.5005
R9554 VSSD.n3237 VSSD.n304 4.5005
R9555 VSSD.n319 VSSD.n311 4.5005
R9556 VSSD.n318 VSSD.n311 4.5005
R9557 VSSD.n317 VSSD.n311 4.5005
R9558 VSSD.n316 VSSD.n311 4.5005
R9559 VSSD.n315 VSSD.n311 4.5005
R9560 VSSD.n314 VSSD.n311 4.5005
R9561 VSSD.n311 VSSD.n304 4.5005
R9562 VSSD.n3230 VSSD.n311 4.5005
R9563 VSSD.n3153 VSSD.n3152 4.5005
R9564 VSSD.n3152 VSSD.n342 4.5005
R9565 VSSD.n3152 VSSD.n3151 4.5005
R9566 VSSD.n352 VSSD.n345 4.5005
R9567 VSSD.n348 VSSD.n345 4.5005
R9568 VSSD.n3149 VSSD.n345 4.5005
R9569 VSSD.n3151 VSSD.n345 4.5005
R9570 VSSD.n3150 VSSD.n352 4.5005
R9571 VSSD.n3150 VSSD.n351 4.5005
R9572 VSSD.n3150 VSSD.n354 4.5005
R9573 VSSD.n3150 VSSD.n350 4.5005
R9574 VSSD.n3150 VSSD.n342 4.5005
R9575 VSSD.n3150 VSSD.n348 4.5005
R9576 VSSD.n3150 VSSD.n3149 4.5005
R9577 VSSD.n3151 VSSD.n3150 4.5005
R9578 VSSD.n3151 VSSD.n344 4.5005
R9579 VSSD.n3149 VSSD.n344 4.5005
R9580 VSSD.n348 VSSD.n344 4.5005
R9581 VSSD.n344 VSSD.n342 4.5005
R9582 VSSD.n350 VSSD.n344 4.5005
R9583 VSSD.n354 VSSD.n344 4.5005
R9584 VSSD.n351 VSSD.n344 4.5005
R9585 VSSD.n352 VSSD.n344 4.5005
R9586 VSSD.n3149 VSSD.n3148 4.5005
R9587 VSSD.n3148 VSSD.n348 4.5005
R9588 VSSD.n3148 VSSD.n342 4.5005
R9589 VSSD.n3148 VSSD.n350 4.5005
R9590 VSSD.n3148 VSSD.n354 4.5005
R9591 VSSD.n3148 VSSD.n351 4.5005
R9592 VSSD.n3148 VSSD.n352 4.5005
R9593 VSSD.n378 VSSD.n361 4.5005
R9594 VSSD.n380 VSSD.n361 4.5005
R9595 VSSD.n365 VSSD.n361 4.5005
R9596 VSSD.n381 VSSD.n361 4.5005
R9597 VSSD.n3144 VSSD.n361 4.5005
R9598 VSSD.n382 VSSD.n361 4.5005
R9599 VSSD.n3138 VSSD.n361 4.5005
R9600 VSSD.n383 VSSD.n361 4.5005
R9601 VSSD.n3142 VSSD.n361 4.5005
R9602 VSSD.n378 VSSD.n359 4.5005
R9603 VSSD.n380 VSSD.n359 4.5005
R9604 VSSD.n365 VSSD.n359 4.5005
R9605 VSSD.n381 VSSD.n359 4.5005
R9606 VSSD.n3144 VSSD.n359 4.5005
R9607 VSSD.n382 VSSD.n359 4.5005
R9608 VSSD.n383 VSSD.n359 4.5005
R9609 VSSD.n3142 VSSD.n359 4.5005
R9610 VSSD.n3143 VSSD.n378 4.5005
R9611 VSSD.n3143 VSSD.n380 4.5005
R9612 VSSD.n3143 VSSD.n365 4.5005
R9613 VSSD.n3143 VSSD.n381 4.5005
R9614 VSSD.n3144 VSSD.n3143 4.5005
R9615 VSSD.n3143 VSSD.n382 4.5005
R9616 VSSD.n3143 VSSD.n383 4.5005
R9617 VSSD.n3143 VSSD.n364 4.5005
R9618 VSSD.n3143 VSSD.n3142 4.5005
R9619 VSSD.n3131 VSSD.n379 4.5005
R9620 VSSD.n3130 VSSD.n379 4.5005
R9621 VSSD.n3132 VSSD.n379 4.5005
R9622 VSSD.n379 VSSD.n360 4.5005
R9623 VSSD.n379 VSSD.n358 4.5005
R9624 VSSD.n3137 VSSD.n379 4.5005
R9625 VSSD.n3139 VSSD.n379 4.5005
R9626 VSSD.n3141 VSSD.n379 4.5005
R9627 VSSD.n3131 VSSD.n3118 4.5005
R9628 VSSD.n3130 VSSD.n3118 4.5005
R9629 VSSD.n3132 VSSD.n3118 4.5005
R9630 VSSD.n3118 VSSD.n360 4.5005
R9631 VSSD.n3118 VSSD.n358 4.5005
R9632 VSSD.n3139 VSSD.n3118 4.5005
R9633 VSSD.n3141 VSSD.n3118 4.5005
R9634 VSSD.n3131 VSSD.n3119 4.5005
R9635 VSSD.n3130 VSSD.n3119 4.5005
R9636 VSSD.n3132 VSSD.n3119 4.5005
R9637 VSSD.n3119 VSSD.n360 4.5005
R9638 VSSD.n3119 VSSD.n358 4.5005
R9639 VSSD.n3139 VSSD.n3119 4.5005
R9640 VSSD.n3141 VSSD.n3119 4.5005
R9641 VSSD.n3131 VSSD.n3117 4.5005
R9642 VSSD.n3130 VSSD.n3117 4.5005
R9643 VSSD.n3132 VSSD.n3117 4.5005
R9644 VSSD.n3117 VSSD.n360 4.5005
R9645 VSSD.n3117 VSSD.n358 4.5005
R9646 VSSD.n3139 VSSD.n3117 4.5005
R9647 VSSD.n3141 VSSD.n3117 4.5005
R9648 VSSD.n3131 VSSD.n3120 4.5005
R9649 VSSD.n3130 VSSD.n3120 4.5005
R9650 VSSD.n3132 VSSD.n3120 4.5005
R9651 VSSD.n3120 VSSD.n360 4.5005
R9652 VSSD.n3120 VSSD.n358 4.5005
R9653 VSSD.n3139 VSSD.n3120 4.5005
R9654 VSSD.n3141 VSSD.n3120 4.5005
R9655 VSSD.n3131 VSSD.n3116 4.5005
R9656 VSSD.n3130 VSSD.n3116 4.5005
R9657 VSSD.n3132 VSSD.n3116 4.5005
R9658 VSSD.n3116 VSSD.n360 4.5005
R9659 VSSD.n3116 VSSD.n358 4.5005
R9660 VSSD.n3139 VSSD.n3116 4.5005
R9661 VSSD.n3141 VSSD.n3116 4.5005
R9662 VSSD.n3131 VSSD.n3121 4.5005
R9663 VSSD.n3130 VSSD.n3121 4.5005
R9664 VSSD.n3132 VSSD.n3121 4.5005
R9665 VSSD.n3121 VSSD.n360 4.5005
R9666 VSSD.n3121 VSSD.n358 4.5005
R9667 VSSD.n3139 VSSD.n3121 4.5005
R9668 VSSD.n3141 VSSD.n3121 4.5005
R9669 VSSD.n3131 VSSD.n3115 4.5005
R9670 VSSD.n3130 VSSD.n3115 4.5005
R9671 VSSD.n3132 VSSD.n3115 4.5005
R9672 VSSD.n3115 VSSD.n360 4.5005
R9673 VSSD.n3115 VSSD.n358 4.5005
R9674 VSSD.n3139 VSSD.n3115 4.5005
R9675 VSSD.n3141 VSSD.n3115 4.5005
R9676 VSSD.n3131 VSSD.n3122 4.5005
R9677 VSSD.n3130 VSSD.n3122 4.5005
R9678 VSSD.n3132 VSSD.n3122 4.5005
R9679 VSSD.n3122 VSSD.n360 4.5005
R9680 VSSD.n3122 VSSD.n358 4.5005
R9681 VSSD.n3139 VSSD.n3122 4.5005
R9682 VSSD.n3141 VSSD.n3122 4.5005
R9683 VSSD.n3131 VSSD.n3114 4.5005
R9684 VSSD.n3130 VSSD.n3114 4.5005
R9685 VSSD.n3132 VSSD.n3114 4.5005
R9686 VSSD.n3114 VSSD.n360 4.5005
R9687 VSSD.n3114 VSSD.n358 4.5005
R9688 VSSD.n3139 VSSD.n3114 4.5005
R9689 VSSD.n3141 VSSD.n3114 4.5005
R9690 VSSD.n3140 VSSD.n3131 4.5005
R9691 VSSD.n3140 VSSD.n3130 4.5005
R9692 VSSD.n3140 VSSD.n3132 4.5005
R9693 VSSD.n3140 VSSD.n360 4.5005
R9694 VSSD.n3140 VSSD.n358 4.5005
R9695 VSSD.n3140 VSSD.n3139 4.5005
R9696 VSSD.n3140 VSSD.n3129 4.5005
R9697 VSSD.n3141 VSSD.n3140 4.5005
R9698 VSSD.n2034 VSSD.n2033 4.5005
R9699 VSSD.n2034 VSSD.n1243 4.5005
R9700 VSSD.n2035 VSSD.n2034 4.5005
R9701 VSSD.n1254 VSSD.n1241 4.5005
R9702 VSSD.n1254 VSSD.n1246 4.5005
R9703 VSSD.n1254 VSSD.n1244 4.5005
R9704 VSSD.n2035 VSSD.n1254 4.5005
R9705 VSSD.n2036 VSSD.n1241 4.5005
R9706 VSSD.n2037 VSSD.n2036 4.5005
R9707 VSSD.n2036 VSSD.n1242 4.5005
R9708 VSSD.n2036 VSSD.n1247 4.5005
R9709 VSSD.n2036 VSSD.n1243 4.5005
R9710 VSSD.n2036 VSSD.n1246 4.5005
R9711 VSSD.n2036 VSSD.n1244 4.5005
R9712 VSSD.n2036 VSSD.n2035 4.5005
R9713 VSSD.n2035 VSSD.n1249 4.5005
R9714 VSSD.n1249 VSSD.n1244 4.5005
R9715 VSSD.n1249 VSSD.n1246 4.5005
R9716 VSSD.n1249 VSSD.n1243 4.5005
R9717 VSSD.n1249 VSSD.n1247 4.5005
R9718 VSSD.n1249 VSSD.n1242 4.5005
R9719 VSSD.n2037 VSSD.n1249 4.5005
R9720 VSSD.n1249 VSSD.n1241 4.5005
R9721 VSSD.n2038 VSSD.n1244 4.5005
R9722 VSSD.n2038 VSSD.n1246 4.5005
R9723 VSSD.n2038 VSSD.n1243 4.5005
R9724 VSSD.n2038 VSSD.n1247 4.5005
R9725 VSSD.n2038 VSSD.n1242 4.5005
R9726 VSSD.n2038 VSSD.n2037 4.5005
R9727 VSSD.n2038 VSSD.n1241 4.5005
R9728 VSSD.n2048 VSSD.n1203 4.5005
R9729 VSSD.n1210 VSSD.n1203 4.5005
R9730 VSSD.n1208 VSSD.n1203 4.5005
R9731 VSSD.n1211 VSSD.n1203 4.5005
R9732 VSSD.n1207 VSSD.n1203 4.5005
R9733 VSSD.n1212 VSSD.n1203 4.5005
R9734 VSSD.n1220 VSSD.n1203 4.5005
R9735 VSSD.n2046 VSSD.n1203 4.5005
R9736 VSSD.n1203 VSSD.n1108 4.5005
R9737 VSSD.n2048 VSSD.n1202 4.5005
R9738 VSSD.n1210 VSSD.n1202 4.5005
R9739 VSSD.n1208 VSSD.n1202 4.5005
R9740 VSSD.n1211 VSSD.n1202 4.5005
R9741 VSSD.n1207 VSSD.n1202 4.5005
R9742 VSSD.n1212 VSSD.n1202 4.5005
R9743 VSSD.n2046 VSSD.n1202 4.5005
R9744 VSSD.n1202 VSSD.n1108 4.5005
R9745 VSSD.n2048 VSSD.n2047 4.5005
R9746 VSSD.n2047 VSSD.n1210 4.5005
R9747 VSSD.n2047 VSSD.n1208 4.5005
R9748 VSSD.n2047 VSSD.n1211 4.5005
R9749 VSSD.n2047 VSSD.n1207 4.5005
R9750 VSSD.n2047 VSSD.n1212 4.5005
R9751 VSSD.n2047 VSSD.n2046 4.5005
R9752 VSSD.n2047 VSSD.n1206 4.5005
R9753 VSSD.n2047 VSSD.n1108 4.5005
R9754 VSSD.n1209 VSSD.n1201 4.5005
R9755 VSSD.n1236 VSSD.n1209 4.5005
R9756 VSSD.n1237 VSSD.n1209 4.5005
R9757 VSSD.n1235 VSSD.n1209 4.5005
R9758 VSSD.n2042 VSSD.n1209 4.5005
R9759 VSSD.n1233 VSSD.n1209 4.5005
R9760 VSSD.n2045 VSSD.n1209 4.5005
R9761 VSSD.n2043 VSSD.n1209 4.5005
R9762 VSSD.n1219 VSSD.n1201 4.5005
R9763 VSSD.n1236 VSSD.n1219 4.5005
R9764 VSSD.n1237 VSSD.n1219 4.5005
R9765 VSSD.n1235 VSSD.n1219 4.5005
R9766 VSSD.n2042 VSSD.n1219 4.5005
R9767 VSSD.n2045 VSSD.n1219 4.5005
R9768 VSSD.n2043 VSSD.n1219 4.5005
R9769 VSSD.n1222 VSSD.n1201 4.5005
R9770 VSSD.n1236 VSSD.n1222 4.5005
R9771 VSSD.n1237 VSSD.n1222 4.5005
R9772 VSSD.n1235 VSSD.n1222 4.5005
R9773 VSSD.n2042 VSSD.n1222 4.5005
R9774 VSSD.n2045 VSSD.n1222 4.5005
R9775 VSSD.n2043 VSSD.n1222 4.5005
R9776 VSSD.n1217 VSSD.n1201 4.5005
R9777 VSSD.n1236 VSSD.n1217 4.5005
R9778 VSSD.n1237 VSSD.n1217 4.5005
R9779 VSSD.n1235 VSSD.n1217 4.5005
R9780 VSSD.n2042 VSSD.n1217 4.5005
R9781 VSSD.n2045 VSSD.n1217 4.5005
R9782 VSSD.n2043 VSSD.n1217 4.5005
R9783 VSSD.n1224 VSSD.n1201 4.5005
R9784 VSSD.n1236 VSSD.n1224 4.5005
R9785 VSSD.n1237 VSSD.n1224 4.5005
R9786 VSSD.n1235 VSSD.n1224 4.5005
R9787 VSSD.n2042 VSSD.n1224 4.5005
R9788 VSSD.n2045 VSSD.n1224 4.5005
R9789 VSSD.n2043 VSSD.n1224 4.5005
R9790 VSSD.n1216 VSSD.n1201 4.5005
R9791 VSSD.n1236 VSSD.n1216 4.5005
R9792 VSSD.n1237 VSSD.n1216 4.5005
R9793 VSSD.n1235 VSSD.n1216 4.5005
R9794 VSSD.n2042 VSSD.n1216 4.5005
R9795 VSSD.n2045 VSSD.n1216 4.5005
R9796 VSSD.n2043 VSSD.n1216 4.5005
R9797 VSSD.n1226 VSSD.n1201 4.5005
R9798 VSSD.n1236 VSSD.n1226 4.5005
R9799 VSSD.n1237 VSSD.n1226 4.5005
R9800 VSSD.n1235 VSSD.n1226 4.5005
R9801 VSSD.n2042 VSSD.n1226 4.5005
R9802 VSSD.n2045 VSSD.n1226 4.5005
R9803 VSSD.n2043 VSSD.n1226 4.5005
R9804 VSSD.n1215 VSSD.n1201 4.5005
R9805 VSSD.n1236 VSSD.n1215 4.5005
R9806 VSSD.n1237 VSSD.n1215 4.5005
R9807 VSSD.n1235 VSSD.n1215 4.5005
R9808 VSSD.n2042 VSSD.n1215 4.5005
R9809 VSSD.n2045 VSSD.n1215 4.5005
R9810 VSSD.n2043 VSSD.n1215 4.5005
R9811 VSSD.n1228 VSSD.n1201 4.5005
R9812 VSSD.n1236 VSSD.n1228 4.5005
R9813 VSSD.n1237 VSSD.n1228 4.5005
R9814 VSSD.n1235 VSSD.n1228 4.5005
R9815 VSSD.n2042 VSSD.n1228 4.5005
R9816 VSSD.n2045 VSSD.n1228 4.5005
R9817 VSSD.n2043 VSSD.n1228 4.5005
R9818 VSSD.n1214 VSSD.n1201 4.5005
R9819 VSSD.n1236 VSSD.n1214 4.5005
R9820 VSSD.n1237 VSSD.n1214 4.5005
R9821 VSSD.n1235 VSSD.n1214 4.5005
R9822 VSSD.n2042 VSSD.n1214 4.5005
R9823 VSSD.n2045 VSSD.n1214 4.5005
R9824 VSSD.n2043 VSSD.n1214 4.5005
R9825 VSSD.n2044 VSSD.n1201 4.5005
R9826 VSSD.n2044 VSSD.n1236 4.5005
R9827 VSSD.n2044 VSSD.n1237 4.5005
R9828 VSSD.n2044 VSSD.n1235 4.5005
R9829 VSSD.n2044 VSSD.n2042 4.5005
R9830 VSSD.n2045 VSSD.n2044 4.5005
R9831 VSSD.n2044 VSSD.n1213 4.5005
R9832 VSSD.n2044 VSSD.n2043 4.5005
R9833 VSSD.n1193 VSSD.n1183 4.5005
R9834 VSSD.n1191 VSSD.n1183 4.5005
R9835 VSSD.n1194 VSSD.n1183 4.5005
R9836 VSSD.n1190 VSSD.n1183 4.5005
R9837 VSSD.n2092 VSSD.n1183 4.5005
R9838 VSSD.n2070 VSSD.n1183 4.5005
R9839 VSSD.n1183 VSSD.n1181 4.5005
R9840 VSSD.n2095 VSSD.n1183 4.5005
R9841 VSSD.n1200 VSSD.n1193 4.5005
R9842 VSSD.n1200 VSSD.n1191 4.5005
R9843 VSSD.n1200 VSSD.n1194 4.5005
R9844 VSSD.n1200 VSSD.n1190 4.5005
R9845 VSSD.n2092 VSSD.n1200 4.5005
R9846 VSSD.n2070 VSSD.n1200 4.5005
R9847 VSSD.n1200 VSSD.n1181 4.5005
R9848 VSSD.n2065 VSSD.n1193 4.5005
R9849 VSSD.n2065 VSSD.n1191 4.5005
R9850 VSSD.n2065 VSSD.n1194 4.5005
R9851 VSSD.n2065 VSSD.n1190 4.5005
R9852 VSSD.n2092 VSSD.n2065 4.5005
R9853 VSSD.n2065 VSSD.n1181 4.5005
R9854 VSSD.n2065 VSSD.n1110 4.5005
R9855 VSSD.n1198 VSSD.n1193 4.5005
R9856 VSSD.n1198 VSSD.n1191 4.5005
R9857 VSSD.n1198 VSSD.n1194 4.5005
R9858 VSSD.n1198 VSSD.n1190 4.5005
R9859 VSSD.n2092 VSSD.n1198 4.5005
R9860 VSSD.n1198 VSSD.n1181 4.5005
R9861 VSSD.n1198 VSSD.n1110 4.5005
R9862 VSSD.n2066 VSSD.n1193 4.5005
R9863 VSSD.n2066 VSSD.n1191 4.5005
R9864 VSSD.n2066 VSSD.n1194 4.5005
R9865 VSSD.n2066 VSSD.n1190 4.5005
R9866 VSSD.n2092 VSSD.n2066 4.5005
R9867 VSSD.n2066 VSSD.n1181 4.5005
R9868 VSSD.n2066 VSSD.n1110 4.5005
R9869 VSSD.n1197 VSSD.n1193 4.5005
R9870 VSSD.n1197 VSSD.n1191 4.5005
R9871 VSSD.n1197 VSSD.n1194 4.5005
R9872 VSSD.n1197 VSSD.n1190 4.5005
R9873 VSSD.n2092 VSSD.n1197 4.5005
R9874 VSSD.n1197 VSSD.n1181 4.5005
R9875 VSSD.n1197 VSSD.n1110 4.5005
R9876 VSSD.n2072 VSSD.n1193 4.5005
R9877 VSSD.n2072 VSSD.n1191 4.5005
R9878 VSSD.n2072 VSSD.n1194 4.5005
R9879 VSSD.n2072 VSSD.n1190 4.5005
R9880 VSSD.n2092 VSSD.n2072 4.5005
R9881 VSSD.n2072 VSSD.n1181 4.5005
R9882 VSSD.n2072 VSSD.n1110 4.5005
R9883 VSSD.n1196 VSSD.n1193 4.5005
R9884 VSSD.n1196 VSSD.n1191 4.5005
R9885 VSSD.n1196 VSSD.n1194 4.5005
R9886 VSSD.n1196 VSSD.n1190 4.5005
R9887 VSSD.n2092 VSSD.n1196 4.5005
R9888 VSSD.n1196 VSSD.n1181 4.5005
R9889 VSSD.n1196 VSSD.n1110 4.5005
R9890 VSSD.n2091 VSSD.n1193 4.5005
R9891 VSSD.n2091 VSSD.n1191 4.5005
R9892 VSSD.n2091 VSSD.n1194 4.5005
R9893 VSSD.n2091 VSSD.n1190 4.5005
R9894 VSSD.n2092 VSSD.n2091 4.5005
R9895 VSSD.n2091 VSSD.n1181 4.5005
R9896 VSSD.n2091 VSSD.n1110 4.5005
R9897 VSSD.n2093 VSSD.n1193 4.5005
R9898 VSSD.n2093 VSSD.n1191 4.5005
R9899 VSSD.n2093 VSSD.n1194 4.5005
R9900 VSSD.n2093 VSSD.n1190 4.5005
R9901 VSSD.n2093 VSSD.n2092 4.5005
R9902 VSSD.n2093 VSSD.n1181 4.5005
R9903 VSSD.n2093 VSSD.n1110 4.5005
R9904 VSSD.n1193 VSSD.n1188 4.5005
R9905 VSSD.n1191 VSSD.n1188 4.5005
R9906 VSSD.n1194 VSSD.n1188 4.5005
R9907 VSSD.n1190 VSSD.n1188 4.5005
R9908 VSSD.n2092 VSSD.n1188 4.5005
R9909 VSSD.n2070 VSSD.n1188 4.5005
R9910 VSSD.n1188 VSSD.n1181 4.5005
R9911 VSSD.n1188 VSSD.n1110 4.5005
R9912 VSSD.n2098 VSSD.n1163 4.5005
R9913 VSSD.n2100 VSSD.n1163 4.5005
R9914 VSSD.n2056 VSSD.n1162 4.5005
R9915 VSSD.n2100 VSSD.n1162 4.5005
R9916 VSSD.n2056 VSSD.n1165 4.5005
R9917 VSSD.n1169 VSSD.n1165 4.5005
R9918 VSSD.n1174 VSSD.n1165 4.5005
R9919 VSSD.n1168 VSSD.n1165 4.5005
R9920 VSSD.n1177 VSSD.n1165 4.5005
R9921 VSSD.n1167 VSSD.n1165 4.5005
R9922 VSSD.n2098 VSSD.n1165 4.5005
R9923 VSSD.n2100 VSSD.n1165 4.5005
R9924 VSSD.n2056 VSSD.n1161 4.5005
R9925 VSSD.n1169 VSSD.n1161 4.5005
R9926 VSSD.n1174 VSSD.n1161 4.5005
R9927 VSSD.n1168 VSSD.n1161 4.5005
R9928 VSSD.n1177 VSSD.n1161 4.5005
R9929 VSSD.n1167 VSSD.n1161 4.5005
R9930 VSSD.n2100 VSSD.n1161 4.5005
R9931 VSSD.n2099 VSSD.n1169 4.5005
R9932 VSSD.n2099 VSSD.n1174 4.5005
R9933 VSSD.n2099 VSSD.n1168 4.5005
R9934 VSSD.n2099 VSSD.n1177 4.5005
R9935 VSSD.n2099 VSSD.n1167 4.5005
R9936 VSSD.n2099 VSSD.n2098 4.5005
R9937 VSSD.n2100 VSSD.n2099 4.5005
R9938 VSSD.n1146 VSSD.n1142 4.5005
R9939 VSSD.n1146 VSSD.n1117 4.5005
R9940 VSSD.n1146 VSSD.n1118 4.5005
R9941 VSSD.n1146 VSSD.n1116 4.5005
R9942 VSSD.n1146 VSSD.n1119 4.5005
R9943 VSSD.n1146 VSSD.n1115 4.5005
R9944 VSSD.n1146 VSSD.n1114 4.5005
R9945 VSSD.n1146 VSSD.n1113 4.5005
R9946 VSSD.n1144 VSSD.n1142 4.5005
R9947 VSSD.n1144 VSSD.n1117 4.5005
R9948 VSSD.n1144 VSSD.n1118 4.5005
R9949 VSSD.n1144 VSSD.n1116 4.5005
R9950 VSSD.n1144 VSSD.n1119 4.5005
R9951 VSSD.n1144 VSSD.n1115 4.5005
R9952 VSSD.n1144 VSSD.n1114 4.5005
R9953 VSSD.n1160 VSSD.n1117 4.5005
R9954 VSSD.n1160 VSSD.n1118 4.5005
R9955 VSSD.n1160 VSSD.n1116 4.5005
R9956 VSSD.n1160 VSSD.n1119 4.5005
R9957 VSSD.n1160 VSSD.n1115 4.5005
R9958 VSSD.n1160 VSSD.n1120 4.5005
R9959 VSSD.n1160 VSSD.n1114 4.5005
R9960 VSSD.n1160 VSSD.n1121 4.5005
R9961 VSSD.n1160 VSSD.n1113 4.5005
R9962 VSSD.n2867 VSSD.n2866 4.5005
R9963 VSSD.n2867 VSSD.n662 4.5005
R9964 VSSD.n2868 VSSD.n2867 4.5005
R9965 VSSD.n673 VSSD.n660 4.5005
R9966 VSSD.n673 VSSD.n665 4.5005
R9967 VSSD.n673 VSSD.n663 4.5005
R9968 VSSD.n2868 VSSD.n673 4.5005
R9969 VSSD.n2869 VSSD.n660 4.5005
R9970 VSSD.n2870 VSSD.n2869 4.5005
R9971 VSSD.n2869 VSSD.n661 4.5005
R9972 VSSD.n2869 VSSD.n666 4.5005
R9973 VSSD.n2869 VSSD.n662 4.5005
R9974 VSSD.n2869 VSSD.n665 4.5005
R9975 VSSD.n2869 VSSD.n663 4.5005
R9976 VSSD.n2869 VSSD.n2868 4.5005
R9977 VSSD.n2868 VSSD.n668 4.5005
R9978 VSSD.n668 VSSD.n663 4.5005
R9979 VSSD.n668 VSSD.n665 4.5005
R9980 VSSD.n668 VSSD.n662 4.5005
R9981 VSSD.n668 VSSD.n666 4.5005
R9982 VSSD.n668 VSSD.n661 4.5005
R9983 VSSD.n2870 VSSD.n668 4.5005
R9984 VSSD.n668 VSSD.n660 4.5005
R9985 VSSD.n2871 VSSD.n663 4.5005
R9986 VSSD.n2871 VSSD.n665 4.5005
R9987 VSSD.n2871 VSSD.n662 4.5005
R9988 VSSD.n2871 VSSD.n666 4.5005
R9989 VSSD.n2871 VSSD.n661 4.5005
R9990 VSSD.n2871 VSSD.n2870 4.5005
R9991 VSSD.n2871 VSSD.n660 4.5005
R9992 VSSD.n2887 VSSD.n626 4.5005
R9993 VSSD.n633 VSSD.n626 4.5005
R9994 VSSD.n631 VSSD.n626 4.5005
R9995 VSSD.n634 VSSD.n626 4.5005
R9996 VSSD.n630 VSSD.n626 4.5005
R9997 VSSD.n635 VSSD.n626 4.5005
R9998 VSSD.n2881 VSSD.n626 4.5005
R9999 VSSD.n636 VSSD.n626 4.5005
R10000 VSSD.n2885 VSSD.n626 4.5005
R10001 VSSD.n2887 VSSD.n625 4.5005
R10002 VSSD.n633 VSSD.n625 4.5005
R10003 VSSD.n631 VSSD.n625 4.5005
R10004 VSSD.n634 VSSD.n625 4.5005
R10005 VSSD.n630 VSSD.n625 4.5005
R10006 VSSD.n635 VSSD.n625 4.5005
R10007 VSSD.n636 VSSD.n625 4.5005
R10008 VSSD.n2885 VSSD.n625 4.5005
R10009 VSSD.n2887 VSSD.n2886 4.5005
R10010 VSSD.n2886 VSSD.n633 4.5005
R10011 VSSD.n2886 VSSD.n631 4.5005
R10012 VSSD.n2886 VSSD.n634 4.5005
R10013 VSSD.n2886 VSSD.n630 4.5005
R10014 VSSD.n2886 VSSD.n635 4.5005
R10015 VSSD.n2886 VSSD.n636 4.5005
R10016 VSSD.n2886 VSSD.n629 4.5005
R10017 VSSD.n2886 VSSD.n2885 4.5005
R10018 VSSD.n632 VSSD.n624 4.5005
R10019 VSSD.n655 VSSD.n632 4.5005
R10020 VSSD.n656 VSSD.n632 4.5005
R10021 VSSD.n654 VSSD.n632 4.5005
R10022 VSSD.n2875 VSSD.n632 4.5005
R10023 VSSD.n2880 VSSD.n632 4.5005
R10024 VSSD.n2882 VSSD.n632 4.5005
R10025 VSSD.n2884 VSSD.n632 4.5005
R10026 VSSD.n642 VSSD.n624 4.5005
R10027 VSSD.n655 VSSD.n642 4.5005
R10028 VSSD.n656 VSSD.n642 4.5005
R10029 VSSD.n654 VSSD.n642 4.5005
R10030 VSSD.n2875 VSSD.n642 4.5005
R10031 VSSD.n2882 VSSD.n642 4.5005
R10032 VSSD.n2884 VSSD.n642 4.5005
R10033 VSSD.n643 VSSD.n624 4.5005
R10034 VSSD.n655 VSSD.n643 4.5005
R10035 VSSD.n656 VSSD.n643 4.5005
R10036 VSSD.n654 VSSD.n643 4.5005
R10037 VSSD.n2875 VSSD.n643 4.5005
R10038 VSSD.n2882 VSSD.n643 4.5005
R10039 VSSD.n2884 VSSD.n643 4.5005
R10040 VSSD.n641 VSSD.n624 4.5005
R10041 VSSD.n655 VSSD.n641 4.5005
R10042 VSSD.n656 VSSD.n641 4.5005
R10043 VSSD.n654 VSSD.n641 4.5005
R10044 VSSD.n2875 VSSD.n641 4.5005
R10045 VSSD.n2882 VSSD.n641 4.5005
R10046 VSSD.n2884 VSSD.n641 4.5005
R10047 VSSD.n644 VSSD.n624 4.5005
R10048 VSSD.n655 VSSD.n644 4.5005
R10049 VSSD.n656 VSSD.n644 4.5005
R10050 VSSD.n654 VSSD.n644 4.5005
R10051 VSSD.n2875 VSSD.n644 4.5005
R10052 VSSD.n2882 VSSD.n644 4.5005
R10053 VSSD.n2884 VSSD.n644 4.5005
R10054 VSSD.n640 VSSD.n624 4.5005
R10055 VSSD.n655 VSSD.n640 4.5005
R10056 VSSD.n656 VSSD.n640 4.5005
R10057 VSSD.n654 VSSD.n640 4.5005
R10058 VSSD.n2875 VSSD.n640 4.5005
R10059 VSSD.n2882 VSSD.n640 4.5005
R10060 VSSD.n2884 VSSD.n640 4.5005
R10061 VSSD.n645 VSSD.n624 4.5005
R10062 VSSD.n655 VSSD.n645 4.5005
R10063 VSSD.n656 VSSD.n645 4.5005
R10064 VSSD.n654 VSSD.n645 4.5005
R10065 VSSD.n2875 VSSD.n645 4.5005
R10066 VSSD.n2882 VSSD.n645 4.5005
R10067 VSSD.n2884 VSSD.n645 4.5005
R10068 VSSD.n639 VSSD.n624 4.5005
R10069 VSSD.n655 VSSD.n639 4.5005
R10070 VSSD.n656 VSSD.n639 4.5005
R10071 VSSD.n654 VSSD.n639 4.5005
R10072 VSSD.n2875 VSSD.n639 4.5005
R10073 VSSD.n2882 VSSD.n639 4.5005
R10074 VSSD.n2884 VSSD.n639 4.5005
R10075 VSSD.n646 VSSD.n624 4.5005
R10076 VSSD.n655 VSSD.n646 4.5005
R10077 VSSD.n656 VSSD.n646 4.5005
R10078 VSSD.n654 VSSD.n646 4.5005
R10079 VSSD.n2875 VSSD.n646 4.5005
R10080 VSSD.n2882 VSSD.n646 4.5005
R10081 VSSD.n2884 VSSD.n646 4.5005
R10082 VSSD.n638 VSSD.n624 4.5005
R10083 VSSD.n655 VSSD.n638 4.5005
R10084 VSSD.n656 VSSD.n638 4.5005
R10085 VSSD.n654 VSSD.n638 4.5005
R10086 VSSD.n2875 VSSD.n638 4.5005
R10087 VSSD.n2882 VSSD.n638 4.5005
R10088 VSSD.n2884 VSSD.n638 4.5005
R10089 VSSD.n2883 VSSD.n624 4.5005
R10090 VSSD.n2883 VSSD.n655 4.5005
R10091 VSSD.n2883 VSSD.n656 4.5005
R10092 VSSD.n2883 VSSD.n654 4.5005
R10093 VSSD.n2883 VSSD.n2875 4.5005
R10094 VSSD.n2883 VSSD.n2882 4.5005
R10095 VSSD.n2883 VSSD.n653 4.5005
R10096 VSSD.n2884 VSSD.n2883 4.5005
R10097 VSSD.n616 VSSD.n606 4.5005
R10098 VSSD.n614 VSSD.n606 4.5005
R10099 VSSD.n617 VSSD.n606 4.5005
R10100 VSSD.n613 VSSD.n606 4.5005
R10101 VSSD.n2931 VSSD.n606 4.5005
R10102 VSSD.n2909 VSSD.n606 4.5005
R10103 VSSD.n606 VSSD.n604 4.5005
R10104 VSSD.n2934 VSSD.n606 4.5005
R10105 VSSD.n623 VSSD.n616 4.5005
R10106 VSSD.n623 VSSD.n614 4.5005
R10107 VSSD.n623 VSSD.n617 4.5005
R10108 VSSD.n623 VSSD.n613 4.5005
R10109 VSSD.n2931 VSSD.n623 4.5005
R10110 VSSD.n2909 VSSD.n623 4.5005
R10111 VSSD.n623 VSSD.n604 4.5005
R10112 VSSD.n2904 VSSD.n616 4.5005
R10113 VSSD.n2904 VSSD.n614 4.5005
R10114 VSSD.n2904 VSSD.n617 4.5005
R10115 VSSD.n2904 VSSD.n613 4.5005
R10116 VSSD.n2931 VSSD.n2904 4.5005
R10117 VSSD.n2904 VSSD.n604 4.5005
R10118 VSSD.n2904 VSSD.n581 4.5005
R10119 VSSD.n621 VSSD.n616 4.5005
R10120 VSSD.n621 VSSD.n614 4.5005
R10121 VSSD.n621 VSSD.n617 4.5005
R10122 VSSD.n621 VSSD.n613 4.5005
R10123 VSSD.n2931 VSSD.n621 4.5005
R10124 VSSD.n621 VSSD.n604 4.5005
R10125 VSSD.n621 VSSD.n581 4.5005
R10126 VSSD.n2905 VSSD.n616 4.5005
R10127 VSSD.n2905 VSSD.n614 4.5005
R10128 VSSD.n2905 VSSD.n617 4.5005
R10129 VSSD.n2905 VSSD.n613 4.5005
R10130 VSSD.n2931 VSSD.n2905 4.5005
R10131 VSSD.n2905 VSSD.n604 4.5005
R10132 VSSD.n2905 VSSD.n581 4.5005
R10133 VSSD.n620 VSSD.n616 4.5005
R10134 VSSD.n620 VSSD.n614 4.5005
R10135 VSSD.n620 VSSD.n617 4.5005
R10136 VSSD.n620 VSSD.n613 4.5005
R10137 VSSD.n2931 VSSD.n620 4.5005
R10138 VSSD.n620 VSSD.n604 4.5005
R10139 VSSD.n620 VSSD.n581 4.5005
R10140 VSSD.n2911 VSSD.n616 4.5005
R10141 VSSD.n2911 VSSD.n614 4.5005
R10142 VSSD.n2911 VSSD.n617 4.5005
R10143 VSSD.n2911 VSSD.n613 4.5005
R10144 VSSD.n2931 VSSD.n2911 4.5005
R10145 VSSD.n2911 VSSD.n604 4.5005
R10146 VSSD.n2911 VSSD.n581 4.5005
R10147 VSSD.n619 VSSD.n616 4.5005
R10148 VSSD.n619 VSSD.n614 4.5005
R10149 VSSD.n619 VSSD.n617 4.5005
R10150 VSSD.n619 VSSD.n613 4.5005
R10151 VSSD.n2931 VSSD.n619 4.5005
R10152 VSSD.n619 VSSD.n604 4.5005
R10153 VSSD.n619 VSSD.n581 4.5005
R10154 VSSD.n2930 VSSD.n616 4.5005
R10155 VSSD.n2930 VSSD.n614 4.5005
R10156 VSSD.n2930 VSSD.n617 4.5005
R10157 VSSD.n2930 VSSD.n613 4.5005
R10158 VSSD.n2931 VSSD.n2930 4.5005
R10159 VSSD.n2930 VSSD.n604 4.5005
R10160 VSSD.n2930 VSSD.n581 4.5005
R10161 VSSD.n2932 VSSD.n616 4.5005
R10162 VSSD.n2932 VSSD.n614 4.5005
R10163 VSSD.n2932 VSSD.n617 4.5005
R10164 VSSD.n2932 VSSD.n613 4.5005
R10165 VSSD.n2932 VSSD.n2931 4.5005
R10166 VSSD.n2932 VSSD.n604 4.5005
R10167 VSSD.n2932 VSSD.n581 4.5005
R10168 VSSD.n616 VSSD.n611 4.5005
R10169 VSSD.n614 VSSD.n611 4.5005
R10170 VSSD.n617 VSSD.n611 4.5005
R10171 VSSD.n613 VSSD.n611 4.5005
R10172 VSSD.n2931 VSSD.n611 4.5005
R10173 VSSD.n2909 VSSD.n611 4.5005
R10174 VSSD.n611 VSSD.n604 4.5005
R10175 VSSD.n611 VSSD.n581 4.5005
R10176 VSSD.n2937 VSSD.n586 4.5005
R10177 VSSD.n2939 VSSD.n586 4.5005
R10178 VSSD.n2895 VSSD.n585 4.5005
R10179 VSSD.n2939 VSSD.n585 4.5005
R10180 VSSD.n2895 VSSD.n588 4.5005
R10181 VSSD.n592 VSSD.n588 4.5005
R10182 VSSD.n597 VSSD.n588 4.5005
R10183 VSSD.n591 VSSD.n588 4.5005
R10184 VSSD.n600 VSSD.n588 4.5005
R10185 VSSD.n590 VSSD.n588 4.5005
R10186 VSSD.n2937 VSSD.n588 4.5005
R10187 VSSD.n2939 VSSD.n588 4.5005
R10188 VSSD.n2895 VSSD.n584 4.5005
R10189 VSSD.n592 VSSD.n584 4.5005
R10190 VSSD.n597 VSSD.n584 4.5005
R10191 VSSD.n591 VSSD.n584 4.5005
R10192 VSSD.n600 VSSD.n584 4.5005
R10193 VSSD.n590 VSSD.n584 4.5005
R10194 VSSD.n2939 VSSD.n584 4.5005
R10195 VSSD.n2938 VSSD.n592 4.5005
R10196 VSSD.n2938 VSSD.n597 4.5005
R10197 VSSD.n2938 VSSD.n591 4.5005
R10198 VSSD.n2938 VSSD.n600 4.5005
R10199 VSSD.n2938 VSSD.n590 4.5005
R10200 VSSD.n2938 VSSD.n2937 4.5005
R10201 VSSD.n2939 VSSD.n2938 4.5005
R10202 VSSD.n692 VSSD.n686 4.5005
R10203 VSSD.n693 VSSD.n686 4.5005
R10204 VSSD.n691 VSSD.n686 4.5005
R10205 VSSD.n694 VSSD.n686 4.5005
R10206 VSSD.n690 VSSD.n686 4.5005
R10207 VSSD.n695 VSSD.n686 4.5005
R10208 VSSD.n723 VSSD.n686 4.5005
R10209 VSSD.n726 VSSD.n686 4.5005
R10210 VSSD.n724 VSSD.n692 4.5005
R10211 VSSD.n724 VSSD.n693 4.5005
R10212 VSSD.n724 VSSD.n691 4.5005
R10213 VSSD.n724 VSSD.n694 4.5005
R10214 VSSD.n724 VSSD.n690 4.5005
R10215 VSSD.n724 VSSD.n695 4.5005
R10216 VSSD.n724 VSSD.n723 4.5005
R10217 VSSD.n693 VSSD.n685 4.5005
R10218 VSSD.n691 VSSD.n685 4.5005
R10219 VSSD.n694 VSSD.n685 4.5005
R10220 VSSD.n690 VSSD.n685 4.5005
R10221 VSSD.n695 VSSD.n685 4.5005
R10222 VSSD.n708 VSSD.n685 4.5005
R10223 VSSD.n723 VSSD.n685 4.5005
R10224 VSSD.n688 VSSD.n685 4.5005
R10225 VSSD.n726 VSSD.n685 4.5005
R10226 VSSD.n3006 VSSD.n3005 4.5005
R10227 VSSD.n3006 VSSD.n479 4.5005
R10228 VSSD.n3007 VSSD.n3006 4.5005
R10229 VSSD.n490 VSSD.n477 4.5005
R10230 VSSD.n490 VSSD.n482 4.5005
R10231 VSSD.n490 VSSD.n480 4.5005
R10232 VSSD.n3007 VSSD.n490 4.5005
R10233 VSSD.n3008 VSSD.n477 4.5005
R10234 VSSD.n3009 VSSD.n3008 4.5005
R10235 VSSD.n3008 VSSD.n478 4.5005
R10236 VSSD.n3008 VSSD.n483 4.5005
R10237 VSSD.n3008 VSSD.n479 4.5005
R10238 VSSD.n3008 VSSD.n482 4.5005
R10239 VSSD.n3008 VSSD.n480 4.5005
R10240 VSSD.n3008 VSSD.n3007 4.5005
R10241 VSSD.n3007 VSSD.n485 4.5005
R10242 VSSD.n485 VSSD.n480 4.5005
R10243 VSSD.n485 VSSD.n482 4.5005
R10244 VSSD.n485 VSSD.n479 4.5005
R10245 VSSD.n485 VSSD.n483 4.5005
R10246 VSSD.n485 VSSD.n478 4.5005
R10247 VSSD.n3009 VSSD.n485 4.5005
R10248 VSSD.n485 VSSD.n477 4.5005
R10249 VSSD.n3010 VSSD.n480 4.5005
R10250 VSSD.n3010 VSSD.n482 4.5005
R10251 VSSD.n3010 VSSD.n479 4.5005
R10252 VSSD.n3010 VSSD.n483 4.5005
R10253 VSSD.n3010 VSSD.n478 4.5005
R10254 VSSD.n3010 VSSD.n3009 4.5005
R10255 VSSD.n3010 VSSD.n477 4.5005
R10256 VSSD.n3026 VSSD.n443 4.5005
R10257 VSSD.n450 VSSD.n443 4.5005
R10258 VSSD.n448 VSSD.n443 4.5005
R10259 VSSD.n451 VSSD.n443 4.5005
R10260 VSSD.n447 VSSD.n443 4.5005
R10261 VSSD.n452 VSSD.n443 4.5005
R10262 VSSD.n3020 VSSD.n443 4.5005
R10263 VSSD.n453 VSSD.n443 4.5005
R10264 VSSD.n3024 VSSD.n443 4.5005
R10265 VSSD.n3026 VSSD.n442 4.5005
R10266 VSSD.n450 VSSD.n442 4.5005
R10267 VSSD.n448 VSSD.n442 4.5005
R10268 VSSD.n451 VSSD.n442 4.5005
R10269 VSSD.n447 VSSD.n442 4.5005
R10270 VSSD.n452 VSSD.n442 4.5005
R10271 VSSD.n453 VSSD.n442 4.5005
R10272 VSSD.n3024 VSSD.n442 4.5005
R10273 VSSD.n3026 VSSD.n3025 4.5005
R10274 VSSD.n3025 VSSD.n450 4.5005
R10275 VSSD.n3025 VSSD.n448 4.5005
R10276 VSSD.n3025 VSSD.n451 4.5005
R10277 VSSD.n3025 VSSD.n447 4.5005
R10278 VSSD.n3025 VSSD.n452 4.5005
R10279 VSSD.n3025 VSSD.n453 4.5005
R10280 VSSD.n3025 VSSD.n446 4.5005
R10281 VSSD.n3025 VSSD.n3024 4.5005
R10282 VSSD.n449 VSSD.n441 4.5005
R10283 VSSD.n472 VSSD.n449 4.5005
R10284 VSSD.n473 VSSD.n449 4.5005
R10285 VSSD.n471 VSSD.n449 4.5005
R10286 VSSD.n3014 VSSD.n449 4.5005
R10287 VSSD.n3019 VSSD.n449 4.5005
R10288 VSSD.n3021 VSSD.n449 4.5005
R10289 VSSD.n3023 VSSD.n449 4.5005
R10290 VSSD.n459 VSSD.n441 4.5005
R10291 VSSD.n472 VSSD.n459 4.5005
R10292 VSSD.n473 VSSD.n459 4.5005
R10293 VSSD.n471 VSSD.n459 4.5005
R10294 VSSD.n3014 VSSD.n459 4.5005
R10295 VSSD.n3021 VSSD.n459 4.5005
R10296 VSSD.n3023 VSSD.n459 4.5005
R10297 VSSD.n460 VSSD.n441 4.5005
R10298 VSSD.n472 VSSD.n460 4.5005
R10299 VSSD.n473 VSSD.n460 4.5005
R10300 VSSD.n471 VSSD.n460 4.5005
R10301 VSSD.n3014 VSSD.n460 4.5005
R10302 VSSD.n3021 VSSD.n460 4.5005
R10303 VSSD.n3023 VSSD.n460 4.5005
R10304 VSSD.n458 VSSD.n441 4.5005
R10305 VSSD.n472 VSSD.n458 4.5005
R10306 VSSD.n473 VSSD.n458 4.5005
R10307 VSSD.n471 VSSD.n458 4.5005
R10308 VSSD.n3014 VSSD.n458 4.5005
R10309 VSSD.n3021 VSSD.n458 4.5005
R10310 VSSD.n3023 VSSD.n458 4.5005
R10311 VSSD.n461 VSSD.n441 4.5005
R10312 VSSD.n472 VSSD.n461 4.5005
R10313 VSSD.n473 VSSD.n461 4.5005
R10314 VSSD.n471 VSSD.n461 4.5005
R10315 VSSD.n3014 VSSD.n461 4.5005
R10316 VSSD.n3021 VSSD.n461 4.5005
R10317 VSSD.n3023 VSSD.n461 4.5005
R10318 VSSD.n457 VSSD.n441 4.5005
R10319 VSSD.n472 VSSD.n457 4.5005
R10320 VSSD.n473 VSSD.n457 4.5005
R10321 VSSD.n471 VSSD.n457 4.5005
R10322 VSSD.n3014 VSSD.n457 4.5005
R10323 VSSD.n3021 VSSD.n457 4.5005
R10324 VSSD.n3023 VSSD.n457 4.5005
R10325 VSSD.n462 VSSD.n441 4.5005
R10326 VSSD.n472 VSSD.n462 4.5005
R10327 VSSD.n473 VSSD.n462 4.5005
R10328 VSSD.n471 VSSD.n462 4.5005
R10329 VSSD.n3014 VSSD.n462 4.5005
R10330 VSSD.n3021 VSSD.n462 4.5005
R10331 VSSD.n3023 VSSD.n462 4.5005
R10332 VSSD.n456 VSSD.n441 4.5005
R10333 VSSD.n472 VSSD.n456 4.5005
R10334 VSSD.n473 VSSD.n456 4.5005
R10335 VSSD.n471 VSSD.n456 4.5005
R10336 VSSD.n3014 VSSD.n456 4.5005
R10337 VSSD.n3021 VSSD.n456 4.5005
R10338 VSSD.n3023 VSSD.n456 4.5005
R10339 VSSD.n463 VSSD.n441 4.5005
R10340 VSSD.n472 VSSD.n463 4.5005
R10341 VSSD.n473 VSSD.n463 4.5005
R10342 VSSD.n471 VSSD.n463 4.5005
R10343 VSSD.n3014 VSSD.n463 4.5005
R10344 VSSD.n3021 VSSD.n463 4.5005
R10345 VSSD.n3023 VSSD.n463 4.5005
R10346 VSSD.n455 VSSD.n441 4.5005
R10347 VSSD.n472 VSSD.n455 4.5005
R10348 VSSD.n473 VSSD.n455 4.5005
R10349 VSSD.n471 VSSD.n455 4.5005
R10350 VSSD.n3014 VSSD.n455 4.5005
R10351 VSSD.n3021 VSSD.n455 4.5005
R10352 VSSD.n3023 VSSD.n455 4.5005
R10353 VSSD.n3022 VSSD.n441 4.5005
R10354 VSSD.n3022 VSSD.n472 4.5005
R10355 VSSD.n3022 VSSD.n473 4.5005
R10356 VSSD.n3022 VSSD.n471 4.5005
R10357 VSSD.n3022 VSSD.n3014 4.5005
R10358 VSSD.n3022 VSSD.n3021 4.5005
R10359 VSSD.n3022 VSSD.n470 4.5005
R10360 VSSD.n3023 VSSD.n3022 4.5005
R10361 VSSD.n433 VSSD.n423 4.5005
R10362 VSSD.n431 VSSD.n423 4.5005
R10363 VSSD.n434 VSSD.n423 4.5005
R10364 VSSD.n430 VSSD.n423 4.5005
R10365 VSSD.n3070 VSSD.n423 4.5005
R10366 VSSD.n3048 VSSD.n423 4.5005
R10367 VSSD.n423 VSSD.n421 4.5005
R10368 VSSD.n3073 VSSD.n423 4.5005
R10369 VSSD.n440 VSSD.n433 4.5005
R10370 VSSD.n440 VSSD.n431 4.5005
R10371 VSSD.n440 VSSD.n434 4.5005
R10372 VSSD.n440 VSSD.n430 4.5005
R10373 VSSD.n3070 VSSD.n440 4.5005
R10374 VSSD.n3048 VSSD.n440 4.5005
R10375 VSSD.n440 VSSD.n421 4.5005
R10376 VSSD.n3043 VSSD.n433 4.5005
R10377 VSSD.n3043 VSSD.n431 4.5005
R10378 VSSD.n3043 VSSD.n434 4.5005
R10379 VSSD.n3043 VSSD.n430 4.5005
R10380 VSSD.n3070 VSSD.n3043 4.5005
R10381 VSSD.n3043 VSSD.n421 4.5005
R10382 VSSD.n3043 VSSD.n398 4.5005
R10383 VSSD.n438 VSSD.n433 4.5005
R10384 VSSD.n438 VSSD.n431 4.5005
R10385 VSSD.n438 VSSD.n434 4.5005
R10386 VSSD.n438 VSSD.n430 4.5005
R10387 VSSD.n3070 VSSD.n438 4.5005
R10388 VSSD.n438 VSSD.n421 4.5005
R10389 VSSD.n438 VSSD.n398 4.5005
R10390 VSSD.n3044 VSSD.n433 4.5005
R10391 VSSD.n3044 VSSD.n431 4.5005
R10392 VSSD.n3044 VSSD.n434 4.5005
R10393 VSSD.n3044 VSSD.n430 4.5005
R10394 VSSD.n3070 VSSD.n3044 4.5005
R10395 VSSD.n3044 VSSD.n421 4.5005
R10396 VSSD.n3044 VSSD.n398 4.5005
R10397 VSSD.n437 VSSD.n433 4.5005
R10398 VSSD.n437 VSSD.n431 4.5005
R10399 VSSD.n437 VSSD.n434 4.5005
R10400 VSSD.n437 VSSD.n430 4.5005
R10401 VSSD.n3070 VSSD.n437 4.5005
R10402 VSSD.n437 VSSD.n421 4.5005
R10403 VSSD.n437 VSSD.n398 4.5005
R10404 VSSD.n3050 VSSD.n433 4.5005
R10405 VSSD.n3050 VSSD.n431 4.5005
R10406 VSSD.n3050 VSSD.n434 4.5005
R10407 VSSD.n3050 VSSD.n430 4.5005
R10408 VSSD.n3070 VSSD.n3050 4.5005
R10409 VSSD.n3050 VSSD.n421 4.5005
R10410 VSSD.n3050 VSSD.n398 4.5005
R10411 VSSD.n436 VSSD.n433 4.5005
R10412 VSSD.n436 VSSD.n431 4.5005
R10413 VSSD.n436 VSSD.n434 4.5005
R10414 VSSD.n436 VSSD.n430 4.5005
R10415 VSSD.n3070 VSSD.n436 4.5005
R10416 VSSD.n436 VSSD.n421 4.5005
R10417 VSSD.n436 VSSD.n398 4.5005
R10418 VSSD.n3069 VSSD.n433 4.5005
R10419 VSSD.n3069 VSSD.n431 4.5005
R10420 VSSD.n3069 VSSD.n434 4.5005
R10421 VSSD.n3069 VSSD.n430 4.5005
R10422 VSSD.n3070 VSSD.n3069 4.5005
R10423 VSSD.n3069 VSSD.n421 4.5005
R10424 VSSD.n3069 VSSD.n398 4.5005
R10425 VSSD.n3071 VSSD.n433 4.5005
R10426 VSSD.n3071 VSSD.n431 4.5005
R10427 VSSD.n3071 VSSD.n434 4.5005
R10428 VSSD.n3071 VSSD.n430 4.5005
R10429 VSSD.n3071 VSSD.n3070 4.5005
R10430 VSSD.n3071 VSSD.n421 4.5005
R10431 VSSD.n3071 VSSD.n398 4.5005
R10432 VSSD.n433 VSSD.n428 4.5005
R10433 VSSD.n431 VSSD.n428 4.5005
R10434 VSSD.n434 VSSD.n428 4.5005
R10435 VSSD.n430 VSSD.n428 4.5005
R10436 VSSD.n3070 VSSD.n428 4.5005
R10437 VSSD.n3048 VSSD.n428 4.5005
R10438 VSSD.n428 VSSD.n421 4.5005
R10439 VSSD.n428 VSSD.n398 4.5005
R10440 VSSD.n3076 VSSD.n403 4.5005
R10441 VSSD.n3078 VSSD.n403 4.5005
R10442 VSSD.n3034 VSSD.n402 4.5005
R10443 VSSD.n3078 VSSD.n402 4.5005
R10444 VSSD.n3034 VSSD.n405 4.5005
R10445 VSSD.n409 VSSD.n405 4.5005
R10446 VSSD.n414 VSSD.n405 4.5005
R10447 VSSD.n408 VSSD.n405 4.5005
R10448 VSSD.n417 VSSD.n405 4.5005
R10449 VSSD.n407 VSSD.n405 4.5005
R10450 VSSD.n3076 VSSD.n405 4.5005
R10451 VSSD.n3078 VSSD.n405 4.5005
R10452 VSSD.n3034 VSSD.n401 4.5005
R10453 VSSD.n409 VSSD.n401 4.5005
R10454 VSSD.n414 VSSD.n401 4.5005
R10455 VSSD.n408 VSSD.n401 4.5005
R10456 VSSD.n417 VSSD.n401 4.5005
R10457 VSSD.n407 VSSD.n401 4.5005
R10458 VSSD.n3078 VSSD.n401 4.5005
R10459 VSSD.n3077 VSSD.n409 4.5005
R10460 VSSD.n3077 VSSD.n414 4.5005
R10461 VSSD.n3077 VSSD.n408 4.5005
R10462 VSSD.n3077 VSSD.n417 4.5005
R10463 VSSD.n3077 VSSD.n407 4.5005
R10464 VSSD.n3077 VSSD.n3076 4.5005
R10465 VSSD.n3078 VSSD.n3077 4.5005
R10466 VSSD.n508 VSSD.n502 4.5005
R10467 VSSD.n509 VSSD.n502 4.5005
R10468 VSSD.n507 VSSD.n502 4.5005
R10469 VSSD.n510 VSSD.n502 4.5005
R10470 VSSD.n506 VSSD.n502 4.5005
R10471 VSSD.n511 VSSD.n502 4.5005
R10472 VSSD.n539 VSSD.n502 4.5005
R10473 VSSD.n542 VSSD.n502 4.5005
R10474 VSSD.n540 VSSD.n508 4.5005
R10475 VSSD.n540 VSSD.n509 4.5005
R10476 VSSD.n540 VSSD.n507 4.5005
R10477 VSSD.n540 VSSD.n510 4.5005
R10478 VSSD.n540 VSSD.n506 4.5005
R10479 VSSD.n540 VSSD.n511 4.5005
R10480 VSSD.n540 VSSD.n539 4.5005
R10481 VSSD.n509 VSSD.n501 4.5005
R10482 VSSD.n507 VSSD.n501 4.5005
R10483 VSSD.n510 VSSD.n501 4.5005
R10484 VSSD.n506 VSSD.n501 4.5005
R10485 VSSD.n511 VSSD.n501 4.5005
R10486 VSSD.n524 VSSD.n501 4.5005
R10487 VSSD.n539 VSSD.n501 4.5005
R10488 VSSD.n504 VSSD.n501 4.5005
R10489 VSSD.n542 VSSD.n501 4.5005
R10490 VSSD.n2737 VSSD.n2723 4.5005
R10491 VSSD.n2732 VSSD.n2723 4.5005
R10492 VSSD.n2732 VSSD.n840 4.5005
R10493 VSSD.n2732 VSSD.n2728 4.5005
R10494 VSSD.n2732 VSSD.n838 4.5005
R10495 VSSD.n2732 VSSD.n2729 4.5005
R10496 VSSD.n2744 VSSD.n2732 4.5005
R10497 VSSD.n2743 VSSD.n2723 4.5005
R10498 VSSD.n2743 VSSD.n2725 4.5005
R10499 VSSD.n2743 VSSD.n839 4.5005
R10500 VSSD.n2743 VSSD.n2728 4.5005
R10501 VSSD.n2743 VSSD.n2729 4.5005
R10502 VSSD.n2744 VSSD.n2743 4.5005
R10503 VSSD.n2730 VSSD.n2723 4.5005
R10504 VSSD.n2730 VSSD.n2724 4.5005
R10505 VSSD.n2730 VSSD.n840 4.5005
R10506 VSSD.n2730 VSSD.n2725 4.5005
R10507 VSSD.n2730 VSSD.n839 4.5005
R10508 VSSD.n2730 VSSD.n2728 4.5005
R10509 VSSD.n2730 VSSD.n2729 4.5005
R10510 VSSD.n2744 VSSD.n2730 4.5005
R10511 VSSD.n2745 VSSD.n2723 4.5005
R10512 VSSD.n2745 VSSD.n2724 4.5005
R10513 VSSD.n2745 VSSD.n840 4.5005
R10514 VSSD.n2745 VSSD.n2725 4.5005
R10515 VSSD.n2745 VSSD.n839 4.5005
R10516 VSSD.n2745 VSSD.n2728 4.5005
R10517 VSSD.n2745 VSSD.n838 4.5005
R10518 VSSD.n2745 VSSD.n2729 4.5005
R10519 VSSD.n2745 VSSD.n2744 4.5005
R10520 VSSD.n804 VSSD.n798 4.5005
R10521 VSSD.n806 VSSD.n798 4.5005
R10522 VSSD.n803 VSSD.n798 4.5005
R10523 VSSD.n807 VSSD.n798 4.5005
R10524 VSSD.n802 VSSD.n798 4.5005
R10525 VSSD.n808 VSSD.n798 4.5005
R10526 VSSD.n816 VSSD.n798 4.5005
R10527 VSSD.n2752 VSSD.n798 4.5005
R10528 VSSD.n2754 VSSD.n798 4.5005
R10529 VSSD.n804 VSSD.n796 4.5005
R10530 VSSD.n806 VSSD.n796 4.5005
R10531 VSSD.n803 VSSD.n796 4.5005
R10532 VSSD.n807 VSSD.n796 4.5005
R10533 VSSD.n802 VSSD.n796 4.5005
R10534 VSSD.n808 VSSD.n796 4.5005
R10535 VSSD.n2752 VSSD.n796 4.5005
R10536 VSSD.n2754 VSSD.n796 4.5005
R10537 VSSD.n2753 VSSD.n804 4.5005
R10538 VSSD.n2753 VSSD.n806 4.5005
R10539 VSSD.n2753 VSSD.n803 4.5005
R10540 VSSD.n2753 VSSD.n807 4.5005
R10541 VSSD.n2753 VSSD.n802 4.5005
R10542 VSSD.n2753 VSSD.n808 4.5005
R10543 VSSD.n2753 VSSD.n2752 4.5005
R10544 VSSD.n2753 VSSD.n801 4.5005
R10545 VSSD.n2754 VSSD.n2753 4.5005
R10546 VSSD.n833 VSSD.n805 4.5005
R10547 VSSD.n832 VSSD.n805 4.5005
R10548 VSSD.n834 VSSD.n805 4.5005
R10549 VSSD.n831 VSSD.n805 4.5005
R10550 VSSD.n2749 VSSD.n805 4.5005
R10551 VSSD.n829 VSSD.n805 4.5005
R10552 VSSD.n2751 VSSD.n805 4.5005
R10553 VSSD.n805 VSSD.n797 4.5005
R10554 VSSD.n833 VSSD.n815 4.5005
R10555 VSSD.n832 VSSD.n815 4.5005
R10556 VSSD.n834 VSSD.n815 4.5005
R10557 VSSD.n831 VSSD.n815 4.5005
R10558 VSSD.n2749 VSSD.n815 4.5005
R10559 VSSD.n2751 VSSD.n815 4.5005
R10560 VSSD.n815 VSSD.n797 4.5005
R10561 VSSD.n833 VSSD.n818 4.5005
R10562 VSSD.n832 VSSD.n818 4.5005
R10563 VSSD.n834 VSSD.n818 4.5005
R10564 VSSD.n831 VSSD.n818 4.5005
R10565 VSSD.n2749 VSSD.n818 4.5005
R10566 VSSD.n2751 VSSD.n818 4.5005
R10567 VSSD.n818 VSSD.n797 4.5005
R10568 VSSD.n833 VSSD.n813 4.5005
R10569 VSSD.n832 VSSD.n813 4.5005
R10570 VSSD.n834 VSSD.n813 4.5005
R10571 VSSD.n831 VSSD.n813 4.5005
R10572 VSSD.n2749 VSSD.n813 4.5005
R10573 VSSD.n2751 VSSD.n813 4.5005
R10574 VSSD.n813 VSSD.n797 4.5005
R10575 VSSD.n833 VSSD.n820 4.5005
R10576 VSSD.n832 VSSD.n820 4.5005
R10577 VSSD.n834 VSSD.n820 4.5005
R10578 VSSD.n831 VSSD.n820 4.5005
R10579 VSSD.n2749 VSSD.n820 4.5005
R10580 VSSD.n2751 VSSD.n820 4.5005
R10581 VSSD.n820 VSSD.n797 4.5005
R10582 VSSD.n833 VSSD.n812 4.5005
R10583 VSSD.n832 VSSD.n812 4.5005
R10584 VSSD.n834 VSSD.n812 4.5005
R10585 VSSD.n831 VSSD.n812 4.5005
R10586 VSSD.n2749 VSSD.n812 4.5005
R10587 VSSD.n2751 VSSD.n812 4.5005
R10588 VSSD.n812 VSSD.n797 4.5005
R10589 VSSD.n833 VSSD.n822 4.5005
R10590 VSSD.n832 VSSD.n822 4.5005
R10591 VSSD.n834 VSSD.n822 4.5005
R10592 VSSD.n831 VSSD.n822 4.5005
R10593 VSSD.n2749 VSSD.n822 4.5005
R10594 VSSD.n2751 VSSD.n822 4.5005
R10595 VSSD.n822 VSSD.n797 4.5005
R10596 VSSD.n833 VSSD.n811 4.5005
R10597 VSSD.n832 VSSD.n811 4.5005
R10598 VSSD.n834 VSSD.n811 4.5005
R10599 VSSD.n831 VSSD.n811 4.5005
R10600 VSSD.n2749 VSSD.n811 4.5005
R10601 VSSD.n2751 VSSD.n811 4.5005
R10602 VSSD.n811 VSSD.n797 4.5005
R10603 VSSD.n833 VSSD.n824 4.5005
R10604 VSSD.n832 VSSD.n824 4.5005
R10605 VSSD.n834 VSSD.n824 4.5005
R10606 VSSD.n831 VSSD.n824 4.5005
R10607 VSSD.n2749 VSSD.n824 4.5005
R10608 VSSD.n2751 VSSD.n824 4.5005
R10609 VSSD.n824 VSSD.n797 4.5005
R10610 VSSD.n833 VSSD.n810 4.5005
R10611 VSSD.n832 VSSD.n810 4.5005
R10612 VSSD.n834 VSSD.n810 4.5005
R10613 VSSD.n831 VSSD.n810 4.5005
R10614 VSSD.n2749 VSSD.n810 4.5005
R10615 VSSD.n2751 VSSD.n810 4.5005
R10616 VSSD.n810 VSSD.n797 4.5005
R10617 VSSD.n2750 VSSD.n833 4.5005
R10618 VSSD.n2750 VSSD.n832 4.5005
R10619 VSSD.n2750 VSSD.n834 4.5005
R10620 VSSD.n2750 VSSD.n831 4.5005
R10621 VSSD.n2750 VSSD.n2749 4.5005
R10622 VSSD.n2751 VSSD.n2750 4.5005
R10623 VSSD.n2750 VSSD.n809 4.5005
R10624 VSSD.n2750 VSSD.n797 4.5005
R10625 VSSD.n2800 VSSD.n761 4.5005
R10626 VSSD.n2800 VSSD.n2771 4.5005
R10627 VSSD.n2800 VSSD.n2777 4.5005
R10628 VSSD.n2800 VSSD.n2769 4.5005
R10629 VSSD.n2800 VSSD.n2779 4.5005
R10630 VSSD.n2800 VSSD.n2768 4.5005
R10631 VSSD.n2801 VSSD.n2800 4.5005
R10632 VSSD.n2800 VSSD.n790 4.5005
R10633 VSSD.n2781 VSSD.n761 4.5005
R10634 VSSD.n2781 VSSD.n2771 4.5005
R10635 VSSD.n2781 VSSD.n2777 4.5005
R10636 VSSD.n2781 VSSD.n2769 4.5005
R10637 VSSD.n2781 VSSD.n2779 4.5005
R10638 VSSD.n2781 VSSD.n2768 4.5005
R10639 VSSD.n2801 VSSD.n2781 4.5005
R10640 VSSD.n2756 VSSD.n761 4.5005
R10641 VSSD.n2771 VSSD.n2756 4.5005
R10642 VSSD.n2777 VSSD.n2756 4.5005
R10643 VSSD.n2769 VSSD.n2756 4.5005
R10644 VSSD.n2779 VSSD.n2756 4.5005
R10645 VSSD.n2801 VSSD.n2756 4.5005
R10646 VSSD.n2803 VSSD.n2756 4.5005
R10647 VSSD.n794 VSSD.n761 4.5005
R10648 VSSD.n2771 VSSD.n794 4.5005
R10649 VSSD.n2777 VSSD.n794 4.5005
R10650 VSSD.n2769 VSSD.n794 4.5005
R10651 VSSD.n2779 VSSD.n794 4.5005
R10652 VSSD.n2801 VSSD.n794 4.5005
R10653 VSSD.n2803 VSSD.n794 4.5005
R10654 VSSD.n2758 VSSD.n761 4.5005
R10655 VSSD.n2771 VSSD.n2758 4.5005
R10656 VSSD.n2777 VSSD.n2758 4.5005
R10657 VSSD.n2769 VSSD.n2758 4.5005
R10658 VSSD.n2779 VSSD.n2758 4.5005
R10659 VSSD.n2801 VSSD.n2758 4.5005
R10660 VSSD.n2803 VSSD.n2758 4.5005
R10661 VSSD.n793 VSSD.n761 4.5005
R10662 VSSD.n2771 VSSD.n793 4.5005
R10663 VSSD.n2777 VSSD.n793 4.5005
R10664 VSSD.n2769 VSSD.n793 4.5005
R10665 VSSD.n2779 VSSD.n793 4.5005
R10666 VSSD.n2801 VSSD.n793 4.5005
R10667 VSSD.n2803 VSSD.n793 4.5005
R10668 VSSD.n2760 VSSD.n761 4.5005
R10669 VSSD.n2771 VSSD.n2760 4.5005
R10670 VSSD.n2777 VSSD.n2760 4.5005
R10671 VSSD.n2769 VSSD.n2760 4.5005
R10672 VSSD.n2779 VSSD.n2760 4.5005
R10673 VSSD.n2801 VSSD.n2760 4.5005
R10674 VSSD.n2803 VSSD.n2760 4.5005
R10675 VSSD.n792 VSSD.n761 4.5005
R10676 VSSD.n2771 VSSD.n792 4.5005
R10677 VSSD.n2777 VSSD.n792 4.5005
R10678 VSSD.n2769 VSSD.n792 4.5005
R10679 VSSD.n2779 VSSD.n792 4.5005
R10680 VSSD.n2801 VSSD.n792 4.5005
R10681 VSSD.n2803 VSSD.n792 4.5005
R10682 VSSD.n2762 VSSD.n761 4.5005
R10683 VSSD.n2771 VSSD.n2762 4.5005
R10684 VSSD.n2777 VSSD.n2762 4.5005
R10685 VSSD.n2769 VSSD.n2762 4.5005
R10686 VSSD.n2779 VSSD.n2762 4.5005
R10687 VSSD.n2801 VSSD.n2762 4.5005
R10688 VSSD.n2803 VSSD.n2762 4.5005
R10689 VSSD.n791 VSSD.n761 4.5005
R10690 VSSD.n2771 VSSD.n791 4.5005
R10691 VSSD.n2777 VSSD.n791 4.5005
R10692 VSSD.n2769 VSSD.n791 4.5005
R10693 VSSD.n2779 VSSD.n791 4.5005
R10694 VSSD.n2801 VSSD.n791 4.5005
R10695 VSSD.n2803 VSSD.n791 4.5005
R10696 VSSD.n2802 VSSD.n761 4.5005
R10697 VSSD.n2802 VSSD.n2771 4.5005
R10698 VSSD.n2802 VSSD.n2777 4.5005
R10699 VSSD.n2802 VSSD.n2769 4.5005
R10700 VSSD.n2802 VSSD.n2779 4.5005
R10701 VSSD.n2802 VSSD.n2768 4.5005
R10702 VSSD.n2802 VSSD.n2801 4.5005
R10703 VSSD.n2803 VSSD.n2802 4.5005
R10704 VSSD.n2812 VSSD.n770 4.5005
R10705 VSSD.n2812 VSSD.n2811 4.5005
R10706 VSSD.n776 VSSD.n765 4.5005
R10707 VSSD.n2811 VSSD.n765 4.5005
R10708 VSSD.n777 VSSD.n776 4.5005
R10709 VSSD.n781 VSSD.n777 4.5005
R10710 VSSD.n784 VSSD.n777 4.5005
R10711 VSSD.n780 VSSD.n777 4.5005
R10712 VSSD.n2809 VSSD.n777 4.5005
R10713 VSSD.n779 VSSD.n777 4.5005
R10714 VSSD.n777 VSSD.n770 4.5005
R10715 VSSD.n2811 VSSD.n777 4.5005
R10716 VSSD.n776 VSSD.n773 4.5005
R10717 VSSD.n781 VSSD.n773 4.5005
R10718 VSSD.n784 VSSD.n773 4.5005
R10719 VSSD.n780 VSSD.n773 4.5005
R10720 VSSD.n2809 VSSD.n773 4.5005
R10721 VSSD.n779 VSSD.n773 4.5005
R10722 VSSD.n2811 VSSD.n773 4.5005
R10723 VSSD.n2810 VSSD.n781 4.5005
R10724 VSSD.n2810 VSSD.n784 4.5005
R10725 VSSD.n2810 VSSD.n780 4.5005
R10726 VSSD.n2810 VSSD.n2809 4.5005
R10727 VSSD.n2810 VSSD.n779 4.5005
R10728 VSSD.n2810 VSSD.n770 4.5005
R10729 VSSD.n2811 VSSD.n2810 4.5005
R10730 VSSD.n2381 VSSD.n2368 4.5005
R10731 VSSD.n2381 VSSD.n2369 4.5005
R10732 VSSD.n2381 VSSD.n2370 4.5005
R10733 VSSD.n2390 VSSD.n2381 4.5005
R10734 VSSD.n2381 VSSD.n2373 4.5005
R10735 VSSD.n2381 VSSD.n2374 4.5005
R10736 VSSD.n2388 VSSD.n2381 4.5005
R10737 VSSD.n2381 VSSD.n2377 4.5005
R10738 VSSD.n2389 VSSD.n2368 4.5005
R10739 VSSD.n2389 VSSD.n2369 4.5005
R10740 VSSD.n2389 VSSD.n2370 4.5005
R10741 VSSD.n2390 VSSD.n2389 4.5005
R10742 VSSD.n2389 VSSD.n2373 4.5005
R10743 VSSD.n2389 VSSD.n2374 4.5005
R10744 VSSD.n2389 VSSD.n2388 4.5005
R10745 VSSD.n2379 VSSD.n2369 4.5005
R10746 VSSD.n2379 VSSD.n2370 4.5005
R10747 VSSD.n2390 VSSD.n2379 4.5005
R10748 VSSD.n2379 VSSD.n2373 4.5005
R10749 VSSD.n2379 VSSD.n2374 4.5005
R10750 VSSD.n2379 VSSD.n2375 4.5005
R10751 VSSD.n2388 VSSD.n2379 4.5005
R10752 VSSD.n2398 VSSD.n2379 4.5005
R10753 VSSD.n2379 VSSD.n2377 4.5005
R10754 VSSD.n2338 VSSD.n2337 4.5005
R10755 VSSD.n2337 VSSD.n1007 4.5005
R10756 VSSD.n2337 VSSD.n2336 4.5005
R10757 VSSD.n2330 VSSD.n1009 4.5005
R10758 VSSD.n1014 VSSD.n1009 4.5005
R10759 VSSD.n2333 VSSD.n1009 4.5005
R10760 VSSD.n2336 VSSD.n1009 4.5005
R10761 VSSD.n2330 VSSD.n1012 4.5005
R10762 VSSD.n1017 VSSD.n1012 4.5005
R10763 VSSD.n2332 VSSD.n1012 4.5005
R10764 VSSD.n1016 VSSD.n1012 4.5005
R10765 VSSD.n1012 VSSD.n1007 4.5005
R10766 VSSD.n1014 VSSD.n1012 4.5005
R10767 VSSD.n2333 VSSD.n1012 4.5005
R10768 VSSD.n2336 VSSD.n1012 4.5005
R10769 VSSD.n2330 VSSD.n1008 4.5005
R10770 VSSD.n1017 VSSD.n1008 4.5005
R10771 VSSD.n2332 VSSD.n1008 4.5005
R10772 VSSD.n1016 VSSD.n1008 4.5005
R10773 VSSD.n1008 VSSD.n1007 4.5005
R10774 VSSD.n1014 VSSD.n1008 4.5005
R10775 VSSD.n2333 VSSD.n1008 4.5005
R10776 VSSD.n2336 VSSD.n1008 4.5005
R10777 VSSD.n2335 VSSD.n2330 4.5005
R10778 VSSD.n2335 VSSD.n1017 4.5005
R10779 VSSD.n2335 VSSD.n2332 4.5005
R10780 VSSD.n2335 VSSD.n1016 4.5005
R10781 VSSD.n2335 VSSD.n1007 4.5005
R10782 VSSD.n2335 VSSD.n1014 4.5005
R10783 VSSD.n2336 VSSD.n2335 4.5005
R10784 VSSD.n2320 VSSD.n738 4.5005
R10785 VSSD.n2320 VSSD.n2311 4.5005
R10786 VSSD.n2320 VSSD.n2310 4.5005
R10787 VSSD.n2320 VSSD.n2312 4.5005
R10788 VSSD.n2320 VSSD.n1026 4.5005
R10789 VSSD.n2320 VSSD.n1020 4.5005
R10790 VSSD.n2320 VSSD.n2319 4.5005
R10791 VSSD.n2321 VSSD.n2320 4.5005
R10792 VSSD.n2320 VSSD.n2307 4.5005
R10793 VSSD.n2313 VSSD.n738 4.5005
R10794 VSSD.n2313 VSSD.n2311 4.5005
R10795 VSSD.n2313 VSSD.n2310 4.5005
R10796 VSSD.n2313 VSSD.n2312 4.5005
R10797 VSSD.n2313 VSSD.n1026 4.5005
R10798 VSSD.n2313 VSSD.n1020 4.5005
R10799 VSSD.n2321 VSSD.n2313 4.5005
R10800 VSSD.n2313 VSSD.n2307 4.5005
R10801 VSSD.n2322 VSSD.n738 4.5005
R10802 VSSD.n2322 VSSD.n2311 4.5005
R10803 VSSD.n2322 VSSD.n2310 4.5005
R10804 VSSD.n2322 VSSD.n2312 4.5005
R10805 VSSD.n2322 VSSD.n1026 4.5005
R10806 VSSD.n2322 VSSD.n1020 4.5005
R10807 VSSD.n2322 VSSD.n2321 4.5005
R10808 VSSD.n2323 VSSD.n2322 4.5005
R10809 VSSD.n2322 VSSD.n2307 4.5005
R10810 VSSD.n1041 VSSD.n1027 4.5005
R10811 VSSD.n1040 VSSD.n1027 4.5005
R10812 VSSD.n1042 VSSD.n1027 4.5005
R10813 VSSD.n1039 VSSD.n1027 4.5005
R10814 VSSD.n2326 VSSD.n1027 4.5005
R10815 VSSD.n2318 VSSD.n1027 4.5005
R10816 VSSD.n1043 VSSD.n1027 4.5005
R10817 VSSD.n2324 VSSD.n1027 4.5005
R10818 VSSD.n1041 VSSD.n1025 4.5005
R10819 VSSD.n1040 VSSD.n1025 4.5005
R10820 VSSD.n1042 VSSD.n1025 4.5005
R10821 VSSD.n1039 VSSD.n1025 4.5005
R10822 VSSD.n2326 VSSD.n1025 4.5005
R10823 VSSD.n1043 VSSD.n1025 4.5005
R10824 VSSD.n2324 VSSD.n1025 4.5005
R10825 VSSD.n1041 VSSD.n1028 4.5005
R10826 VSSD.n1040 VSSD.n1028 4.5005
R10827 VSSD.n1042 VSSD.n1028 4.5005
R10828 VSSD.n1039 VSSD.n1028 4.5005
R10829 VSSD.n2326 VSSD.n1028 4.5005
R10830 VSSD.n1043 VSSD.n1028 4.5005
R10831 VSSD.n2324 VSSD.n1028 4.5005
R10832 VSSD.n1041 VSSD.n1024 4.5005
R10833 VSSD.n1040 VSSD.n1024 4.5005
R10834 VSSD.n1042 VSSD.n1024 4.5005
R10835 VSSD.n1039 VSSD.n1024 4.5005
R10836 VSSD.n2326 VSSD.n1024 4.5005
R10837 VSSD.n1043 VSSD.n1024 4.5005
R10838 VSSD.n2324 VSSD.n1024 4.5005
R10839 VSSD.n1041 VSSD.n1029 4.5005
R10840 VSSD.n1040 VSSD.n1029 4.5005
R10841 VSSD.n1042 VSSD.n1029 4.5005
R10842 VSSD.n1039 VSSD.n1029 4.5005
R10843 VSSD.n2326 VSSD.n1029 4.5005
R10844 VSSD.n1043 VSSD.n1029 4.5005
R10845 VSSD.n2324 VSSD.n1029 4.5005
R10846 VSSD.n1041 VSSD.n1023 4.5005
R10847 VSSD.n1040 VSSD.n1023 4.5005
R10848 VSSD.n1042 VSSD.n1023 4.5005
R10849 VSSD.n1039 VSSD.n1023 4.5005
R10850 VSSD.n2326 VSSD.n1023 4.5005
R10851 VSSD.n1043 VSSD.n1023 4.5005
R10852 VSSD.n2324 VSSD.n1023 4.5005
R10853 VSSD.n1041 VSSD.n1030 4.5005
R10854 VSSD.n1040 VSSD.n1030 4.5005
R10855 VSSD.n1042 VSSD.n1030 4.5005
R10856 VSSD.n1039 VSSD.n1030 4.5005
R10857 VSSD.n2326 VSSD.n1030 4.5005
R10858 VSSD.n1043 VSSD.n1030 4.5005
R10859 VSSD.n2324 VSSD.n1030 4.5005
R10860 VSSD.n1041 VSSD.n1022 4.5005
R10861 VSSD.n1040 VSSD.n1022 4.5005
R10862 VSSD.n1042 VSSD.n1022 4.5005
R10863 VSSD.n1039 VSSD.n1022 4.5005
R10864 VSSD.n2326 VSSD.n1022 4.5005
R10865 VSSD.n1043 VSSD.n1022 4.5005
R10866 VSSD.n2324 VSSD.n1022 4.5005
R10867 VSSD.n1041 VSSD.n1031 4.5005
R10868 VSSD.n1040 VSSD.n1031 4.5005
R10869 VSSD.n1042 VSSD.n1031 4.5005
R10870 VSSD.n1039 VSSD.n1031 4.5005
R10871 VSSD.n2326 VSSD.n1031 4.5005
R10872 VSSD.n1043 VSSD.n1031 4.5005
R10873 VSSD.n2324 VSSD.n1031 4.5005
R10874 VSSD.n1041 VSSD.n1021 4.5005
R10875 VSSD.n1040 VSSD.n1021 4.5005
R10876 VSSD.n1042 VSSD.n1021 4.5005
R10877 VSSD.n1039 VSSD.n1021 4.5005
R10878 VSSD.n2326 VSSD.n1021 4.5005
R10879 VSSD.n1043 VSSD.n1021 4.5005
R10880 VSSD.n2324 VSSD.n1021 4.5005
R10881 VSSD.n2325 VSSD.n1041 4.5005
R10882 VSSD.n2325 VSSD.n1040 4.5005
R10883 VSSD.n2325 VSSD.n1042 4.5005
R10884 VSSD.n2325 VSSD.n1039 4.5005
R10885 VSSD.n2326 VSSD.n2325 4.5005
R10886 VSSD.n2325 VSSD.n1043 4.5005
R10887 VSSD.n2325 VSSD.n1038 4.5005
R10888 VSSD.n2325 VSSD.n2324 4.5005
R10889 VSSD.n1079 VSSD.n1069 4.5005
R10890 VSSD.n1077 VSSD.n1069 4.5005
R10891 VSSD.n1080 VSSD.n1069 4.5005
R10892 VSSD.n1076 VSSD.n1069 4.5005
R10893 VSSD.n2296 VSSD.n1069 4.5005
R10894 VSSD.n2274 VSSD.n1069 4.5005
R10895 VSSD.n1069 VSSD.n1067 4.5005
R10896 VSSD.n2299 VSSD.n1069 4.5005
R10897 VSSD.n1086 VSSD.n1079 4.5005
R10898 VSSD.n1086 VSSD.n1077 4.5005
R10899 VSSD.n1086 VSSD.n1080 4.5005
R10900 VSSD.n1086 VSSD.n1076 4.5005
R10901 VSSD.n2296 VSSD.n1086 4.5005
R10902 VSSD.n2274 VSSD.n1086 4.5005
R10903 VSSD.n1086 VSSD.n1067 4.5005
R10904 VSSD.n2269 VSSD.n1079 4.5005
R10905 VSSD.n2269 VSSD.n1077 4.5005
R10906 VSSD.n2269 VSSD.n1080 4.5005
R10907 VSSD.n2269 VSSD.n1076 4.5005
R10908 VSSD.n2296 VSSD.n2269 4.5005
R10909 VSSD.n2269 VSSD.n1067 4.5005
R10910 VSSD.n2269 VSSD.n1044 4.5005
R10911 VSSD.n1084 VSSD.n1079 4.5005
R10912 VSSD.n1084 VSSD.n1077 4.5005
R10913 VSSD.n1084 VSSD.n1080 4.5005
R10914 VSSD.n1084 VSSD.n1076 4.5005
R10915 VSSD.n2296 VSSD.n1084 4.5005
R10916 VSSD.n1084 VSSD.n1067 4.5005
R10917 VSSD.n1084 VSSD.n1044 4.5005
R10918 VSSD.n2270 VSSD.n1079 4.5005
R10919 VSSD.n2270 VSSD.n1077 4.5005
R10920 VSSD.n2270 VSSD.n1080 4.5005
R10921 VSSD.n2270 VSSD.n1076 4.5005
R10922 VSSD.n2296 VSSD.n2270 4.5005
R10923 VSSD.n2270 VSSD.n1067 4.5005
R10924 VSSD.n2270 VSSD.n1044 4.5005
R10925 VSSD.n1083 VSSD.n1079 4.5005
R10926 VSSD.n1083 VSSD.n1077 4.5005
R10927 VSSD.n1083 VSSD.n1080 4.5005
R10928 VSSD.n1083 VSSD.n1076 4.5005
R10929 VSSD.n2296 VSSD.n1083 4.5005
R10930 VSSD.n1083 VSSD.n1067 4.5005
R10931 VSSD.n1083 VSSD.n1044 4.5005
R10932 VSSD.n2276 VSSD.n1079 4.5005
R10933 VSSD.n2276 VSSD.n1077 4.5005
R10934 VSSD.n2276 VSSD.n1080 4.5005
R10935 VSSD.n2276 VSSD.n1076 4.5005
R10936 VSSD.n2296 VSSD.n2276 4.5005
R10937 VSSD.n2276 VSSD.n1067 4.5005
R10938 VSSD.n2276 VSSD.n1044 4.5005
R10939 VSSD.n1082 VSSD.n1079 4.5005
R10940 VSSD.n1082 VSSD.n1077 4.5005
R10941 VSSD.n1082 VSSD.n1080 4.5005
R10942 VSSD.n1082 VSSD.n1076 4.5005
R10943 VSSD.n2296 VSSD.n1082 4.5005
R10944 VSSD.n1082 VSSD.n1067 4.5005
R10945 VSSD.n1082 VSSD.n1044 4.5005
R10946 VSSD.n2295 VSSD.n1079 4.5005
R10947 VSSD.n2295 VSSD.n1077 4.5005
R10948 VSSD.n2295 VSSD.n1080 4.5005
R10949 VSSD.n2295 VSSD.n1076 4.5005
R10950 VSSD.n2296 VSSD.n2295 4.5005
R10951 VSSD.n2295 VSSD.n1067 4.5005
R10952 VSSD.n2295 VSSD.n1044 4.5005
R10953 VSSD.n2297 VSSD.n1079 4.5005
R10954 VSSD.n2297 VSSD.n1077 4.5005
R10955 VSSD.n2297 VSSD.n1080 4.5005
R10956 VSSD.n2297 VSSD.n1076 4.5005
R10957 VSSD.n2297 VSSD.n2296 4.5005
R10958 VSSD.n2297 VSSD.n1067 4.5005
R10959 VSSD.n2297 VSSD.n1044 4.5005
R10960 VSSD.n1079 VSSD.n1074 4.5005
R10961 VSSD.n1077 VSSD.n1074 4.5005
R10962 VSSD.n1080 VSSD.n1074 4.5005
R10963 VSSD.n1076 VSSD.n1074 4.5005
R10964 VSSD.n2296 VSSD.n1074 4.5005
R10965 VSSD.n2274 VSSD.n1074 4.5005
R10966 VSSD.n1074 VSSD.n1067 4.5005
R10967 VSSD.n1074 VSSD.n1044 4.5005
R10968 VSSD.n2302 VSSD.n1049 4.5005
R10969 VSSD.n2304 VSSD.n1049 4.5005
R10970 VSSD.n2260 VSSD.n1048 4.5005
R10971 VSSD.n2304 VSSD.n1048 4.5005
R10972 VSSD.n2260 VSSD.n1051 4.5005
R10973 VSSD.n1055 VSSD.n1051 4.5005
R10974 VSSD.n1060 VSSD.n1051 4.5005
R10975 VSSD.n1054 VSSD.n1051 4.5005
R10976 VSSD.n1063 VSSD.n1051 4.5005
R10977 VSSD.n1053 VSSD.n1051 4.5005
R10978 VSSD.n2302 VSSD.n1051 4.5005
R10979 VSSD.n2304 VSSD.n1051 4.5005
R10980 VSSD.n2260 VSSD.n1047 4.5005
R10981 VSSD.n1055 VSSD.n1047 4.5005
R10982 VSSD.n1060 VSSD.n1047 4.5005
R10983 VSSD.n1054 VSSD.n1047 4.5005
R10984 VSSD.n1063 VSSD.n1047 4.5005
R10985 VSSD.n1053 VSSD.n1047 4.5005
R10986 VSSD.n2304 VSSD.n1047 4.5005
R10987 VSSD.n2303 VSSD.n1055 4.5005
R10988 VSSD.n2303 VSSD.n1060 4.5005
R10989 VSSD.n2303 VSSD.n1054 4.5005
R10990 VSSD.n2303 VSSD.n1063 4.5005
R10991 VSSD.n2303 VSSD.n1053 4.5005
R10992 VSSD.n2303 VSSD.n2302 4.5005
R10993 VSSD.n2304 VSSD.n2303 4.5005
R10994 VSSD.n2187 VSSD.n2174 4.5005
R10995 VSSD.n2187 VSSD.n2175 4.5005
R10996 VSSD.n2187 VSSD.n2176 4.5005
R10997 VSSD.n2196 VSSD.n2187 4.5005
R10998 VSSD.n2187 VSSD.n2179 4.5005
R10999 VSSD.n2187 VSSD.n2180 4.5005
R11000 VSSD.n2194 VSSD.n2187 4.5005
R11001 VSSD.n2187 VSSD.n2183 4.5005
R11002 VSSD.n2195 VSSD.n2174 4.5005
R11003 VSSD.n2195 VSSD.n2175 4.5005
R11004 VSSD.n2195 VSSD.n2176 4.5005
R11005 VSSD.n2196 VSSD.n2195 4.5005
R11006 VSSD.n2195 VSSD.n2179 4.5005
R11007 VSSD.n2195 VSSD.n2180 4.5005
R11008 VSSD.n2195 VSSD.n2194 4.5005
R11009 VSSD.n2185 VSSD.n2175 4.5005
R11010 VSSD.n2185 VSSD.n2176 4.5005
R11011 VSSD.n2196 VSSD.n2185 4.5005
R11012 VSSD.n2185 VSSD.n2179 4.5005
R11013 VSSD.n2185 VSSD.n2180 4.5005
R11014 VSSD.n2185 VSSD.n2181 4.5005
R11015 VSSD.n2194 VSSD.n2185 4.5005
R11016 VSSD.n2204 VSSD.n2185 4.5005
R11017 VSSD.n2185 VSSD.n2183 4.5005
R11018 VSSD.n1685 VSSD.n1671 4.5005
R11019 VSSD.n1680 VSSD.n1671 4.5005
R11020 VSSD.n1680 VSSD.n1637 4.5005
R11021 VSSD.n1680 VSSD.n1676 4.5005
R11022 VSSD.n1680 VSSD.n1635 4.5005
R11023 VSSD.n1680 VSSD.n1677 4.5005
R11024 VSSD.n1692 VSSD.n1680 4.5005
R11025 VSSD.n1691 VSSD.n1671 4.5005
R11026 VSSD.n1691 VSSD.n1673 4.5005
R11027 VSSD.n1691 VSSD.n1636 4.5005
R11028 VSSD.n1691 VSSD.n1676 4.5005
R11029 VSSD.n1691 VSSD.n1677 4.5005
R11030 VSSD.n1692 VSSD.n1691 4.5005
R11031 VSSD.n1678 VSSD.n1671 4.5005
R11032 VSSD.n1678 VSSD.n1672 4.5005
R11033 VSSD.n1678 VSSD.n1637 4.5005
R11034 VSSD.n1678 VSSD.n1673 4.5005
R11035 VSSD.n1678 VSSD.n1636 4.5005
R11036 VSSD.n1678 VSSD.n1676 4.5005
R11037 VSSD.n1678 VSSD.n1677 4.5005
R11038 VSSD.n1692 VSSD.n1678 4.5005
R11039 VSSD.n1693 VSSD.n1671 4.5005
R11040 VSSD.n1693 VSSD.n1672 4.5005
R11041 VSSD.n1693 VSSD.n1637 4.5005
R11042 VSSD.n1693 VSSD.n1673 4.5005
R11043 VSSD.n1693 VSSD.n1636 4.5005
R11044 VSSD.n1693 VSSD.n1676 4.5005
R11045 VSSD.n1693 VSSD.n1635 4.5005
R11046 VSSD.n1693 VSSD.n1677 4.5005
R11047 VSSD.n1693 VSSD.n1692 4.5005
R11048 VSSD.n1601 VSSD.n1595 4.5005
R11049 VSSD.n1603 VSSD.n1595 4.5005
R11050 VSSD.n1600 VSSD.n1595 4.5005
R11051 VSSD.n1604 VSSD.n1595 4.5005
R11052 VSSD.n1599 VSSD.n1595 4.5005
R11053 VSSD.n1605 VSSD.n1595 4.5005
R11054 VSSD.n1613 VSSD.n1595 4.5005
R11055 VSSD.n1700 VSSD.n1595 4.5005
R11056 VSSD.n1702 VSSD.n1595 4.5005
R11057 VSSD.n1601 VSSD.n1593 4.5005
R11058 VSSD.n1603 VSSD.n1593 4.5005
R11059 VSSD.n1600 VSSD.n1593 4.5005
R11060 VSSD.n1604 VSSD.n1593 4.5005
R11061 VSSD.n1599 VSSD.n1593 4.5005
R11062 VSSD.n1605 VSSD.n1593 4.5005
R11063 VSSD.n1700 VSSD.n1593 4.5005
R11064 VSSD.n1702 VSSD.n1593 4.5005
R11065 VSSD.n1701 VSSD.n1601 4.5005
R11066 VSSD.n1701 VSSD.n1603 4.5005
R11067 VSSD.n1701 VSSD.n1600 4.5005
R11068 VSSD.n1701 VSSD.n1604 4.5005
R11069 VSSD.n1701 VSSD.n1599 4.5005
R11070 VSSD.n1701 VSSD.n1605 4.5005
R11071 VSSD.n1701 VSSD.n1700 4.5005
R11072 VSSD.n1701 VSSD.n1598 4.5005
R11073 VSSD.n1702 VSSD.n1701 4.5005
R11074 VSSD.n1630 VSSD.n1602 4.5005
R11075 VSSD.n1629 VSSD.n1602 4.5005
R11076 VSSD.n1631 VSSD.n1602 4.5005
R11077 VSSD.n1628 VSSD.n1602 4.5005
R11078 VSSD.n1697 VSSD.n1602 4.5005
R11079 VSSD.n1626 VSSD.n1602 4.5005
R11080 VSSD.n1699 VSSD.n1602 4.5005
R11081 VSSD.n1602 VSSD.n1594 4.5005
R11082 VSSD.n1630 VSSD.n1612 4.5005
R11083 VSSD.n1629 VSSD.n1612 4.5005
R11084 VSSD.n1631 VSSD.n1612 4.5005
R11085 VSSD.n1628 VSSD.n1612 4.5005
R11086 VSSD.n1697 VSSD.n1612 4.5005
R11087 VSSD.n1699 VSSD.n1612 4.5005
R11088 VSSD.n1612 VSSD.n1594 4.5005
R11089 VSSD.n1630 VSSD.n1615 4.5005
R11090 VSSD.n1629 VSSD.n1615 4.5005
R11091 VSSD.n1631 VSSD.n1615 4.5005
R11092 VSSD.n1628 VSSD.n1615 4.5005
R11093 VSSD.n1697 VSSD.n1615 4.5005
R11094 VSSD.n1699 VSSD.n1615 4.5005
R11095 VSSD.n1615 VSSD.n1594 4.5005
R11096 VSSD.n1630 VSSD.n1610 4.5005
R11097 VSSD.n1629 VSSD.n1610 4.5005
R11098 VSSD.n1631 VSSD.n1610 4.5005
R11099 VSSD.n1628 VSSD.n1610 4.5005
R11100 VSSD.n1697 VSSD.n1610 4.5005
R11101 VSSD.n1699 VSSD.n1610 4.5005
R11102 VSSD.n1610 VSSD.n1594 4.5005
R11103 VSSD.n1630 VSSD.n1617 4.5005
R11104 VSSD.n1629 VSSD.n1617 4.5005
R11105 VSSD.n1631 VSSD.n1617 4.5005
R11106 VSSD.n1628 VSSD.n1617 4.5005
R11107 VSSD.n1697 VSSD.n1617 4.5005
R11108 VSSD.n1699 VSSD.n1617 4.5005
R11109 VSSD.n1617 VSSD.n1594 4.5005
R11110 VSSD.n1630 VSSD.n1609 4.5005
R11111 VSSD.n1629 VSSD.n1609 4.5005
R11112 VSSD.n1631 VSSD.n1609 4.5005
R11113 VSSD.n1628 VSSD.n1609 4.5005
R11114 VSSD.n1697 VSSD.n1609 4.5005
R11115 VSSD.n1699 VSSD.n1609 4.5005
R11116 VSSD.n1609 VSSD.n1594 4.5005
R11117 VSSD.n1630 VSSD.n1619 4.5005
R11118 VSSD.n1629 VSSD.n1619 4.5005
R11119 VSSD.n1631 VSSD.n1619 4.5005
R11120 VSSD.n1628 VSSD.n1619 4.5005
R11121 VSSD.n1697 VSSD.n1619 4.5005
R11122 VSSD.n1699 VSSD.n1619 4.5005
R11123 VSSD.n1619 VSSD.n1594 4.5005
R11124 VSSD.n1630 VSSD.n1608 4.5005
R11125 VSSD.n1629 VSSD.n1608 4.5005
R11126 VSSD.n1631 VSSD.n1608 4.5005
R11127 VSSD.n1628 VSSD.n1608 4.5005
R11128 VSSD.n1697 VSSD.n1608 4.5005
R11129 VSSD.n1699 VSSD.n1608 4.5005
R11130 VSSD.n1608 VSSD.n1594 4.5005
R11131 VSSD.n1630 VSSD.n1621 4.5005
R11132 VSSD.n1629 VSSD.n1621 4.5005
R11133 VSSD.n1631 VSSD.n1621 4.5005
R11134 VSSD.n1628 VSSD.n1621 4.5005
R11135 VSSD.n1697 VSSD.n1621 4.5005
R11136 VSSD.n1699 VSSD.n1621 4.5005
R11137 VSSD.n1621 VSSD.n1594 4.5005
R11138 VSSD.n1630 VSSD.n1607 4.5005
R11139 VSSD.n1629 VSSD.n1607 4.5005
R11140 VSSD.n1631 VSSD.n1607 4.5005
R11141 VSSD.n1628 VSSD.n1607 4.5005
R11142 VSSD.n1697 VSSD.n1607 4.5005
R11143 VSSD.n1699 VSSD.n1607 4.5005
R11144 VSSD.n1607 VSSD.n1594 4.5005
R11145 VSSD.n1698 VSSD.n1630 4.5005
R11146 VSSD.n1698 VSSD.n1629 4.5005
R11147 VSSD.n1698 VSSD.n1631 4.5005
R11148 VSSD.n1698 VSSD.n1628 4.5005
R11149 VSSD.n1698 VSSD.n1697 4.5005
R11150 VSSD.n1699 VSSD.n1698 4.5005
R11151 VSSD.n1698 VSSD.n1606 4.5005
R11152 VSSD.n1698 VSSD.n1594 4.5005
R11153 VSSD.n1719 VSSD.n1560 4.5005
R11154 VSSD.n1838 VSSD.n1560 4.5005
R11155 VSSD.n1560 VSSD.n1553 4.5005
R11156 VSSD.n1572 VSSD.n1560 4.5005
R11157 VSSD.n1720 VSSD.n1560 4.5005
R11158 VSSD.n1570 VSSD.n1560 4.5005
R11159 VSSD.n1721 VSSD.n1560 4.5005
R11160 VSSD.n1836 VSSD.n1560 4.5005
R11161 VSSD.n1719 VSSD.n1558 4.5005
R11162 VSSD.n1838 VSSD.n1558 4.5005
R11163 VSSD.n1558 VSSD.n1553 4.5005
R11164 VSSD.n1572 VSSD.n1558 4.5005
R11165 VSSD.n1720 VSSD.n1558 4.5005
R11166 VSSD.n1721 VSSD.n1558 4.5005
R11167 VSSD.n1836 VSSD.n1558 4.5005
R11168 VSSD.n1719 VSSD.n1561 4.5005
R11169 VSSD.n1838 VSSD.n1561 4.5005
R11170 VSSD.n1561 VSSD.n1553 4.5005
R11171 VSSD.n1572 VSSD.n1561 4.5005
R11172 VSSD.n1720 VSSD.n1561 4.5005
R11173 VSSD.n1721 VSSD.n1561 4.5005
R11174 VSSD.n1836 VSSD.n1561 4.5005
R11175 VSSD.n1719 VSSD.n1557 4.5005
R11176 VSSD.n1838 VSSD.n1557 4.5005
R11177 VSSD.n1557 VSSD.n1553 4.5005
R11178 VSSD.n1572 VSSD.n1557 4.5005
R11179 VSSD.n1720 VSSD.n1557 4.5005
R11180 VSSD.n1721 VSSD.n1557 4.5005
R11181 VSSD.n1836 VSSD.n1557 4.5005
R11182 VSSD.n1719 VSSD.n1562 4.5005
R11183 VSSD.n1838 VSSD.n1562 4.5005
R11184 VSSD.n1562 VSSD.n1553 4.5005
R11185 VSSD.n1572 VSSD.n1562 4.5005
R11186 VSSD.n1720 VSSD.n1562 4.5005
R11187 VSSD.n1721 VSSD.n1562 4.5005
R11188 VSSD.n1836 VSSD.n1562 4.5005
R11189 VSSD.n1719 VSSD.n1556 4.5005
R11190 VSSD.n1838 VSSD.n1556 4.5005
R11191 VSSD.n1556 VSSD.n1553 4.5005
R11192 VSSD.n1572 VSSD.n1556 4.5005
R11193 VSSD.n1720 VSSD.n1556 4.5005
R11194 VSSD.n1721 VSSD.n1556 4.5005
R11195 VSSD.n1836 VSSD.n1556 4.5005
R11196 VSSD.n1719 VSSD.n1563 4.5005
R11197 VSSD.n1838 VSSD.n1563 4.5005
R11198 VSSD.n1563 VSSD.n1553 4.5005
R11199 VSSD.n1572 VSSD.n1563 4.5005
R11200 VSSD.n1720 VSSD.n1563 4.5005
R11201 VSSD.n1721 VSSD.n1563 4.5005
R11202 VSSD.n1836 VSSD.n1563 4.5005
R11203 VSSD.n1719 VSSD.n1555 4.5005
R11204 VSSD.n1838 VSSD.n1555 4.5005
R11205 VSSD.n1555 VSSD.n1553 4.5005
R11206 VSSD.n1572 VSSD.n1555 4.5005
R11207 VSSD.n1720 VSSD.n1555 4.5005
R11208 VSSD.n1721 VSSD.n1555 4.5005
R11209 VSSD.n1836 VSSD.n1555 4.5005
R11210 VSSD.n1719 VSSD.n1564 4.5005
R11211 VSSD.n1838 VSSD.n1564 4.5005
R11212 VSSD.n1564 VSSD.n1553 4.5005
R11213 VSSD.n1572 VSSD.n1564 4.5005
R11214 VSSD.n1720 VSSD.n1564 4.5005
R11215 VSSD.n1721 VSSD.n1564 4.5005
R11216 VSSD.n1824 VSSD.n1564 4.5005
R11217 VSSD.n1719 VSSD.n1554 4.5005
R11218 VSSD.n1838 VSSD.n1554 4.5005
R11219 VSSD.n1554 VSSD.n1553 4.5005
R11220 VSSD.n1572 VSSD.n1554 4.5005
R11221 VSSD.n1720 VSSD.n1554 4.5005
R11222 VSSD.n1570 VSSD.n1554 4.5005
R11223 VSSD.n1721 VSSD.n1554 4.5005
R11224 VSSD.n1837 VSSD.n1719 4.5005
R11225 VSSD.n1838 VSSD.n1837 4.5005
R11226 VSSD.n1837 VSSD.n1553 4.5005
R11227 VSSD.n1837 VSSD.n1572 4.5005
R11228 VSSD.n1837 VSSD.n1720 4.5005
R11229 VSSD.n1837 VSSD.n1570 4.5005
R11230 VSSD.n1837 VSSD.n1721 4.5005
R11231 VSSD.n1837 VSSD.n1836 4.5005
R11232 VSSD.n1908 VSSD.n1478 4.5005
R11233 VSSD.n1483 VSSD.n1478 4.5005
R11234 VSSD.n1484 VSSD.n1478 4.5005
R11235 VSSD.n1485 VSSD.n1478 4.5005
R11236 VSSD.n1904 VSSD.n1493 4.5005
R11237 VSSD.n1904 VSSD.n1484 4.5005
R11238 VSSD.n1904 VSSD.n1485 4.5005
R11239 VSSD.n1485 VSSD.n1479 4.5005
R11240 VSSD.n1496 VSSD.n1479 4.5005
R11241 VSSD.n1906 VSSD.n1479 4.5005
R11242 VSSD.n1908 VSSD.n1479 4.5005
R11243 VSSD.n1483 VSSD.n1476 4.5005
R11244 VSSD.n1493 VSSD.n1476 4.5005
R11245 VSSD.n1906 VSSD.n1476 4.5005
R11246 VSSD.n1908 VSSD.n1476 4.5005
R11247 VSSD.n1907 VSSD.n1485 4.5005
R11248 VSSD.n1907 VSSD.n1488 4.5005
R11249 VSSD.n1907 VSSD.n1484 4.5005
R11250 VSSD.n1907 VSSD.n1491 4.5005
R11251 VSSD.n1907 VSSD.n1483 4.5005
R11252 VSSD.n1907 VSSD.n1493 4.5005
R11253 VSSD.n1907 VSSD.n1906 4.5005
R11254 VSSD.n1907 VSSD.n1482 4.5005
R11255 VSSD.n1908 VSSD.n1907 4.5005
R11256 VSSD.n1909 VSSD.n1444 4.5005
R11257 VSSD.n1470 VSSD.n1444 4.5005
R11258 VSSD.n1444 VSSD.n1425 4.5005
R11259 VSSD.n1912 VSSD.n1444 4.5005
R11260 VSSD.n1912 VSSD.n1459 4.5005
R11261 VSSD.n1470 VSSD.n1431 4.5005
R11262 VSSD.n1431 VSSD.n1413 4.5005
R11263 VSSD.n1431 VSSD.n1411 4.5005
R11264 VSSD.n1431 VSSD.n1414 4.5005
R11265 VSSD.n1431 VSSD.n1410 4.5005
R11266 VSSD.n1431 VSSD.n1415 4.5005
R11267 VSSD.n1431 VSSD.n1409 4.5005
R11268 VSSD.n1431 VSSD.n1416 4.5005
R11269 VSSD.n1431 VSSD.n1408 4.5005
R11270 VSSD.n1431 VSSD.n1417 4.5005
R11271 VSSD.n1431 VSSD.n1407 4.5005
R11272 VSSD.n1431 VSSD.n1418 4.5005
R11273 VSSD.n1431 VSSD.n1406 4.5005
R11274 VSSD.n1431 VSSD.n1419 4.5005
R11275 VSSD.n1431 VSSD.n1405 4.5005
R11276 VSSD.n1431 VSSD.n1420 4.5005
R11277 VSSD.n1431 VSSD.n1404 4.5005
R11278 VSSD.n1431 VSSD.n1421 4.5005
R11279 VSSD.n1431 VSSD.n1403 4.5005
R11280 VSSD.n1431 VSSD.n1422 4.5005
R11281 VSSD.n1431 VSSD.n1402 4.5005
R11282 VSSD.n1431 VSSD.n1423 4.5005
R11283 VSSD.n1431 VSSD.n1401 4.5005
R11284 VSSD.n1431 VSSD.n1424 4.5005
R11285 VSSD.n1431 VSSD.n1400 4.5005
R11286 VSSD.n1431 VSSD.n1425 4.5005
R11287 VSSD.n1912 VSSD.n1431 4.5005
R11288 VSSD.n1470 VSSD.n1461 4.5005
R11289 VSSD.n1461 VSSD.n1413 4.5005
R11290 VSSD.n1461 VSSD.n1411 4.5005
R11291 VSSD.n1461 VSSD.n1414 4.5005
R11292 VSSD.n1461 VSSD.n1410 4.5005
R11293 VSSD.n1461 VSSD.n1415 4.5005
R11294 VSSD.n1461 VSSD.n1409 4.5005
R11295 VSSD.n1461 VSSD.n1416 4.5005
R11296 VSSD.n1461 VSSD.n1408 4.5005
R11297 VSSD.n1461 VSSD.n1417 4.5005
R11298 VSSD.n1461 VSSD.n1407 4.5005
R11299 VSSD.n1461 VSSD.n1418 4.5005
R11300 VSSD.n1461 VSSD.n1406 4.5005
R11301 VSSD.n1461 VSSD.n1419 4.5005
R11302 VSSD.n1461 VSSD.n1405 4.5005
R11303 VSSD.n1461 VSSD.n1420 4.5005
R11304 VSSD.n1461 VSSD.n1404 4.5005
R11305 VSSD.n1461 VSSD.n1421 4.5005
R11306 VSSD.n1461 VSSD.n1403 4.5005
R11307 VSSD.n1461 VSSD.n1422 4.5005
R11308 VSSD.n1461 VSSD.n1402 4.5005
R11309 VSSD.n1461 VSSD.n1423 4.5005
R11310 VSSD.n1461 VSSD.n1401 4.5005
R11311 VSSD.n1461 VSSD.n1424 4.5005
R11312 VSSD.n1461 VSSD.n1400 4.5005
R11313 VSSD.n1461 VSSD.n1425 4.5005
R11314 VSSD.n1912 VSSD.n1461 4.5005
R11315 VSSD.n1470 VSSD.n1430 4.5005
R11316 VSSD.n1430 VSSD.n1413 4.5005
R11317 VSSD.n1430 VSSD.n1411 4.5005
R11318 VSSD.n1430 VSSD.n1414 4.5005
R11319 VSSD.n1430 VSSD.n1410 4.5005
R11320 VSSD.n1430 VSSD.n1415 4.5005
R11321 VSSD.n1430 VSSD.n1409 4.5005
R11322 VSSD.n1430 VSSD.n1416 4.5005
R11323 VSSD.n1430 VSSD.n1408 4.5005
R11324 VSSD.n1430 VSSD.n1417 4.5005
R11325 VSSD.n1430 VSSD.n1407 4.5005
R11326 VSSD.n1430 VSSD.n1418 4.5005
R11327 VSSD.n1430 VSSD.n1406 4.5005
R11328 VSSD.n1430 VSSD.n1419 4.5005
R11329 VSSD.n1430 VSSD.n1405 4.5005
R11330 VSSD.n1430 VSSD.n1420 4.5005
R11331 VSSD.n1430 VSSD.n1404 4.5005
R11332 VSSD.n1430 VSSD.n1421 4.5005
R11333 VSSD.n1430 VSSD.n1403 4.5005
R11334 VSSD.n1430 VSSD.n1422 4.5005
R11335 VSSD.n1430 VSSD.n1402 4.5005
R11336 VSSD.n1430 VSSD.n1423 4.5005
R11337 VSSD.n1430 VSSD.n1401 4.5005
R11338 VSSD.n1430 VSSD.n1424 4.5005
R11339 VSSD.n1430 VSSD.n1400 4.5005
R11340 VSSD.n1430 VSSD.n1425 4.5005
R11341 VSSD.n1912 VSSD.n1430 4.5005
R11342 VSSD.n1470 VSSD.n1463 4.5005
R11343 VSSD.n1463 VSSD.n1413 4.5005
R11344 VSSD.n1463 VSSD.n1411 4.5005
R11345 VSSD.n1463 VSSD.n1414 4.5005
R11346 VSSD.n1463 VSSD.n1410 4.5005
R11347 VSSD.n1463 VSSD.n1415 4.5005
R11348 VSSD.n1463 VSSD.n1409 4.5005
R11349 VSSD.n1463 VSSD.n1416 4.5005
R11350 VSSD.n1463 VSSD.n1408 4.5005
R11351 VSSD.n1463 VSSD.n1417 4.5005
R11352 VSSD.n1463 VSSD.n1407 4.5005
R11353 VSSD.n1463 VSSD.n1418 4.5005
R11354 VSSD.n1463 VSSD.n1406 4.5005
R11355 VSSD.n1463 VSSD.n1419 4.5005
R11356 VSSD.n1463 VSSD.n1405 4.5005
R11357 VSSD.n1463 VSSD.n1420 4.5005
R11358 VSSD.n1463 VSSD.n1404 4.5005
R11359 VSSD.n1463 VSSD.n1421 4.5005
R11360 VSSD.n1463 VSSD.n1403 4.5005
R11361 VSSD.n1463 VSSD.n1422 4.5005
R11362 VSSD.n1463 VSSD.n1402 4.5005
R11363 VSSD.n1463 VSSD.n1423 4.5005
R11364 VSSD.n1463 VSSD.n1401 4.5005
R11365 VSSD.n1463 VSSD.n1424 4.5005
R11366 VSSD.n1463 VSSD.n1400 4.5005
R11367 VSSD.n1463 VSSD.n1425 4.5005
R11368 VSSD.n1912 VSSD.n1463 4.5005
R11369 VSSD.n1470 VSSD.n1429 4.5005
R11370 VSSD.n1429 VSSD.n1413 4.5005
R11371 VSSD.n1429 VSSD.n1411 4.5005
R11372 VSSD.n1429 VSSD.n1414 4.5005
R11373 VSSD.n1429 VSSD.n1410 4.5005
R11374 VSSD.n1429 VSSD.n1415 4.5005
R11375 VSSD.n1429 VSSD.n1409 4.5005
R11376 VSSD.n1429 VSSD.n1416 4.5005
R11377 VSSD.n1429 VSSD.n1408 4.5005
R11378 VSSD.n1429 VSSD.n1417 4.5005
R11379 VSSD.n1429 VSSD.n1407 4.5005
R11380 VSSD.n1429 VSSD.n1418 4.5005
R11381 VSSD.n1429 VSSD.n1406 4.5005
R11382 VSSD.n1429 VSSD.n1419 4.5005
R11383 VSSD.n1429 VSSD.n1405 4.5005
R11384 VSSD.n1429 VSSD.n1420 4.5005
R11385 VSSD.n1429 VSSD.n1404 4.5005
R11386 VSSD.n1429 VSSD.n1421 4.5005
R11387 VSSD.n1429 VSSD.n1403 4.5005
R11388 VSSD.n1429 VSSD.n1422 4.5005
R11389 VSSD.n1429 VSSD.n1402 4.5005
R11390 VSSD.n1429 VSSD.n1423 4.5005
R11391 VSSD.n1429 VSSD.n1401 4.5005
R11392 VSSD.n1429 VSSD.n1424 4.5005
R11393 VSSD.n1429 VSSD.n1400 4.5005
R11394 VSSD.n1429 VSSD.n1425 4.5005
R11395 VSSD.n1912 VSSD.n1429 4.5005
R11396 VSSD.n1470 VSSD.n1465 4.5005
R11397 VSSD.n1465 VSSD.n1413 4.5005
R11398 VSSD.n1465 VSSD.n1411 4.5005
R11399 VSSD.n1465 VSSD.n1414 4.5005
R11400 VSSD.n1465 VSSD.n1410 4.5005
R11401 VSSD.n1465 VSSD.n1415 4.5005
R11402 VSSD.n1465 VSSD.n1409 4.5005
R11403 VSSD.n1465 VSSD.n1416 4.5005
R11404 VSSD.n1465 VSSD.n1408 4.5005
R11405 VSSD.n1465 VSSD.n1417 4.5005
R11406 VSSD.n1465 VSSD.n1407 4.5005
R11407 VSSD.n1465 VSSD.n1418 4.5005
R11408 VSSD.n1465 VSSD.n1406 4.5005
R11409 VSSD.n1465 VSSD.n1419 4.5005
R11410 VSSD.n1465 VSSD.n1405 4.5005
R11411 VSSD.n1465 VSSD.n1420 4.5005
R11412 VSSD.n1465 VSSD.n1404 4.5005
R11413 VSSD.n1465 VSSD.n1421 4.5005
R11414 VSSD.n1465 VSSD.n1403 4.5005
R11415 VSSD.n1465 VSSD.n1422 4.5005
R11416 VSSD.n1465 VSSD.n1402 4.5005
R11417 VSSD.n1465 VSSD.n1423 4.5005
R11418 VSSD.n1465 VSSD.n1401 4.5005
R11419 VSSD.n1465 VSSD.n1424 4.5005
R11420 VSSD.n1465 VSSD.n1400 4.5005
R11421 VSSD.n1465 VSSD.n1425 4.5005
R11422 VSSD.n1912 VSSD.n1465 4.5005
R11423 VSSD.n1470 VSSD.n1428 4.5005
R11424 VSSD.n1428 VSSD.n1413 4.5005
R11425 VSSD.n1428 VSSD.n1411 4.5005
R11426 VSSD.n1428 VSSD.n1414 4.5005
R11427 VSSD.n1428 VSSD.n1410 4.5005
R11428 VSSD.n1428 VSSD.n1415 4.5005
R11429 VSSD.n1428 VSSD.n1409 4.5005
R11430 VSSD.n1428 VSSD.n1416 4.5005
R11431 VSSD.n1428 VSSD.n1408 4.5005
R11432 VSSD.n1428 VSSD.n1417 4.5005
R11433 VSSD.n1428 VSSD.n1407 4.5005
R11434 VSSD.n1428 VSSD.n1418 4.5005
R11435 VSSD.n1428 VSSD.n1406 4.5005
R11436 VSSD.n1428 VSSD.n1419 4.5005
R11437 VSSD.n1428 VSSD.n1405 4.5005
R11438 VSSD.n1428 VSSD.n1420 4.5005
R11439 VSSD.n1428 VSSD.n1404 4.5005
R11440 VSSD.n1428 VSSD.n1421 4.5005
R11441 VSSD.n1428 VSSD.n1403 4.5005
R11442 VSSD.n1428 VSSD.n1422 4.5005
R11443 VSSD.n1428 VSSD.n1402 4.5005
R11444 VSSD.n1428 VSSD.n1423 4.5005
R11445 VSSD.n1428 VSSD.n1401 4.5005
R11446 VSSD.n1428 VSSD.n1424 4.5005
R11447 VSSD.n1428 VSSD.n1400 4.5005
R11448 VSSD.n1428 VSSD.n1425 4.5005
R11449 VSSD.n1912 VSSD.n1428 4.5005
R11450 VSSD.n1470 VSSD.n1467 4.5005
R11451 VSSD.n1467 VSSD.n1413 4.5005
R11452 VSSD.n1467 VSSD.n1411 4.5005
R11453 VSSD.n1467 VSSD.n1414 4.5005
R11454 VSSD.n1467 VSSD.n1410 4.5005
R11455 VSSD.n1467 VSSD.n1415 4.5005
R11456 VSSD.n1467 VSSD.n1409 4.5005
R11457 VSSD.n1467 VSSD.n1416 4.5005
R11458 VSSD.n1467 VSSD.n1408 4.5005
R11459 VSSD.n1467 VSSD.n1417 4.5005
R11460 VSSD.n1467 VSSD.n1407 4.5005
R11461 VSSD.n1467 VSSD.n1418 4.5005
R11462 VSSD.n1467 VSSD.n1406 4.5005
R11463 VSSD.n1467 VSSD.n1419 4.5005
R11464 VSSD.n1467 VSSD.n1405 4.5005
R11465 VSSD.n1467 VSSD.n1420 4.5005
R11466 VSSD.n1467 VSSD.n1404 4.5005
R11467 VSSD.n1467 VSSD.n1421 4.5005
R11468 VSSD.n1467 VSSD.n1403 4.5005
R11469 VSSD.n1467 VSSD.n1422 4.5005
R11470 VSSD.n1467 VSSD.n1402 4.5005
R11471 VSSD.n1467 VSSD.n1423 4.5005
R11472 VSSD.n1467 VSSD.n1401 4.5005
R11473 VSSD.n1467 VSSD.n1424 4.5005
R11474 VSSD.n1467 VSSD.n1400 4.5005
R11475 VSSD.n1467 VSSD.n1425 4.5005
R11476 VSSD.n1912 VSSD.n1467 4.5005
R11477 VSSD.n1470 VSSD.n1427 4.5005
R11478 VSSD.n1427 VSSD.n1413 4.5005
R11479 VSSD.n1427 VSSD.n1411 4.5005
R11480 VSSD.n1427 VSSD.n1414 4.5005
R11481 VSSD.n1427 VSSD.n1410 4.5005
R11482 VSSD.n1427 VSSD.n1415 4.5005
R11483 VSSD.n1427 VSSD.n1409 4.5005
R11484 VSSD.n1427 VSSD.n1416 4.5005
R11485 VSSD.n1427 VSSD.n1408 4.5005
R11486 VSSD.n1427 VSSD.n1417 4.5005
R11487 VSSD.n1427 VSSD.n1407 4.5005
R11488 VSSD.n1427 VSSD.n1418 4.5005
R11489 VSSD.n1427 VSSD.n1406 4.5005
R11490 VSSD.n1427 VSSD.n1419 4.5005
R11491 VSSD.n1427 VSSD.n1405 4.5005
R11492 VSSD.n1427 VSSD.n1420 4.5005
R11493 VSSD.n1427 VSSD.n1404 4.5005
R11494 VSSD.n1427 VSSD.n1421 4.5005
R11495 VSSD.n1427 VSSD.n1403 4.5005
R11496 VSSD.n1427 VSSD.n1422 4.5005
R11497 VSSD.n1427 VSSD.n1402 4.5005
R11498 VSSD.n1427 VSSD.n1423 4.5005
R11499 VSSD.n1427 VSSD.n1401 4.5005
R11500 VSSD.n1427 VSSD.n1424 4.5005
R11501 VSSD.n1427 VSSD.n1400 4.5005
R11502 VSSD.n1427 VSSD.n1425 4.5005
R11503 VSSD.n1912 VSSD.n1427 4.5005
R11504 VSSD.n1911 VSSD.n1470 4.5005
R11505 VSSD.n1911 VSSD.n1413 4.5005
R11506 VSSD.n1911 VSSD.n1411 4.5005
R11507 VSSD.n1911 VSSD.n1414 4.5005
R11508 VSSD.n1911 VSSD.n1410 4.5005
R11509 VSSD.n1911 VSSD.n1415 4.5005
R11510 VSSD.n1911 VSSD.n1409 4.5005
R11511 VSSD.n1911 VSSD.n1416 4.5005
R11512 VSSD.n1911 VSSD.n1408 4.5005
R11513 VSSD.n1911 VSSD.n1417 4.5005
R11514 VSSD.n1911 VSSD.n1407 4.5005
R11515 VSSD.n1911 VSSD.n1418 4.5005
R11516 VSSD.n1911 VSSD.n1406 4.5005
R11517 VSSD.n1911 VSSD.n1419 4.5005
R11518 VSSD.n1911 VSSD.n1405 4.5005
R11519 VSSD.n1911 VSSD.n1420 4.5005
R11520 VSSD.n1911 VSSD.n1404 4.5005
R11521 VSSD.n1911 VSSD.n1421 4.5005
R11522 VSSD.n1911 VSSD.n1403 4.5005
R11523 VSSD.n1911 VSSD.n1422 4.5005
R11524 VSSD.n1911 VSSD.n1402 4.5005
R11525 VSSD.n1911 VSSD.n1423 4.5005
R11526 VSSD.n1911 VSSD.n1401 4.5005
R11527 VSSD.n1911 VSSD.n1424 4.5005
R11528 VSSD.n1911 VSSD.n1400 4.5005
R11529 VSSD.n1911 VSSD.n1425 4.5005
R11530 VSSD.n1912 VSSD.n1911 4.5005
R11531 VSSD.n1470 VSSD.n1426 4.5005
R11532 VSSD.n1426 VSSD.n1413 4.5005
R11533 VSSD.n1426 VSSD.n1411 4.5005
R11534 VSSD.n1426 VSSD.n1414 4.5005
R11535 VSSD.n1426 VSSD.n1410 4.5005
R11536 VSSD.n1426 VSSD.n1415 4.5005
R11537 VSSD.n1426 VSSD.n1409 4.5005
R11538 VSSD.n1426 VSSD.n1416 4.5005
R11539 VSSD.n1426 VSSD.n1408 4.5005
R11540 VSSD.n1426 VSSD.n1417 4.5005
R11541 VSSD.n1426 VSSD.n1407 4.5005
R11542 VSSD.n1426 VSSD.n1418 4.5005
R11543 VSSD.n1426 VSSD.n1406 4.5005
R11544 VSSD.n1426 VSSD.n1419 4.5005
R11545 VSSD.n1426 VSSD.n1405 4.5005
R11546 VSSD.n1426 VSSD.n1420 4.5005
R11547 VSSD.n1426 VSSD.n1404 4.5005
R11548 VSSD.n1426 VSSD.n1421 4.5005
R11549 VSSD.n1426 VSSD.n1403 4.5005
R11550 VSSD.n1426 VSSD.n1422 4.5005
R11551 VSSD.n1426 VSSD.n1402 4.5005
R11552 VSSD.n1426 VSSD.n1423 4.5005
R11553 VSSD.n1426 VSSD.n1401 4.5005
R11554 VSSD.n1426 VSSD.n1424 4.5005
R11555 VSSD.n1426 VSSD.n1400 4.5005
R11556 VSSD.n1426 VSSD.n1425 4.5005
R11557 VSSD.n1912 VSSD.n1426 4.5005
R11558 VSSD.n1913 VSSD.n1413 4.5005
R11559 VSSD.n1913 VSSD.n1411 4.5005
R11560 VSSD.n1913 VSSD.n1414 4.5005
R11561 VSSD.n1913 VSSD.n1410 4.5005
R11562 VSSD.n1913 VSSD.n1415 4.5005
R11563 VSSD.n1913 VSSD.n1409 4.5005
R11564 VSSD.n1913 VSSD.n1416 4.5005
R11565 VSSD.n1913 VSSD.n1408 4.5005
R11566 VSSD.n1913 VSSD.n1417 4.5005
R11567 VSSD.n1913 VSSD.n1407 4.5005
R11568 VSSD.n1913 VSSD.n1418 4.5005
R11569 VSSD.n1913 VSSD.n1406 4.5005
R11570 VSSD.n1913 VSSD.n1419 4.5005
R11571 VSSD.n1913 VSSD.n1405 4.5005
R11572 VSSD.n1913 VSSD.n1420 4.5005
R11573 VSSD.n1913 VSSD.n1404 4.5005
R11574 VSSD.n1913 VSSD.n1421 4.5005
R11575 VSSD.n1913 VSSD.n1403 4.5005
R11576 VSSD.n1913 VSSD.n1422 4.5005
R11577 VSSD.n1913 VSSD.n1402 4.5005
R11578 VSSD.n1913 VSSD.n1423 4.5005
R11579 VSSD.n1913 VSSD.n1401 4.5005
R11580 VSSD.n1913 VSSD.n1424 4.5005
R11581 VSSD.n1913 VSSD.n1400 4.5005
R11582 VSSD.n1913 VSSD.n1425 4.5005
R11583 VSSD.n1913 VSSD.n1912 4.5005
R11584 VSSD.n1929 VSSD.n1358 4.5005
R11585 VSSD.n1929 VSSD.n1928 4.5005
R11586 VSSD.n1930 VSSD.n1929 4.5005
R11587 VSSD.n1372 VSSD.n1359 4.5005
R11588 VSSD.n1372 VSSD.n1357 4.5005
R11589 VSSD.n1372 VSSD.n1360 4.5005
R11590 VSSD.n1372 VSSD.n1356 4.5005
R11591 VSSD.n1372 VSSD.n1361 4.5005
R11592 VSSD.n1372 VSSD.n1355 4.5005
R11593 VSSD.n1372 VSSD.n1362 4.5005
R11594 VSSD.n1372 VSSD.n1354 4.5005
R11595 VSSD.n1372 VSSD.n1363 4.5005
R11596 VSSD.n1372 VSSD.n1353 4.5005
R11597 VSSD.n1372 VSSD.n1364 4.5005
R11598 VSSD.n1372 VSSD.n1352 4.5005
R11599 VSSD.n1372 VSSD.n1365 4.5005
R11600 VSSD.n1372 VSSD.n1351 4.5005
R11601 VSSD.n1372 VSSD.n1366 4.5005
R11602 VSSD.n1372 VSSD.n1350 4.5005
R11603 VSSD.n1372 VSSD.n1367 4.5005
R11604 VSSD.n1372 VSSD.n1349 4.5005
R11605 VSSD.n1372 VSSD.n1368 4.5005
R11606 VSSD.n1372 VSSD.n1348 4.5005
R11607 VSSD.n1372 VSSD.n1369 4.5005
R11608 VSSD.n1372 VSSD.n1347 4.5005
R11609 VSSD.n1372 VSSD.n1370 4.5005
R11610 VSSD.n1928 VSSD.n1372 4.5005
R11611 VSSD.n1930 VSSD.n1372 4.5005
R11612 VSSD.n1932 VSSD.n1341 4.5005
R11613 VSSD.n1358 VSSD.n1341 4.5005
R11614 VSSD.n1359 VSSD.n1341 4.5005
R11615 VSSD.n1357 VSSD.n1341 4.5005
R11616 VSSD.n1360 VSSD.n1341 4.5005
R11617 VSSD.n1356 VSSD.n1341 4.5005
R11618 VSSD.n1361 VSSD.n1341 4.5005
R11619 VSSD.n1355 VSSD.n1341 4.5005
R11620 VSSD.n1362 VSSD.n1341 4.5005
R11621 VSSD.n1354 VSSD.n1341 4.5005
R11622 VSSD.n1363 VSSD.n1341 4.5005
R11623 VSSD.n1353 VSSD.n1341 4.5005
R11624 VSSD.n1364 VSSD.n1341 4.5005
R11625 VSSD.n1352 VSSD.n1341 4.5005
R11626 VSSD.n1365 VSSD.n1341 4.5005
R11627 VSSD.n1351 VSSD.n1341 4.5005
R11628 VSSD.n1366 VSSD.n1341 4.5005
R11629 VSSD.n1350 VSSD.n1341 4.5005
R11630 VSSD.n1367 VSSD.n1341 4.5005
R11631 VSSD.n1349 VSSD.n1341 4.5005
R11632 VSSD.n1368 VSSD.n1341 4.5005
R11633 VSSD.n1348 VSSD.n1341 4.5005
R11634 VSSD.n1369 VSSD.n1341 4.5005
R11635 VSSD.n1347 VSSD.n1341 4.5005
R11636 VSSD.n1370 VSSD.n1341 4.5005
R11637 VSSD.n1928 VSSD.n1341 4.5005
R11638 VSSD.n1930 VSSD.n1341 4.5005
R11639 VSSD.n1932 VSSD.n1338 4.5005
R11640 VSSD.n1358 VSSD.n1338 4.5005
R11641 VSSD.n1359 VSSD.n1338 4.5005
R11642 VSSD.n1357 VSSD.n1338 4.5005
R11643 VSSD.n1360 VSSD.n1338 4.5005
R11644 VSSD.n1356 VSSD.n1338 4.5005
R11645 VSSD.n1361 VSSD.n1338 4.5005
R11646 VSSD.n1355 VSSD.n1338 4.5005
R11647 VSSD.n1362 VSSD.n1338 4.5005
R11648 VSSD.n1354 VSSD.n1338 4.5005
R11649 VSSD.n1363 VSSD.n1338 4.5005
R11650 VSSD.n1353 VSSD.n1338 4.5005
R11651 VSSD.n1364 VSSD.n1338 4.5005
R11652 VSSD.n1352 VSSD.n1338 4.5005
R11653 VSSD.n1365 VSSD.n1338 4.5005
R11654 VSSD.n1351 VSSD.n1338 4.5005
R11655 VSSD.n1366 VSSD.n1338 4.5005
R11656 VSSD.n1350 VSSD.n1338 4.5005
R11657 VSSD.n1367 VSSD.n1338 4.5005
R11658 VSSD.n1349 VSSD.n1338 4.5005
R11659 VSSD.n1368 VSSD.n1338 4.5005
R11660 VSSD.n1348 VSSD.n1338 4.5005
R11661 VSSD.n1369 VSSD.n1338 4.5005
R11662 VSSD.n1347 VSSD.n1338 4.5005
R11663 VSSD.n1370 VSSD.n1338 4.5005
R11664 VSSD.n1928 VSSD.n1338 4.5005
R11665 VSSD.n1930 VSSD.n1338 4.5005
R11666 VSSD.n1932 VSSD.n1342 4.5005
R11667 VSSD.n1358 VSSD.n1342 4.5005
R11668 VSSD.n1359 VSSD.n1342 4.5005
R11669 VSSD.n1357 VSSD.n1342 4.5005
R11670 VSSD.n1360 VSSD.n1342 4.5005
R11671 VSSD.n1356 VSSD.n1342 4.5005
R11672 VSSD.n1361 VSSD.n1342 4.5005
R11673 VSSD.n1355 VSSD.n1342 4.5005
R11674 VSSD.n1362 VSSD.n1342 4.5005
R11675 VSSD.n1354 VSSD.n1342 4.5005
R11676 VSSD.n1363 VSSD.n1342 4.5005
R11677 VSSD.n1353 VSSD.n1342 4.5005
R11678 VSSD.n1364 VSSD.n1342 4.5005
R11679 VSSD.n1352 VSSD.n1342 4.5005
R11680 VSSD.n1365 VSSD.n1342 4.5005
R11681 VSSD.n1351 VSSD.n1342 4.5005
R11682 VSSD.n1366 VSSD.n1342 4.5005
R11683 VSSD.n1350 VSSD.n1342 4.5005
R11684 VSSD.n1367 VSSD.n1342 4.5005
R11685 VSSD.n1349 VSSD.n1342 4.5005
R11686 VSSD.n1368 VSSD.n1342 4.5005
R11687 VSSD.n1348 VSSD.n1342 4.5005
R11688 VSSD.n1369 VSSD.n1342 4.5005
R11689 VSSD.n1347 VSSD.n1342 4.5005
R11690 VSSD.n1370 VSSD.n1342 4.5005
R11691 VSSD.n1928 VSSD.n1342 4.5005
R11692 VSSD.n1930 VSSD.n1342 4.5005
R11693 VSSD.n1932 VSSD.n1337 4.5005
R11694 VSSD.n1358 VSSD.n1337 4.5005
R11695 VSSD.n1359 VSSD.n1337 4.5005
R11696 VSSD.n1357 VSSD.n1337 4.5005
R11697 VSSD.n1360 VSSD.n1337 4.5005
R11698 VSSD.n1356 VSSD.n1337 4.5005
R11699 VSSD.n1361 VSSD.n1337 4.5005
R11700 VSSD.n1355 VSSD.n1337 4.5005
R11701 VSSD.n1362 VSSD.n1337 4.5005
R11702 VSSD.n1354 VSSD.n1337 4.5005
R11703 VSSD.n1363 VSSD.n1337 4.5005
R11704 VSSD.n1353 VSSD.n1337 4.5005
R11705 VSSD.n1364 VSSD.n1337 4.5005
R11706 VSSD.n1352 VSSD.n1337 4.5005
R11707 VSSD.n1365 VSSD.n1337 4.5005
R11708 VSSD.n1351 VSSD.n1337 4.5005
R11709 VSSD.n1366 VSSD.n1337 4.5005
R11710 VSSD.n1350 VSSD.n1337 4.5005
R11711 VSSD.n1367 VSSD.n1337 4.5005
R11712 VSSD.n1349 VSSD.n1337 4.5005
R11713 VSSD.n1368 VSSD.n1337 4.5005
R11714 VSSD.n1348 VSSD.n1337 4.5005
R11715 VSSD.n1369 VSSD.n1337 4.5005
R11716 VSSD.n1347 VSSD.n1337 4.5005
R11717 VSSD.n1370 VSSD.n1337 4.5005
R11718 VSSD.n1928 VSSD.n1337 4.5005
R11719 VSSD.n1930 VSSD.n1337 4.5005
R11720 VSSD.n1932 VSSD.n1343 4.5005
R11721 VSSD.n1358 VSSD.n1343 4.5005
R11722 VSSD.n1359 VSSD.n1343 4.5005
R11723 VSSD.n1357 VSSD.n1343 4.5005
R11724 VSSD.n1360 VSSD.n1343 4.5005
R11725 VSSD.n1356 VSSD.n1343 4.5005
R11726 VSSD.n1361 VSSD.n1343 4.5005
R11727 VSSD.n1355 VSSD.n1343 4.5005
R11728 VSSD.n1362 VSSD.n1343 4.5005
R11729 VSSD.n1354 VSSD.n1343 4.5005
R11730 VSSD.n1363 VSSD.n1343 4.5005
R11731 VSSD.n1353 VSSD.n1343 4.5005
R11732 VSSD.n1364 VSSD.n1343 4.5005
R11733 VSSD.n1352 VSSD.n1343 4.5005
R11734 VSSD.n1365 VSSD.n1343 4.5005
R11735 VSSD.n1351 VSSD.n1343 4.5005
R11736 VSSD.n1366 VSSD.n1343 4.5005
R11737 VSSD.n1350 VSSD.n1343 4.5005
R11738 VSSD.n1367 VSSD.n1343 4.5005
R11739 VSSD.n1349 VSSD.n1343 4.5005
R11740 VSSD.n1368 VSSD.n1343 4.5005
R11741 VSSD.n1348 VSSD.n1343 4.5005
R11742 VSSD.n1369 VSSD.n1343 4.5005
R11743 VSSD.n1347 VSSD.n1343 4.5005
R11744 VSSD.n1370 VSSD.n1343 4.5005
R11745 VSSD.n1928 VSSD.n1343 4.5005
R11746 VSSD.n1930 VSSD.n1343 4.5005
R11747 VSSD.n1932 VSSD.n1336 4.5005
R11748 VSSD.n1358 VSSD.n1336 4.5005
R11749 VSSD.n1359 VSSD.n1336 4.5005
R11750 VSSD.n1357 VSSD.n1336 4.5005
R11751 VSSD.n1360 VSSD.n1336 4.5005
R11752 VSSD.n1356 VSSD.n1336 4.5005
R11753 VSSD.n1361 VSSD.n1336 4.5005
R11754 VSSD.n1355 VSSD.n1336 4.5005
R11755 VSSD.n1362 VSSD.n1336 4.5005
R11756 VSSD.n1354 VSSD.n1336 4.5005
R11757 VSSD.n1363 VSSD.n1336 4.5005
R11758 VSSD.n1353 VSSD.n1336 4.5005
R11759 VSSD.n1364 VSSD.n1336 4.5005
R11760 VSSD.n1352 VSSD.n1336 4.5005
R11761 VSSD.n1365 VSSD.n1336 4.5005
R11762 VSSD.n1351 VSSD.n1336 4.5005
R11763 VSSD.n1366 VSSD.n1336 4.5005
R11764 VSSD.n1350 VSSD.n1336 4.5005
R11765 VSSD.n1367 VSSD.n1336 4.5005
R11766 VSSD.n1349 VSSD.n1336 4.5005
R11767 VSSD.n1368 VSSD.n1336 4.5005
R11768 VSSD.n1348 VSSD.n1336 4.5005
R11769 VSSD.n1369 VSSD.n1336 4.5005
R11770 VSSD.n1347 VSSD.n1336 4.5005
R11771 VSSD.n1370 VSSD.n1336 4.5005
R11772 VSSD.n1928 VSSD.n1336 4.5005
R11773 VSSD.n1930 VSSD.n1336 4.5005
R11774 VSSD.n1932 VSSD.n1344 4.5005
R11775 VSSD.n1358 VSSD.n1344 4.5005
R11776 VSSD.n1359 VSSD.n1344 4.5005
R11777 VSSD.n1357 VSSD.n1344 4.5005
R11778 VSSD.n1360 VSSD.n1344 4.5005
R11779 VSSD.n1356 VSSD.n1344 4.5005
R11780 VSSD.n1361 VSSD.n1344 4.5005
R11781 VSSD.n1355 VSSD.n1344 4.5005
R11782 VSSD.n1362 VSSD.n1344 4.5005
R11783 VSSD.n1354 VSSD.n1344 4.5005
R11784 VSSD.n1363 VSSD.n1344 4.5005
R11785 VSSD.n1353 VSSD.n1344 4.5005
R11786 VSSD.n1364 VSSD.n1344 4.5005
R11787 VSSD.n1352 VSSD.n1344 4.5005
R11788 VSSD.n1365 VSSD.n1344 4.5005
R11789 VSSD.n1351 VSSD.n1344 4.5005
R11790 VSSD.n1366 VSSD.n1344 4.5005
R11791 VSSD.n1350 VSSD.n1344 4.5005
R11792 VSSD.n1367 VSSD.n1344 4.5005
R11793 VSSD.n1349 VSSD.n1344 4.5005
R11794 VSSD.n1368 VSSD.n1344 4.5005
R11795 VSSD.n1348 VSSD.n1344 4.5005
R11796 VSSD.n1369 VSSD.n1344 4.5005
R11797 VSSD.n1347 VSSD.n1344 4.5005
R11798 VSSD.n1370 VSSD.n1344 4.5005
R11799 VSSD.n1928 VSSD.n1344 4.5005
R11800 VSSD.n1930 VSSD.n1344 4.5005
R11801 VSSD.n1932 VSSD.n1335 4.5005
R11802 VSSD.n1358 VSSD.n1335 4.5005
R11803 VSSD.n1359 VSSD.n1335 4.5005
R11804 VSSD.n1357 VSSD.n1335 4.5005
R11805 VSSD.n1360 VSSD.n1335 4.5005
R11806 VSSD.n1356 VSSD.n1335 4.5005
R11807 VSSD.n1361 VSSD.n1335 4.5005
R11808 VSSD.n1355 VSSD.n1335 4.5005
R11809 VSSD.n1362 VSSD.n1335 4.5005
R11810 VSSD.n1354 VSSD.n1335 4.5005
R11811 VSSD.n1363 VSSD.n1335 4.5005
R11812 VSSD.n1353 VSSD.n1335 4.5005
R11813 VSSD.n1364 VSSD.n1335 4.5005
R11814 VSSD.n1352 VSSD.n1335 4.5005
R11815 VSSD.n1365 VSSD.n1335 4.5005
R11816 VSSD.n1351 VSSD.n1335 4.5005
R11817 VSSD.n1366 VSSD.n1335 4.5005
R11818 VSSD.n1350 VSSD.n1335 4.5005
R11819 VSSD.n1367 VSSD.n1335 4.5005
R11820 VSSD.n1349 VSSD.n1335 4.5005
R11821 VSSD.n1368 VSSD.n1335 4.5005
R11822 VSSD.n1348 VSSD.n1335 4.5005
R11823 VSSD.n1369 VSSD.n1335 4.5005
R11824 VSSD.n1347 VSSD.n1335 4.5005
R11825 VSSD.n1370 VSSD.n1335 4.5005
R11826 VSSD.n1928 VSSD.n1335 4.5005
R11827 VSSD.n1930 VSSD.n1335 4.5005
R11828 VSSD.n1932 VSSD.n1345 4.5005
R11829 VSSD.n1358 VSSD.n1345 4.5005
R11830 VSSD.n1359 VSSD.n1345 4.5005
R11831 VSSD.n1357 VSSD.n1345 4.5005
R11832 VSSD.n1360 VSSD.n1345 4.5005
R11833 VSSD.n1356 VSSD.n1345 4.5005
R11834 VSSD.n1361 VSSD.n1345 4.5005
R11835 VSSD.n1355 VSSD.n1345 4.5005
R11836 VSSD.n1362 VSSD.n1345 4.5005
R11837 VSSD.n1354 VSSD.n1345 4.5005
R11838 VSSD.n1363 VSSD.n1345 4.5005
R11839 VSSD.n1353 VSSD.n1345 4.5005
R11840 VSSD.n1364 VSSD.n1345 4.5005
R11841 VSSD.n1352 VSSD.n1345 4.5005
R11842 VSSD.n1365 VSSD.n1345 4.5005
R11843 VSSD.n1351 VSSD.n1345 4.5005
R11844 VSSD.n1366 VSSD.n1345 4.5005
R11845 VSSD.n1350 VSSD.n1345 4.5005
R11846 VSSD.n1367 VSSD.n1345 4.5005
R11847 VSSD.n1349 VSSD.n1345 4.5005
R11848 VSSD.n1368 VSSD.n1345 4.5005
R11849 VSSD.n1348 VSSD.n1345 4.5005
R11850 VSSD.n1369 VSSD.n1345 4.5005
R11851 VSSD.n1347 VSSD.n1345 4.5005
R11852 VSSD.n1370 VSSD.n1345 4.5005
R11853 VSSD.n1928 VSSD.n1345 4.5005
R11854 VSSD.n1930 VSSD.n1345 4.5005
R11855 VSSD.n1932 VSSD.n1334 4.5005
R11856 VSSD.n1358 VSSD.n1334 4.5005
R11857 VSSD.n1359 VSSD.n1334 4.5005
R11858 VSSD.n1357 VSSD.n1334 4.5005
R11859 VSSD.n1360 VSSD.n1334 4.5005
R11860 VSSD.n1356 VSSD.n1334 4.5005
R11861 VSSD.n1361 VSSD.n1334 4.5005
R11862 VSSD.n1355 VSSD.n1334 4.5005
R11863 VSSD.n1362 VSSD.n1334 4.5005
R11864 VSSD.n1354 VSSD.n1334 4.5005
R11865 VSSD.n1363 VSSD.n1334 4.5005
R11866 VSSD.n1353 VSSD.n1334 4.5005
R11867 VSSD.n1364 VSSD.n1334 4.5005
R11868 VSSD.n1352 VSSD.n1334 4.5005
R11869 VSSD.n1365 VSSD.n1334 4.5005
R11870 VSSD.n1351 VSSD.n1334 4.5005
R11871 VSSD.n1366 VSSD.n1334 4.5005
R11872 VSSD.n1350 VSSD.n1334 4.5005
R11873 VSSD.n1367 VSSD.n1334 4.5005
R11874 VSSD.n1349 VSSD.n1334 4.5005
R11875 VSSD.n1368 VSSD.n1334 4.5005
R11876 VSSD.n1348 VSSD.n1334 4.5005
R11877 VSSD.n1369 VSSD.n1334 4.5005
R11878 VSSD.n1347 VSSD.n1334 4.5005
R11879 VSSD.n1370 VSSD.n1334 4.5005
R11880 VSSD.n1928 VSSD.n1334 4.5005
R11881 VSSD.n1930 VSSD.n1334 4.5005
R11882 VSSD.n1932 VSSD.n1931 4.5005
R11883 VSSD.n1931 VSSD.n1358 4.5005
R11884 VSSD.n1931 VSSD.n1359 4.5005
R11885 VSSD.n1931 VSSD.n1357 4.5005
R11886 VSSD.n1931 VSSD.n1360 4.5005
R11887 VSSD.n1931 VSSD.n1356 4.5005
R11888 VSSD.n1931 VSSD.n1361 4.5005
R11889 VSSD.n1931 VSSD.n1355 4.5005
R11890 VSSD.n1931 VSSD.n1362 4.5005
R11891 VSSD.n1931 VSSD.n1354 4.5005
R11892 VSSD.n1931 VSSD.n1363 4.5005
R11893 VSSD.n1931 VSSD.n1353 4.5005
R11894 VSSD.n1931 VSSD.n1364 4.5005
R11895 VSSD.n1931 VSSD.n1352 4.5005
R11896 VSSD.n1931 VSSD.n1365 4.5005
R11897 VSSD.n1931 VSSD.n1351 4.5005
R11898 VSSD.n1931 VSSD.n1366 4.5005
R11899 VSSD.n1931 VSSD.n1350 4.5005
R11900 VSSD.n1931 VSSD.n1367 4.5005
R11901 VSSD.n1931 VSSD.n1349 4.5005
R11902 VSSD.n1931 VSSD.n1368 4.5005
R11903 VSSD.n1931 VSSD.n1348 4.5005
R11904 VSSD.n1931 VSSD.n1369 4.5005
R11905 VSSD.n1931 VSSD.n1347 4.5005
R11906 VSSD.n1931 VSSD.n1370 4.5005
R11907 VSSD.n1931 VSSD.n1930 4.5005
R11908 VSSD.n1955 VSSD.n1954 4.5005
R11909 VSSD.n1955 VSSD.n1297 4.5005
R11910 VSSD.n1955 VSSD.n1296 4.5005
R11911 VSSD.n1955 VSSD.n1295 4.5005
R11912 VSSD.n1955 VSSD.n1294 4.5005
R11913 VSSD.n1955 VSSD.n1293 4.5005
R11914 VSSD.n1955 VSSD.n1292 4.5005
R11915 VSSD.n1955 VSSD.n1291 4.5005
R11916 VSSD.n1954 VSSD.n1303 4.5005
R11917 VSSD.n1303 VSSD.n1297 4.5005
R11918 VSSD.n1303 VSSD.n1296 4.5005
R11919 VSSD.n1303 VSSD.n1295 4.5005
R11920 VSSD.n1303 VSSD.n1294 4.5005
R11921 VSSD.n1303 VSSD.n1293 4.5005
R11922 VSSD.n1303 VSSD.n1292 4.5005
R11923 VSSD.n1954 VSSD.n1307 4.5005
R11924 VSSD.n1307 VSSD.n1297 4.5005
R11925 VSSD.n1307 VSSD.n1296 4.5005
R11926 VSSD.n1307 VSSD.n1295 4.5005
R11927 VSSD.n1307 VSSD.n1294 4.5005
R11928 VSSD.n1307 VSSD.n1292 4.5005
R11929 VSSD.n1952 VSSD.n1307 4.5005
R11930 VSSD.n1954 VSSD.n1302 4.5005
R11931 VSSD.n1302 VSSD.n1297 4.5005
R11932 VSSD.n1302 VSSD.n1296 4.5005
R11933 VSSD.n1302 VSSD.n1295 4.5005
R11934 VSSD.n1302 VSSD.n1294 4.5005
R11935 VSSD.n1302 VSSD.n1292 4.5005
R11936 VSSD.n1952 VSSD.n1302 4.5005
R11937 VSSD.n1954 VSSD.n1310 4.5005
R11938 VSSD.n1310 VSSD.n1297 4.5005
R11939 VSSD.n1310 VSSD.n1296 4.5005
R11940 VSSD.n1310 VSSD.n1295 4.5005
R11941 VSSD.n1310 VSSD.n1294 4.5005
R11942 VSSD.n1310 VSSD.n1292 4.5005
R11943 VSSD.n1952 VSSD.n1310 4.5005
R11944 VSSD.n1954 VSSD.n1301 4.5005
R11945 VSSD.n1301 VSSD.n1297 4.5005
R11946 VSSD.n1301 VSSD.n1296 4.5005
R11947 VSSD.n1301 VSSD.n1295 4.5005
R11948 VSSD.n1301 VSSD.n1294 4.5005
R11949 VSSD.n1301 VSSD.n1292 4.5005
R11950 VSSD.n1952 VSSD.n1301 4.5005
R11951 VSSD.n1954 VSSD.n1313 4.5005
R11952 VSSD.n1313 VSSD.n1297 4.5005
R11953 VSSD.n1313 VSSD.n1296 4.5005
R11954 VSSD.n1313 VSSD.n1295 4.5005
R11955 VSSD.n1313 VSSD.n1294 4.5005
R11956 VSSD.n1313 VSSD.n1292 4.5005
R11957 VSSD.n1952 VSSD.n1313 4.5005
R11958 VSSD.n1954 VSSD.n1300 4.5005
R11959 VSSD.n1300 VSSD.n1297 4.5005
R11960 VSSD.n1300 VSSD.n1296 4.5005
R11961 VSSD.n1300 VSSD.n1295 4.5005
R11962 VSSD.n1300 VSSD.n1294 4.5005
R11963 VSSD.n1300 VSSD.n1292 4.5005
R11964 VSSD.n1952 VSSD.n1300 4.5005
R11965 VSSD.n1954 VSSD.n1316 4.5005
R11966 VSSD.n1316 VSSD.n1297 4.5005
R11967 VSSD.n1316 VSSD.n1296 4.5005
R11968 VSSD.n1316 VSSD.n1295 4.5005
R11969 VSSD.n1316 VSSD.n1294 4.5005
R11970 VSSD.n1316 VSSD.n1292 4.5005
R11971 VSSD.n1952 VSSD.n1316 4.5005
R11972 VSSD.n1954 VSSD.n1299 4.5005
R11973 VSSD.n1299 VSSD.n1297 4.5005
R11974 VSSD.n1299 VSSD.n1296 4.5005
R11975 VSSD.n1299 VSSD.n1295 4.5005
R11976 VSSD.n1299 VSSD.n1294 4.5005
R11977 VSSD.n1299 VSSD.n1292 4.5005
R11978 VSSD.n1952 VSSD.n1299 4.5005
R11979 VSSD.n1954 VSSD.n1953 4.5005
R11980 VSSD.n1953 VSSD.n1297 4.5005
R11981 VSSD.n1953 VSSD.n1296 4.5005
R11982 VSSD.n1953 VSSD.n1295 4.5005
R11983 VSSD.n1953 VSSD.n1294 4.5005
R11984 VSSD.n1953 VSSD.n1293 4.5005
R11985 VSSD.n1953 VSSD.n1292 4.5005
R11986 VSSD.n1953 VSSD.n1952 4.5005
R11987 VSSD.n1286 VSSD.n1281 4.5005
R11988 VSSD.n1959 VSSD.n1281 4.5005
R11989 VSSD.n1276 VSSD.n1270 4.5005
R11990 VSSD.n1959 VSSD.n1276 4.5005
R11991 VSSD.n1283 VSSD.n1270 4.5005
R11992 VSSD.n1283 VSSD.n1268 4.5005
R11993 VSSD.n1283 VSSD.n1271 4.5005
R11994 VSSD.n1283 VSSD.n1267 4.5005
R11995 VSSD.n1283 VSSD.n1272 4.5005
R11996 VSSD.n1283 VSSD.n1266 4.5005
R11997 VSSD.n1286 VSSD.n1283 4.5005
R11998 VSSD.n1959 VSSD.n1283 4.5005
R11999 VSSD.n1960 VSSD.n1270 4.5005
R12000 VSSD.n1960 VSSD.n1268 4.5005
R12001 VSSD.n1960 VSSD.n1271 4.5005
R12002 VSSD.n1960 VSSD.n1267 4.5005
R12003 VSSD.n1960 VSSD.n1272 4.5005
R12004 VSSD.n1960 VSSD.n1266 4.5005
R12005 VSSD.n1960 VSSD.n1959 4.5005
R12006 VSSD.n1958 VSSD.n1268 4.5005
R12007 VSSD.n1958 VSSD.n1271 4.5005
R12008 VSSD.n1958 VSSD.n1267 4.5005
R12009 VSSD.n1958 VSSD.n1272 4.5005
R12010 VSSD.n1958 VSSD.n1266 4.5005
R12011 VSSD.n1958 VSSD.n1286 4.5005
R12012 VSSD.n1959 VSSD.n1958 4.5005
R12013 VSSD.n1968 VSSD.n1962 4.5005
R12014 VSSD.n1969 VSSD.n1962 4.5005
R12015 VSSD.n1967 VSSD.n1962 4.5005
R12016 VSSD.n1970 VSSD.n1962 4.5005
R12017 VSSD.n1966 VSSD.n1962 4.5005
R12018 VSSD.n1971 VSSD.n1962 4.5005
R12019 VSSD.n1999 VSSD.n1962 4.5005
R12020 VSSD.n2002 VSSD.n1962 4.5005
R12021 VSSD.n2000 VSSD.n1968 4.5005
R12022 VSSD.n2000 VSSD.n1969 4.5005
R12023 VSSD.n2000 VSSD.n1967 4.5005
R12024 VSSD.n2000 VSSD.n1970 4.5005
R12025 VSSD.n2000 VSSD.n1966 4.5005
R12026 VSSD.n2000 VSSD.n1971 4.5005
R12027 VSSD.n2000 VSSD.n1999 4.5005
R12028 VSSD.n1969 VSSD.n1961 4.5005
R12029 VSSD.n1967 VSSD.n1961 4.5005
R12030 VSSD.n1970 VSSD.n1961 4.5005
R12031 VSSD.n1966 VSSD.n1961 4.5005
R12032 VSSD.n1971 VSSD.n1961 4.5005
R12033 VSSD.n1984 VSSD.n1961 4.5005
R12034 VSSD.n1999 VSSD.n1961 4.5005
R12035 VSSD.n1964 VSSD.n1961 4.5005
R12036 VSSD.n2002 VSSD.n1961 4.5005
R12037 VSSD.n3299 VSSD.n3298 4.5005
R12038 VSSD.n3299 VSSD.n255 4.5005
R12039 VSSD.n3300 VSSD.n3299 4.5005
R12040 VSSD.n266 VSSD.n253 4.5005
R12041 VSSD.n266 VSSD.n258 4.5005
R12042 VSSD.n266 VSSD.n256 4.5005
R12043 VSSD.n3300 VSSD.n266 4.5005
R12044 VSSD.n3301 VSSD.n253 4.5005
R12045 VSSD.n3302 VSSD.n3301 4.5005
R12046 VSSD.n3301 VSSD.n254 4.5005
R12047 VSSD.n3301 VSSD.n259 4.5005
R12048 VSSD.n3301 VSSD.n255 4.5005
R12049 VSSD.n3301 VSSD.n258 4.5005
R12050 VSSD.n3301 VSSD.n256 4.5005
R12051 VSSD.n3301 VSSD.n3300 4.5005
R12052 VSSD.n3300 VSSD.n261 4.5005
R12053 VSSD.n261 VSSD.n256 4.5005
R12054 VSSD.n261 VSSD.n258 4.5005
R12055 VSSD.n261 VSSD.n255 4.5005
R12056 VSSD.n261 VSSD.n259 4.5005
R12057 VSSD.n261 VSSD.n254 4.5005
R12058 VSSD.n3302 VSSD.n261 4.5005
R12059 VSSD.n261 VSSD.n253 4.5005
R12060 VSSD.n3303 VSSD.n256 4.5005
R12061 VSSD.n3303 VSSD.n258 4.5005
R12062 VSSD.n3303 VSSD.n255 4.5005
R12063 VSSD.n3303 VSSD.n259 4.5005
R12064 VSSD.n3303 VSSD.n254 4.5005
R12065 VSSD.n3303 VSSD.n3302 4.5005
R12066 VSSD.n3303 VSSD.n253 4.5005
R12067 VSSD.n3317 VSSD.n242 4.5005
R12068 VSSD.n3314 VSSD.n242 4.5005
R12069 VSSD.n242 VSSD.n3 4.5005
R12070 VSSD.n3311 VSSD.n244 4.5005
R12071 VSSD.n3311 VSSD.n3307 4.5005
R12072 VSSD.n3314 VSSD.n3311 4.5005
R12073 VSSD.n3311 VSSD.n3 4.5005
R12074 VSSD.n3317 VSSD.n3316 4.5005
R12075 VSSD.n3316 VSSD.n247 4.5005
R12076 VSSD.n3316 VSSD.n245 4.5005
R12077 VSSD.n3316 VSSD.n249 4.5005
R12078 VSSD.n3316 VSSD.n244 4.5005
R12079 VSSD.n3316 VSSD.n3307 4.5005
R12080 VSSD.n3316 VSSD.n3 4.5005
R12081 VSSD.t471 VSSD.t36 4.10145
R12082 VSSD.t441 VSSD.t216 4.10145
R12083 VSSD.t82 VSSD.t268 4.10145
R12084 VSSD.t288 VSSD.t110 4.10145
R12085 VSSD.n1802 VSSD.t176 3.96068
R12086 VSSD.n1806 VSSD.t255 3.96068
R12087 VSSD.n1503 VSSD.t149 3.96068
R12088 VSSD.n1507 VSSD.t427 3.96068
R12089 VSSD.n1511 VSSD.t371 3.96068
R12090 VSSD.n1515 VSSD.t573 3.96068
R12091 VSSD.n1651 VSSD.t502 3.96068
R12092 VSSD.n1647 VSSD.t659 3.96068
R12093 VSSD.n1643 VSSD.t55 3.96068
R12094 VSSD.n1639 VSSD.t180 3.96068
R12095 VSSD.n843 VSSD.t162 3.96068
R12096 VSSD.n847 VSSD.t608 3.96068
R12097 VSSD.n851 VSSD.t377 3.96068
R12098 VSSD.n855 VSSD.t220 3.96068
R12099 VSSD.n2434 VSSD.t182 3.96068
R12100 VSSD.n2438 VSSD.t577 3.96068
R12101 VSSD.n2442 VSSD.t137 3.96068
R12102 VSSD.n2446 VSSD.t476 3.96068
R12103 VSSD.n2617 VSSD.t213 3.96068
R12104 VSSD.n2613 VSSD.t461 3.96068
R12105 VSSD.n2609 VSSD.t310 3.96068
R12106 VSSD.n2605 VSSD.t571 3.96068
R12107 VSSD.n2515 VSSD.t178 3.96068
R12108 VSSD.n2519 VSSD.t468 3.96068
R12109 VSSD.n88 VSSD.t46 3.96068
R12110 VSSD.n92 VSSD.t423 3.96068
R12111 VSSD.n96 VSSD.t31 3.96068
R12112 VSSD.n100 VSSD.t123 3.96068
R12113 VSSD.n2523 VSSD.t596 3.96068
R12114 VSSD.n2527 VSSD.t318 3.96068
R12115 VSSD.n2569 VSSD.t257 3.96068
R12116 VSSD.n2573 VSSD.t539 3.96068
R12117 VSSD.n2577 VSSD.t457 3.96068
R12118 VSSD.n2581 VSSD.t73 3.96068
R12119 VSSD.n3084 VSSD.t642 3.96068
R12120 VSSD.n3088 VSSD.t453 3.96068
R12121 VSSD.n3092 VSSD.t226 3.96068
R12122 VSSD.n3096 VSSD.t224 3.96068
R12123 VSSD.n3280 VSSD.t48 3.96068
R12124 VSSD.n3284 VSSD.t383 3.96068
R12125 VSSD.n3288 VSSD.t588 3.96068
R12126 VSSD.n3292 VSSD.t185 3.96068
R12127 VSSD.n3191 VSSD.t306 3.96068
R12128 VSSD.n3187 VSSD.t425 3.96068
R12129 VSSD.n3183 VSSD.t631 3.96068
R12130 VSSD.n3179 VSSD.t308 3.96068
R12131 VSSD.n559 VSSD.t565 3.96068
R12132 VSSD.n555 VSSD.t447 3.96068
R12133 VSSD.n551 VSSD.t141 3.96068
R12134 VSSD.n547 VSSD.t63 3.96068
R12135 VSSD.n2987 VSSD.t545 3.96068
R12136 VSSD.n2991 VSSD.t187 3.96068
R12137 VSSD.n2995 VSSD.t671 3.96068
R12138 VSSD.n2999 VSSD.t42 3.96068
R12139 VSSD.n2945 VSSD.t337 3.96068
R12140 VSSD.n2949 VSSD.t598 3.96068
R12141 VSSD.n2953 VSSD.t474 3.96068
R12142 VSSD.n2957 VSSD.t561 3.96068
R12143 VSSD.n2848 VSSD.t646 3.96068
R12144 VSSD.n2852 VSSD.t276 3.96068
R12145 VSSD.n2856 VSSD.t689 3.96068
R12146 VSSD.n2860 VSSD.t416 3.96068
R12147 VSSD.n2150 VSSD.t627 3.96068
R12148 VSSD.n2146 VSSD.t143 3.96068
R12149 VSSD.n2142 VSSD.t492 3.96068
R12150 VSSD.n2138 VSSD.t559 3.96068
R12151 VSSD.n1761 VSSD.t1 3.96068
R12152 VSSD.n1757 VSSD.t673 3.96068
R12153 VSSD.n1753 VSSD.t71 3.96068
R12154 VSSD.n1749 VSSD.t174 3.96068
R12155 VSSD.n746 VSSD.t555 3.96068
R12156 VSSD.n750 VSSD.t358 3.96068
R12157 VSSD.n754 VSSD.t604 3.96068
R12158 VSSD.n758 VSSD.t207 3.96068
R12159 VSSD.n2352 VSSD.t625 3.96068
R12160 VSSD.n2348 VSSD.t683 3.96068
R12161 VSSD.n2344 VSSD.t97 3.96068
R12162 VSSD.n2340 VSSD.t125 3.96068
R12163 VSSD.n2237 VSSD.t470 3.96068
R12164 VSSD.n2241 VSSD.t369 3.96068
R12165 VSSD.n2245 VSSD.t437 3.96068
R12166 VSSD.n2249 VSSD.t230 3.96068
R12167 VSSD.n1810 VSSD.t602 3.96068
R12168 VSSD.n1814 VSSD.t251 3.96068
R12169 VSSD.n2021 VSSD.t663 3.96068
R12170 VSSD.n2017 VSSD.t650 3.96068
R12171 VSSD.n2013 VSSD.t618 3.96068
R12172 VSSD.n2009 VSSD.t164 3.96068
R12173 VSSD.n1803 VSSD.t241 3.92733
R12174 VSSD.n1807 VSSD.t610 3.92733
R12175 VSSD.n1502 VSSD.t50 3.92733
R12176 VSSD.n1506 VSSD.t496 3.92733
R12177 VSSD.n1510 VSSD.t435 3.92733
R12178 VSSD.n1514 VSSD.t107 3.92733
R12179 VSSD.n1652 VSSD.t203 3.92733
R12180 VSSD.n1648 VSSD.t17 3.92733
R12181 VSSD.n1644 VSSD.t455 3.92733
R12182 VSSD.n1640 VSSD.t38 3.92733
R12183 VSSD.n842 VSSD.t172 3.92733
R12184 VSSD.n846 VSSD.t498 3.92733
R12185 VSSD.n850 VSSD.t600 3.92733
R12186 VSSD.n854 VSSD.t237 3.92733
R12187 VSSD.n2435 VSSD.t679 3.92733
R12188 VSSD.n2439 VSSD.t616 3.92733
R12189 VSSD.n2443 VSSD.t147 3.92733
R12190 VSSD.n2447 VSSD.t133 3.92733
R12191 VSSD.n2618 VSSD.t131 3.92733
R12192 VSSD.n2614 VSSD.t19 3.92733
R12193 VSSD.n2610 VSSD.t431 3.92733
R12194 VSSD.n2606 VSSD.t488 3.92733
R12195 VSSD.n2516 VSSD.t320 3.92733
R12196 VSSD.n2520 VSSD.t685 3.92733
R12197 VSSD.n87 VSSD.t549 3.92733
R12198 VSSD.n91 VSSD.t590 3.92733
R12199 VSSD.n95 VSSD.t459 3.92733
R12200 VSSD.n99 VSSD.t103 3.92733
R12201 VSSD.n2524 VSSD.t533 3.92733
R12202 VSSD.n2528 VSSD.t168 3.92733
R12203 VSSD.n2570 VSSD.t297 3.92733
R12204 VSSD.n2574 VSSD.t145 3.92733
R12205 VSSD.n2578 VSSD.t581 3.92733
R12206 VSSD.n2582 VSSD.t661 3.92733
R12207 VSSD.n3083 VSSD.t567 3.92733
R12208 VSSD.n3087 VSSD.t302 3.92733
R12209 VSSD.n3091 VSSD.t614 3.92733
R12210 VSSD.n3095 VSSD.t396 3.92733
R12211 VSSD.n3281 VSSD.t69 3.92733
R12212 VSSD.n3285 VSSD.t139 3.92733
R12213 VSSD.n3289 VSSD.t40 3.92733
R12214 VSSD.n3293 VSSD.t129 3.92733
R12215 VSSD.n3192 VSSD.t222 3.92733
R12216 VSSD.n3188 VSSD.t367 3.92733
R12217 VSSD.n3184 VSSD.t687 3.92733
R12218 VSSD.n3180 VSSD.t508 3.92733
R12219 VSSD.n558 VSSD.t637 3.92733
R12220 VSSD.n554 VSSD.t681 3.92733
R12221 VSSD.n550 VSSD.t7 3.92733
R12222 VSSD.n546 VSSD.t228 3.92733
R12223 VSSD.n2988 VSSD.t33 3.92733
R12224 VSSD.n2992 VSSD.t606 3.92733
R12225 VSSD.n2996 VSSD.t504 3.92733
R12226 VSSD.n3000 VSSD.t557 3.92733
R12227 VSSD.n2944 VSSD.t547 3.92733
R12228 VSSD.n2948 VSSD.t105 3.92733
R12229 VSSD.n2952 VSSD.t433 3.92733
R12230 VSSD.n2956 VSSD.t394 3.92733
R12231 VSSD.n2849 VSSD.t594 3.92733
R12232 VSSD.n2853 VSSD.t451 3.92733
R12233 VSSD.n2857 VSSD.t81 3.92733
R12234 VSSD.n2861 VSSD.t553 3.92733
R12235 VSSD.n2151 VSSD.t648 3.92733
R12236 VSSD.n2147 VSSD.t398 3.92733
R12237 VSSD.n2143 VSSD.t429 3.92733
R12238 VSSD.n2139 VSSD.t363 3.92733
R12239 VSSD.n1762 VSSD.t665 3.92733
R12240 VSSD.n1758 VSSD.t640 3.92733
R12241 VSSD.n1754 VSSD.t655 3.92733
R12242 VSSD.n1750 VSSD.t408 3.92733
R12243 VSSD.n747 VSSD.t390 3.92733
R12244 VSSD.n751 VSSD.t653 3.92733
R12245 VSSD.n755 VSSD.t322 3.92733
R12246 VSSD.n759 VSSD.t569 3.92733
R12247 VSSD.n2353 VSSD.t563 3.92733
R12248 VSSD.n2349 VSSD.t95 3.92733
R12249 VSSD.n2345 VSSD.t657 3.92733
R12250 VSSD.n2341 VSSD.t272 3.92733
R12251 VSSD.n2238 VSSD.t381 3.92733
R12252 VSSD.n2242 VSSD.t612 3.92733
R12253 VSSD.n2246 VSSD.t592 3.92733
R12254 VSSD.n2250 VSSD.t551 3.92733
R12255 VSSD.n1811 VSSD.t79 3.92733
R12256 VSSD.n1815 VSSD.t127 3.92733
R12257 VSSD.n2020 VSSD.t243 3.92733
R12258 VSSD.n2016 VSSD.t675 3.92733
R12259 VSSD.n2012 VSSD.t99 3.92733
R12260 VSSD.n2008 VSSD.t170 3.92733
R12261 VSSD.n271 VSSD.t189 3.76153
R12262 VSSD.n328 VSSD.t299 3.76153
R12263 VSSD.n3176 VSSD.t510 3.76153
R12264 VSSD.n2029 VSSD.t166 3.76153
R12265 VSSD.n1873 VSSD.t341 3.76153
R12266 VSSD.n1877 VSSD.t151 3.76153
R12267 VSSD.n1517 VSSD.t284 3.76153
R12268 VSSD.n1518 VSSD.t386 3.76153
R12269 VSSD.n1519 VSSD.t365 3.76153
R12270 VSSD.n1089 VSSD.t85 3.76153
R12271 VSSD.n1088 VSSD.t522 3.76153
R12272 VSSD.n1669 VSSD.t500 3.76153
R12273 VSSD.n2364 VSSD.t449 3.76153
R12274 VSSD.n2465 VSSD.t404 3.76153
R12275 VSSD.n2467 VSSD.t516 3.76153
R12276 VSSD.n2721 VSSD.t121 3.76153
R12277 VSSD.n858 VSSD.t195 3.76153
R12278 VSSD.n2462 VSSD.t201 3.76153
R12279 VSSD.n978 VSSD.t346 3.76153
R12280 VSSD.n3551 VSSD.t21 3.76153
R12281 VSSD.n3547 VSSD.t335 3.76153
R12282 VSSD.n102 VSSD.t484 3.76153
R12283 VSSD.n103 VSSD.t644 3.76153
R12284 VSSD.n104 VSSD.t360 3.76153
R12285 VSSD.n2543 VSSD.t316 3.76153
R12286 VSSD.n2597 VSSD.t245 3.76153
R12287 VSSD.n2487 VSSD.t530 3.76153
R12288 VSSD.n2488 VSSD.t354 3.76153
R12289 VSSD.n3662 VSSD.t239 3.76153
R12290 VSSD.n977 VSSD.t10 3.76153
R12291 VSSD.n2601 VSSD.t293 3.76153
R12292 VSSD.n976 VSSD.t215 3.76153
R12293 VSSD.n981 VSSD.t524 3.76153
R12294 VSSD.n982 VSSD.t77 3.76153
R12295 VSSD.n566 VSSD.t109 3.76153
R12296 VSSD.n273 VSSD.t343 3.76153
R12297 VSSD.n272 VSSD.t375 3.76153
R12298 VSSD.n275 VSSD.t118 3.76153
R12299 VSSD.n274 VSSD.t155 3.76153
R12300 VSSD.n327 VSSD.t267 3.76153
R12301 VSSD.n396 VSSD.t313 3.76153
R12302 VSSD.n3099 VSSD.t528 3.76153
R12303 VSSD.n3155 VSSD.t65 3.76153
R12304 VSSD.n578 VSSD.t26 3.76153
R12305 VSSD.n579 VSSD.t526 3.76153
R12306 VSSD.n495 VSSD.t5 3.76153
R12307 VSSD.n2983 VSSD.t494 3.76153
R12308 VSSD.n2103 VSSD.t621 3.76153
R12309 VSSD.n2104 VSSD.t518 3.76153
R12310 VSSD.n678 VSSD.t418 3.76153
R12311 VSSD.n2844 VSSD.t439 3.76153
R12312 VSSD.n1734 VSSD.t233 3.76153
R12313 VSSD.n1746 VSSD.t520 3.76153
R12314 VSSD.n2154 VSSD.t629 3.76153
R12315 VSSD.n1127 VSSD.t392 3.76153
R12316 VSSD.n1100 VSSD.t14 3.76153
R12317 VSSD.n679 VSSD.t633 3.76153
R12318 VSSD.n580 VSSD.t197 3.76153
R12319 VSSD.n730 VSSD.t349 3.76153
R12320 VSSD.n681 VSSD.t479 3.76153
R12321 VSSD.n496 VSSD.t209 3.76153
R12322 VSSD.n397 VSSD.t287 3.76153
R12323 VSSD.n570 VSSD.t265 3.76153
R12324 VSSD.n545 VSSD.t116 3.76153
R12325 VSSD.n563 VSSD.t59 3.76153
R12326 VSSD.n859 VSSD.t677 3.76153
R12327 VSSD.n2717 VSSD.t259 3.76153
R12328 VSSD.n857 VSSD.t669 3.76153
R12329 VSSD.n2818 VSSD.t205 3.76153
R12330 VSSD.n995 VSSD.t44 3.76153
R12331 VSSD.n2414 VSSD.t295 3.76153
R12332 VSSD.n2359 VSSD.t541 3.76153
R12333 VSSD.n2356 VSSD.t274 3.76153
R12334 VSSD.n2823 VSSD.t514 3.76153
R12335 VSSD.n2821 VSSD.t325 3.76153
R12336 VSSD.n1087 VSSD.t270 3.76153
R12337 VSSD.n1097 VSSD.t90 3.76153
R12338 VSSD.n2172 VSSD.t445 3.76153
R12339 VSSD.n1665 VSSD.t52 3.76153
R12340 VSSD.n2222 VSSD.t413 3.76153
R12341 VSSD.n1722 VSSD.t253 3.76153
R12342 VSSD.n1724 VSSD.t512 3.76153
R12343 VSSD.n1723 VSSD.t278 3.76153
R12344 VSSD.n1765 VSSD.t3 3.76153
R12345 VSSD.n1262 VSSD.t153 3.76153
R12346 VSSD.n1261 VSSD.t135 3.76153
R12347 VSSD.n1260 VSSD.t35 3.76153
R12348 VSSD.n2024 VSSD.t351 3.76153
R12349 VSSD.n385 VSSD.t289 3.71588
R12350 VSSD.n3171 VSSD.t157 3.71588
R12351 VSSD.n395 VSSD.t113 3.71588
R12352 VSSD.n2971 VSSD.t83 3.71588
R12353 VSSD.n2476 VSSD.t465 3.71588
R12354 VSSD.n740 VSSD.t329 3.71588
R12355 VSSD.n2832 VSSD.t67 3.71588
R12356 VSSD.n2122 VSSD.t217 3.71588
R12357 VSSD.n577 VSSD.t262 3.71588
R12358 VSSD.n2105 VSSD.t12 3.71588
R12359 VSSD.n2160 VSSD.t472 3.71588
R12360 VSSD.n1656 VSSD.t101 3.71588
R12361 VSSD.n1741 VSSD.t586 3.71588
R12362 VSSD.n1091 VSSD.t92 3.71588
R12363 VSSD.n2422 VSSD.t193 3.71588
R12364 VSSD.n993 VSSD.t536 3.71588
R12365 VSSD.n2565 VSSD.t506 3.71588
R12366 VSSD.n2 VSSD.t443 3.71588
R12367 VSSD.n2490 VSSD.t579 3.71588
R12368 VSSD.n2496 VSSD.t159 3.71588
R12369 VSSD.n1725 VSSD.t388 3.71588
R12370 VSSD.n1774 VSSD.t61 3.71588
R12371 VSSD.t36 VSSD.n1103 3.4863
R12372 VSSD.n2125 VSSD.t441 3.4863
R12373 VSSD.t268 VSSD.n572 3.4863
R12374 VSSD.t110 VSSD.n392 3.4863
R12375 VSSD.n1877 VSSD.n1876 3.46717
R12376 VSSD.n1874 VSSD.n1873 3.46717
R12377 VSSD.n1783 VSSD.n1517 3.46717
R12378 VSSD.n3551 VSSD.n3550 3.46717
R12379 VSSD.n3548 VSSD.n3547 3.46717
R12380 VSSD.n2484 VSSD.n102 3.46717
R12381 VSSD.n2485 VSSD.n103 3.46717
R12382 VSSD.n2486 VSSD.n104 3.46717
R12383 VSSD.n2506 VSSD.n2487 3.46717
R12384 VSSD.n2505 VSSD.n2488 3.46717
R12385 VSSD.n2544 VSSD.n2543 3.46717
R12386 VSSD.n979 VSSD.n978 3.46717
R12387 VSSD.n3663 VSSD.n3662 3.46717
R12388 VSSD.n2561 VSSD.n981 3.46717
R12389 VSSD.n2560 VSSD.n982 3.46717
R12390 VSSD.n2598 VSSD.n2597 3.46717
R12391 VSSD.n2601 VSSD.n2600 3.46717
R12392 VSSD.n988 VSSD.n977 3.46717
R12393 VSSD.n990 VSSD.n976 3.46717
R12394 VSSD.n2844 VSSD.n2843 3.46717
R12395 VSSD.n2842 VSSD.n679 3.46717
R12396 VSSD.n2840 VSSD.n678 3.46717
R12397 VSSD.n2983 VSSD.n2982 3.46717
R12398 VSSD.n2981 VSSD.n496 3.46717
R12399 VSSD.n2979 VSSD.n495 3.46717
R12400 VSSD.n566 VSSD.n565 3.46717
R12401 VSSD.n564 VSSD.n563 3.46717
R12402 VSSD.n3156 VSSD.n3155 3.46717
R12403 VSSD.n2430 VSSD.n858 3.46717
R12404 VSSD.n994 VSSD.n859 3.46717
R12405 VSSD.n2721 VSSD.n2720 3.46717
R12406 VSSD.n2718 VSSD.n2717 3.46717
R12407 VSSD.n2431 VSSD.n857 3.46717
R12408 VSSD.n2463 VSSD.n2462 3.46717
R12409 VSSD.n2468 VSSD.n2467 3.46717
R12410 VSSD.n2466 VSSD.n2465 3.46717
R12411 VSSD.n2364 VSSD.n2363 3.46717
R12412 VSSD.n2360 VSSD.n2359 3.46717
R12413 VSSD.n2357 VSSD.n2356 3.46717
R12414 VSSD.n1098 VSSD.n1097 3.46717
R12415 VSSD.n2172 VSSD.n2171 3.46717
R12416 VSSD.n1669 VSSD.n1668 3.46717
R12417 VSSD.n1666 VSSD.n1665 3.46717
R12418 VSSD.n2223 VSSD.n2222 3.46717
R12419 VSSD.n2225 VSSD.n1087 3.46717
R12420 VSSD.n2228 VSSD.n1088 3.46717
R12421 VSSD.n2227 VSSD.n1089 3.46717
R12422 VSSD.n2029 VSSD.n2028 3.46717
R12423 VSSD.n2025 VSSD.n2024 3.46717
R12424 VSSD.n1733 VSSD.n1260 3.46717
R12425 VSSD.n1766 VSSD.n1765 3.46717
R12426 VSSD.n1735 VSSD.n1734 3.46717
R12427 VSSD.n1746 VSSD.n1745 3.46717
R12428 VSSD.n1769 VSSD.n1262 3.46717
R12429 VSSD.n1768 VSSD.n1261 3.46717
R12430 VSSD.n1790 VSSD.n1724 3.46717
R12431 VSSD.n1789 VSSD.n1723 3.46717
R12432 VSSD.n1787 VSSD.n1722 3.46717
R12433 VSSD.n1785 VSSD.n1518 3.46717
R12434 VSSD.n1784 VSSD.n1519 3.46717
R12435 VSSD.n1127 VSSD.n1102 3.46717
R12436 VSSD.n1101 VSSD.n1100 3.46717
R12437 VSSD.n2155 VSSD.n2154 3.46717
R12438 VSSD.n2109 VSSD.n2103 3.46717
R12439 VSSD.n2110 VSSD.n2104 3.46717
R12440 VSSD.n2117 VSSD.n580 3.46717
R12441 VSSD.n2116 VSSD.n578 3.46717
R12442 VSSD.n2115 VSSD.n579 3.46717
R12443 VSSD.n731 VSSD.n730 3.46717
R12444 VSSD.n682 VSSD.n681 3.46717
R12445 VSSD.n2824 VSSD.n2823 3.46717
R12446 VSSD.n2822 VSSD.n2821 3.46717
R12447 VSSD.n2819 VSSD.n2818 3.46717
R12448 VSSD.n2361 VSSD.n995 3.46717
R12449 VSSD.n2415 VSSD.n2414 3.46717
R12450 VSSD.n571 VSSD.n570 3.46717
R12451 VSSD.n562 VSSD.n545 3.46717
R12452 VSSD.n2965 VSSD.n397 3.46717
R12453 VSSD.n2964 VSSD.n396 3.46717
R12454 VSSD.n3100 VSSD.n3099 3.46717
R12455 VSSD.n3109 VSSD.n327 3.46717
R12456 VSSD.n3108 VSSD.n328 3.46717
R12457 VSSD.n3176 VSSD.n3175 3.46717
R12458 VSSD.n3160 VSSD.n275 3.46717
R12459 VSSD.n3161 VSSD.n274 3.46717
R12460 VSSD.n3162 VSSD.n273 3.46717
R12461 VSSD.n3163 VSSD.n272 3.46717
R12462 VSSD.n3165 VSSD.n271 3.46717
R12463 VSSD.n1804 VSSD.n1801 2.8535
R12464 VSSD.n1808 VSSD.n1805 2.8535
R12465 VSSD.n1504 VSSD.n1501 2.8535
R12466 VSSD.n1508 VSSD.n1505 2.8535
R12467 VSSD.n1512 VSSD.n1509 2.8535
R12468 VSSD.n1516 VSSD.n1513 2.8535
R12469 VSSD.n1653 VSSD.n1650 2.8535
R12470 VSSD.n1649 VSSD.n1646 2.8535
R12471 VSSD.n1645 VSSD.n1642 2.8535
R12472 VSSD.n1641 VSSD.n1638 2.8535
R12473 VSSD.n844 VSSD.n841 2.8535
R12474 VSSD.n848 VSSD.n845 2.8535
R12475 VSSD.n852 VSSD.n849 2.8535
R12476 VSSD.n856 VSSD.n853 2.8535
R12477 VSSD.n2436 VSSD.n2433 2.8535
R12478 VSSD.n2440 VSSD.n2437 2.8535
R12479 VSSD.n2444 VSSD.n2441 2.8535
R12480 VSSD.n2448 VSSD.n2445 2.8535
R12481 VSSD.n2619 VSSD.n2616 2.8535
R12482 VSSD.n2615 VSSD.n2612 2.8535
R12483 VSSD.n2611 VSSD.n2608 2.8535
R12484 VSSD.n2607 VSSD.n2604 2.8535
R12485 VSSD.n2517 VSSD.n2514 2.8535
R12486 VSSD.n2521 VSSD.n2518 2.8535
R12487 VSSD.n89 VSSD.n86 2.8535
R12488 VSSD.n93 VSSD.n90 2.8535
R12489 VSSD.n97 VSSD.n94 2.8535
R12490 VSSD.n101 VSSD.n98 2.8535
R12491 VSSD.n2525 VSSD.n2522 2.8535
R12492 VSSD.n2529 VSSD.n2526 2.8535
R12493 VSSD.n2571 VSSD.n2568 2.8535
R12494 VSSD.n2575 VSSD.n2572 2.8535
R12495 VSSD.n2579 VSSD.n2576 2.8535
R12496 VSSD.n2583 VSSD.n2580 2.8535
R12497 VSSD.n3085 VSSD.n3082 2.8535
R12498 VSSD.n3089 VSSD.n3086 2.8535
R12499 VSSD.n3093 VSSD.n3090 2.8535
R12500 VSSD.n3097 VSSD.n3094 2.8535
R12501 VSSD.n3282 VSSD.n3279 2.8535
R12502 VSSD.n3286 VSSD.n3283 2.8535
R12503 VSSD.n3290 VSSD.n3287 2.8535
R12504 VSSD.n3294 VSSD.n3291 2.8535
R12505 VSSD.n3193 VSSD.n3190 2.8535
R12506 VSSD.n3189 VSSD.n3186 2.8535
R12507 VSSD.n3185 VSSD.n3182 2.8535
R12508 VSSD.n3181 VSSD.n3178 2.8535
R12509 VSSD.n560 VSSD.n557 2.8535
R12510 VSSD.n556 VSSD.n553 2.8535
R12511 VSSD.n552 VSSD.n549 2.8535
R12512 VSSD.n548 VSSD.n334 2.8535
R12513 VSSD.n2989 VSSD.n2986 2.8535
R12514 VSSD.n2993 VSSD.n2990 2.8535
R12515 VSSD.n2997 VSSD.n2994 2.8535
R12516 VSSD.n3001 VSSD.n2998 2.8535
R12517 VSSD.n2946 VSSD.n2943 2.8535
R12518 VSSD.n2950 VSSD.n2947 2.8535
R12519 VSSD.n2954 VSSD.n2951 2.8535
R12520 VSSD.n2958 VSSD.n2955 2.8535
R12521 VSSD.n2850 VSSD.n2847 2.8535
R12522 VSSD.n2854 VSSD.n2851 2.8535
R12523 VSSD.n2858 VSSD.n2855 2.8535
R12524 VSSD.n2862 VSSD.n2859 2.8535
R12525 VSSD.n2152 VSSD.n2149 2.8535
R12526 VSSD.n2148 VSSD.n2145 2.8535
R12527 VSSD.n2144 VSSD.n2141 2.8535
R12528 VSSD.n2140 VSSD.n2137 2.8535
R12529 VSSD.n1763 VSSD.n1760 2.8535
R12530 VSSD.n1759 VSSD.n1756 2.8535
R12531 VSSD.n1755 VSSD.n1752 2.8535
R12532 VSSD.n1751 VSSD.n1748 2.8535
R12533 VSSD.n748 VSSD.n745 2.8535
R12534 VSSD.n752 VSSD.n749 2.8535
R12535 VSSD.n756 VSSD.n753 2.8535
R12536 VSSD.n760 VSSD.n757 2.8535
R12537 VSSD.n2354 VSSD.n2351 2.8535
R12538 VSSD.n2350 VSSD.n2347 2.8535
R12539 VSSD.n2346 VSSD.n2343 2.8535
R12540 VSSD.n2342 VSSD.n2339 2.8535
R12541 VSSD.n2239 VSSD.n2236 2.8535
R12542 VSSD.n2243 VSSD.n2240 2.8535
R12543 VSSD.n2247 VSSD.n2244 2.8535
R12544 VSSD.n2251 VSSD.n2248 2.8535
R12545 VSSD.n1812 VSSD.n1809 2.8535
R12546 VSSD.n1816 VSSD.n1813 2.8535
R12547 VSSD.n2022 VSSD.n2019 2.8535
R12548 VSSD.n2018 VSSD.n2015 2.8535
R12549 VSSD.n2014 VSSD.n2011 2.8535
R12550 VSSD.n2010 VSSD.n1259 2.8535
R12551 VSSD.n3367 VSSD.n225 2.2503
R12552 VSSD.n3324 VSSD.n3323 2.2503
R12553 VSSD.n3367 VSSD.n224 2.2503
R12554 VSSD.n3324 VSSD.n3322 2.2503
R12555 VSSD.n3367 VSSD.n223 2.2503
R12556 VSSD.n3324 VSSD.n3321 2.2503
R12557 VSSD.n3367 VSSD.n222 2.2503
R12558 VSSD.n3324 VSSD.n3320 2.2503
R12559 VSSD.n3367 VSSD.n221 2.2503
R12560 VSSD.n3324 VSSD.n3319 2.2503
R12561 VSSD.n3367 VSSD.n220 2.2503
R12562 VSSD.n3324 VSSD.n168 2.2503
R12563 VSSD.n218 VSSD.n155 2.2503
R12564 VSSD.n3435 VSSD.n3372 2.2503
R12565 VSSD.n3437 VSSD.n3386 2.2503
R12566 VSSD.n3426 VSSD.n3425 2.2503
R12567 VSSD.n3437 VSSD.n3430 2.2503
R12568 VSSD.n3426 VSSD.n3424 2.2503
R12569 VSSD.n3437 VSSD.n3431 2.2503
R12570 VSSD.n3426 VSSD.n3423 2.2503
R12571 VSSD.n3437 VSSD.n3432 2.2503
R12572 VSSD.n3426 VSSD.n3422 2.2503
R12573 VSSD.n3437 VSSD.n3433 2.2503
R12574 VSSD.n3426 VSSD.n3421 2.2503
R12575 VSSD.n3437 VSSD.n3434 2.2503
R12576 VSSD.n3492 VSSD.n3491 2.2503
R12577 VSSD.n1446 VSSD.n1445 2.2503
R12578 VSSD.n1909 VSSD.n1475 2.2503
R12579 VSSD.n1460 VSSD.n1445 2.2503
R12580 VSSD.n1909 VSSD.n1474 2.2503
R12581 VSSD.n1462 VSSD.n1445 2.2503
R12582 VSSD.n1909 VSSD.n1473 2.2503
R12583 VSSD.n1464 VSSD.n1445 2.2503
R12584 VSSD.n1909 VSSD.n1472 2.2503
R12585 VSSD.n1466 VSSD.n1445 2.2503
R12586 VSSD.n1909 VSSD.n1471 2.2503
R12587 VSSD.n1468 VSSD.n1445 2.2503
R12588 VSSD.n1910 VSSD.n1909 2.2503
R12589 VSSD.n1445 VSSD.n1399 2.2503
R12590 VSSD.n1932 VSSD.n1340 2.2503
R12591 VSSD.n1380 VSSD.n1379 2.2503
R12592 VSSD.n1398 VSSD.n1393 2.2503
R12593 VSSD.n1379 VSSD.n1378 2.2503
R12594 VSSD.n1398 VSSD.n1394 2.2503
R12595 VSSD.n1379 VSSD.n1377 2.2503
R12596 VSSD.n1398 VSSD.n1395 2.2503
R12597 VSSD.n1379 VSSD.n1376 2.2503
R12598 VSSD.n1398 VSSD.n1396 2.2503
R12599 VSSD.n1379 VSSD.n1375 2.2503
R12600 VSSD.n1398 VSSD.n1397 2.2503
R12601 VSSD.n1379 VSSD.n1374 2.2503
R12602 VSSD.n1398 VSSD.n1346 2.2503
R12603 VSSD.n75 VSSD.n69 2.24961
R12604 VSSD.n78 VSSD.n69 2.24961
R12605 VSSD.n3580 VSSD.n69 2.24961
R12606 VSSD.n74 VSSD.n66 2.24961
R12607 VSSD.n77 VSSD.n66 2.24961
R12608 VSSD.n3584 VSSD.n3583 2.24961
R12609 VSSD.n1444 VSSD.n1443 2.24961
R12610 VSSD.n1444 VSSD.n1442 2.24961
R12611 VSSD.n1444 VSSD.n1441 2.24961
R12612 VSSD.n1444 VSSD.n1440 2.24961
R12613 VSSD.n1444 VSSD.n1439 2.24961
R12614 VSSD.n1444 VSSD.n1438 2.24961
R12615 VSSD.n1444 VSSD.n1437 2.24961
R12616 VSSD.n1444 VSSD.n1436 2.24961
R12617 VSSD.n1444 VSSD.n1435 2.24961
R12618 VSSD.n1444 VSSD.n1434 2.24961
R12619 VSSD.n1444 VSSD.n1433 2.24961
R12620 VSSD.n1444 VSSD.n1432 2.24961
R12621 VSSD.n1469 VSSD.n1459 2.24961
R12622 VSSD.n1459 VSSD.n1458 2.24961
R12623 VSSD.n1459 VSSD.n1457 2.24961
R12624 VSSD.n1459 VSSD.n1456 2.24961
R12625 VSSD.n1459 VSSD.n1455 2.24961
R12626 VSSD.n1459 VSSD.n1454 2.24961
R12627 VSSD.n1459 VSSD.n1453 2.24961
R12628 VSSD.n1459 VSSD.n1452 2.24961
R12629 VSSD.n1459 VSSD.n1451 2.24961
R12630 VSSD.n1459 VSSD.n1450 2.24961
R12631 VSSD.n1459 VSSD.n1449 2.24961
R12632 VSSD.n1459 VSSD.n1448 2.24961
R12633 VSSD.n1459 VSSD.n1447 2.24961
R12634 VSSD.n1913 VSSD.n1412 2.24961
R12635 VSSD.n1926 VSSD.n1925 2.24961
R12636 VSSD.n1926 VSSD.n1924 2.24961
R12637 VSSD.n1926 VSSD.n1923 2.24961
R12638 VSSD.n1926 VSSD.n1922 2.24961
R12639 VSSD.n1926 VSSD.n1921 2.24961
R12640 VSSD.n1926 VSSD.n1920 2.24961
R12641 VSSD.n1926 VSSD.n1919 2.24961
R12642 VSSD.n1926 VSSD.n1918 2.24961
R12643 VSSD.n1926 VSSD.n1917 2.24961
R12644 VSSD.n1926 VSSD.n1916 2.24961
R12645 VSSD.n1926 VSSD.n1915 2.24961
R12646 VSSD.n1926 VSSD.n1914 2.24961
R12647 VSSD.n1927 VSSD.n1926 2.24961
R12648 VSSD.n1926 VSSD.n1373 2.24961
R12649 VSSD.n1929 VSSD.n1392 2.24961
R12650 VSSD.n1929 VSSD.n1391 2.24961
R12651 VSSD.n1929 VSSD.n1390 2.24961
R12652 VSSD.n1929 VSSD.n1389 2.24961
R12653 VSSD.n1929 VSSD.n1388 2.24961
R12654 VSSD.n1929 VSSD.n1387 2.24961
R12655 VSSD.n1929 VSSD.n1386 2.24961
R12656 VSSD.n1929 VSSD.n1385 2.24961
R12657 VSSD.n1929 VSSD.n1384 2.24961
R12658 VSSD.n1929 VSSD.n1383 2.24961
R12659 VSSD.n1929 VSSD.n1382 2.24961
R12660 VSSD.n1929 VSSD.n1381 2.24961
R12661 VSSD.n1372 VSSD.n1339 2.24961
R12662 VSSD.n1931 VSSD.n1371 2.24961
R12663 VSSD.n246 VSSD.n242 2.24961
R12664 VSSD.n248 VSSD.n242 2.24961
R12665 VSSD.n3312 VSSD.n242 2.24961
R12666 VSSD.n3311 VSSD.n241 2.24961
R12667 VSSD.n3311 VSSD.n3310 2.24961
R12668 VSSD.n3316 VSSD.n3315 2.24961
R12669 VSSD.n198 VSSD.n197 2.24945
R12670 VSSD.n198 VSSD.n196 2.24945
R12671 VSSD.n198 VSSD.n195 2.24945
R12672 VSSD.n198 VSSD.n194 2.24945
R12673 VSSD.n198 VSSD.n193 2.24945
R12674 VSSD.n198 VSSD.n192 2.24945
R12675 VSSD.n198 VSSD.n191 2.24945
R12676 VSSD.n198 VSSD.n190 2.24945
R12677 VSSD.n198 VSSD.n189 2.24945
R12678 VSSD.n198 VSSD.n188 2.24945
R12679 VSSD.n198 VSSD.n187 2.24945
R12680 VSSD.n212 VSSD.n211 2.24945
R12681 VSSD.n212 VSSD.n210 2.24945
R12682 VSSD.n212 VSSD.n209 2.24945
R12683 VSSD.n212 VSSD.n208 2.24945
R12684 VSSD.n212 VSSD.n207 2.24945
R12685 VSSD.n212 VSSD.n206 2.24945
R12686 VSSD.n212 VSSD.n205 2.24945
R12687 VSSD.n212 VSSD.n204 2.24945
R12688 VSSD.n212 VSSD.n203 2.24945
R12689 VSSD.n212 VSSD.n202 2.24945
R12690 VSSD.n212 VSSD.n201 2.24945
R12691 VSSD.n212 VSSD.n200 2.24945
R12692 VSSD.n186 VSSD.n185 2.24945
R12693 VSSD.n227 VSSD.n186 2.24945
R12694 VSSD.n3370 VSSD.n154 2.24945
R12695 VSSD.n3318 VSSD.n219 2.24945
R12696 VSSD.n3368 VSSD.n219 2.24945
R12697 VSSD.n3490 VSSD.n3489 2.24945
R12698 VSSD.n3490 VSSD.n3384 2.24945
R12699 VSSD.n3490 VSSD.n3383 2.24945
R12700 VSSD.n3490 VSSD.n3382 2.24945
R12701 VSSD.n3490 VSSD.n3381 2.24945
R12702 VSSD.n3490 VSSD.n3380 2.24945
R12703 VSSD.n3490 VSSD.n3379 2.24945
R12704 VSSD.n3490 VSSD.n3378 2.24945
R12705 VSSD.n3490 VSSD.n3377 2.24945
R12706 VSSD.n3490 VSSD.n3376 2.24945
R12707 VSSD.n3490 VSSD.n3375 2.24945
R12708 VSSD.n3490 VSSD.n3374 2.24945
R12709 VSSD.n3490 VSSD.n3373 2.24945
R12710 VSSD.n3487 VSSD.n142 2.24945
R12711 VSSD.n3487 VSSD.n3486 2.24945
R12712 VSSD.n3487 VSSD.n3397 2.24945
R12713 VSSD.n3487 VSSD.n3396 2.24945
R12714 VSSD.n3487 VSSD.n3395 2.24945
R12715 VSSD.n3487 VSSD.n3394 2.24945
R12716 VSSD.n3487 VSSD.n3393 2.24945
R12717 VSSD.n3487 VSSD.n3392 2.24945
R12718 VSSD.n3487 VSSD.n3391 2.24945
R12719 VSSD.n3487 VSSD.n3390 2.24945
R12720 VSSD.n3487 VSSD.n3389 2.24945
R12721 VSSD.n3487 VSSD.n3388 2.24945
R12722 VSSD.n3487 VSSD.n3387 2.24945
R12723 VSSD.n3398 VSSD.n148 2.24945
R12724 VSSD.n3436 VSSD.n3371 2.24945
R12725 VSSD.n1892 VSSD.n1880 2.24901
R12726 VSSD.n1896 VSSD.n1895 2.24901
R12727 VSSD.n1897 VSSD.n1498 2.24901
R12728 VSSD.n1895 VSSD.n1497 2.24901
R12729 VSSD.n1534 VSSD.n1530 2.24901
R12730 VSSD.n1530 VSSD.n1525 2.24901
R12731 VSSD.n1713 VSSD.n1543 2.24901
R12732 VSSD.n1716 VSSD.n1715 2.24901
R12733 VSSD.n1704 VSSD.n1703 2.24901
R12734 VSSD.n1709 VSSD.n1540 2.24901
R12735 VSSD.n874 VSSD.n870 2.24901
R12736 VSSD.n870 VSSD.n865 2.24901
R12737 VSSD.n2648 VSSD.n883 2.24901
R12738 VSSD.n2651 VSSD.n2650 2.24901
R12739 VSSD.n2639 VSSD.n2638 2.24901
R12740 VSSD.n2644 VSSD.n880 2.24901
R12741 VSSD.n119 VSSD.n115 2.24901
R12742 VSSD.n115 VSSD.n110 2.24901
R12743 VSSD.n3506 VSSD.n128 2.24901
R12744 VSSD.n3509 VSSD.n3508 2.24901
R12745 VSSD.n3497 VSSD.n3496 2.24901
R12746 VSSD.n3502 VSSD.n125 2.24901
R12747 VSSD.n24 VSSD.n20 2.24901
R12748 VSSD.n20 VSSD.n15 2.24901
R12749 VSSD.n3596 VSSD.n33 2.24901
R12750 VSSD.n3599 VSSD.n3598 2.24901
R12751 VSSD.n3587 VSSD.n3586 2.24901
R12752 VSSD.n3592 VSSD.n30 2.24901
R12753 VSSD.n68 VSSD.n67 2.24901
R12754 VSSD.n3581 VSSD.n70 2.24901
R12755 VSSD.n3566 VSSD.n3554 2.24901
R12756 VSSD.n3570 VSSD.n3569 2.24901
R12757 VSSD.n3571 VSSD.n83 2.24901
R12758 VSSD.n3569 VSSD.n82 2.24901
R12759 VSSD.n970 VSSD.n969 2.24901
R12760 VSSD.n2623 VSSD.n969 2.24901
R12761 VSSD.n921 VSSD.n920 2.24901
R12762 VSSD.n936 VSSD.n919 2.24901
R12763 VSSD.n934 VSSD.n929 2.24901
R12764 VSSD.n949 VSSD.n945 2.24901
R12765 VSSD.n937 VSSD.n929 2.24901
R12766 VSSD.n949 VSSD.n946 2.24901
R12767 VSSD.n939 VSSD.n929 2.24901
R12768 VSSD.n949 VSSD.n947 2.24901
R12769 VSSD.n941 VSSD.n929 2.24901
R12770 VSSD.n949 VSSD.n948 2.24901
R12771 VSSD.n943 VSSD.n929 2.24901
R12772 VSSD.n950 VSSD.n949 2.24901
R12773 VSSD.n282 VSSD.n278 2.24901
R12774 VSSD.n284 VSSD.n278 2.24901
R12775 VSSD.n3205 VSSD.n294 2.24901
R12776 VSSD.n3208 VSSD.n3207 2.24901
R12777 VSSD.n3196 VSSD.n3195 2.24901
R12778 VSSD.n3201 VSSD.n291 2.24901
R12779 VSSD.n355 VSSD.n338 2.24901
R12780 VSSD.n355 VSSD.n346 2.24901
R12781 VSSD.n364 VSSD.n363 2.24901
R12782 VSSD.n3138 VSSD.n362 2.24901
R12783 VSSD.n3129 VSSD.n3128 2.24901
R12784 VSSD.n3137 VSSD.n3133 2.24901
R12785 VSSD.n3129 VSSD.n3127 2.24901
R12786 VSSD.n3137 VSSD.n3134 2.24901
R12787 VSSD.n3129 VSSD.n3126 2.24901
R12788 VSSD.n3137 VSSD.n3135 2.24901
R12789 VSSD.n3129 VSSD.n3125 2.24901
R12790 VSSD.n3137 VSSD.n3136 2.24901
R12791 VSSD.n3129 VSSD.n3124 2.24901
R12792 VSSD.n3137 VSSD.n3123 2.24901
R12793 VSSD.n1256 VSSD.n1255 2.24901
R12794 VSSD.n1255 VSSD.n1252 2.24901
R12795 VSSD.n1206 VSSD.n1205 2.24901
R12796 VSSD.n1220 VSSD.n1204 2.24901
R12797 VSSD.n1218 VSSD.n1213 2.24901
R12798 VSSD.n1233 VSSD.n1229 2.24901
R12799 VSSD.n1221 VSSD.n1213 2.24901
R12800 VSSD.n1233 VSSD.n1230 2.24901
R12801 VSSD.n1223 VSSD.n1213 2.24901
R12802 VSSD.n1233 VSSD.n1231 2.24901
R12803 VSSD.n1225 VSSD.n1213 2.24901
R12804 VSSD.n1233 VSSD.n1232 2.24901
R12805 VSSD.n1227 VSSD.n1213 2.24901
R12806 VSSD.n1234 VSSD.n1233 2.24901
R12807 VSSD.n1164 VSSD.n1112 2.24901
R12808 VSSD.n1166 VSSD.n1112 2.24901
R12809 VSSD.n1159 VSSD.n1142 2.24901
R12810 VSSD.n1153 VSSD.n1113 2.24901
R12811 VSSD.n1147 VSSD.n1121 2.24901
R12812 VSSD.n1145 VSSD.n1120 2.24901
R12813 VSSD.n675 VSSD.n674 2.24901
R12814 VSSD.n674 VSSD.n671 2.24901
R12815 VSSD.n629 VSSD.n628 2.24901
R12816 VSSD.n2881 VSSD.n627 2.24901
R12817 VSSD.n653 VSSD.n652 2.24901
R12818 VSSD.n2880 VSSD.n2876 2.24901
R12819 VSSD.n653 VSSD.n651 2.24901
R12820 VSSD.n2880 VSSD.n2877 2.24901
R12821 VSSD.n653 VSSD.n650 2.24901
R12822 VSSD.n2880 VSSD.n2878 2.24901
R12823 VSSD.n653 VSSD.n649 2.24901
R12824 VSSD.n2880 VSSD.n2879 2.24901
R12825 VSSD.n653 VSSD.n648 2.24901
R12826 VSSD.n2880 VSSD.n647 2.24901
R12827 VSSD.n587 VSSD.n583 2.24901
R12828 VSSD.n589 VSSD.n583 2.24901
R12829 VSSD.n705 VSSD.n692 2.24901
R12830 VSSD.n726 VSSD.n687 2.24901
R12831 VSSD.n697 VSSD.n688 2.24901
R12832 VSSD.n708 VSSD.n689 2.24901
R12833 VSSD.n492 VSSD.n491 2.24901
R12834 VSSD.n491 VSSD.n488 2.24901
R12835 VSSD.n446 VSSD.n445 2.24901
R12836 VSSD.n3020 VSSD.n444 2.24901
R12837 VSSD.n470 VSSD.n469 2.24901
R12838 VSSD.n3019 VSSD.n3015 2.24901
R12839 VSSD.n470 VSSD.n468 2.24901
R12840 VSSD.n3019 VSSD.n3016 2.24901
R12841 VSSD.n470 VSSD.n467 2.24901
R12842 VSSD.n3019 VSSD.n3017 2.24901
R12843 VSSD.n470 VSSD.n466 2.24901
R12844 VSSD.n3019 VSSD.n3018 2.24901
R12845 VSSD.n470 VSSD.n465 2.24901
R12846 VSSD.n3019 VSSD.n464 2.24901
R12847 VSSD.n404 VSSD.n400 2.24901
R12848 VSSD.n406 VSSD.n400 2.24901
R12849 VSSD.n521 VSSD.n508 2.24901
R12850 VSSD.n542 VSSD.n503 2.24901
R12851 VSSD.n513 VSSD.n504 2.24901
R12852 VSSD.n524 VSSD.n505 2.24901
R12853 VSSD.n2736 VSSD.n2724 2.24901
R12854 VSSD.n2740 VSSD.n2739 2.24901
R12855 VSSD.n2741 VSSD.n838 2.24901
R12856 VSSD.n2739 VSSD.n837 2.24901
R12857 VSSD.n801 VSSD.n800 2.24901
R12858 VSSD.n816 VSSD.n799 2.24901
R12859 VSSD.n814 VSSD.n809 2.24901
R12860 VSSD.n829 VSSD.n825 2.24901
R12861 VSSD.n817 VSSD.n809 2.24901
R12862 VSSD.n829 VSSD.n826 2.24901
R12863 VSSD.n819 VSSD.n809 2.24901
R12864 VSSD.n829 VSSD.n827 2.24901
R12865 VSSD.n821 VSSD.n809 2.24901
R12866 VSSD.n829 VSSD.n828 2.24901
R12867 VSSD.n823 VSSD.n809 2.24901
R12868 VSSD.n830 VSSD.n829 2.24901
R12869 VSSD.n775 VSSD.n771 2.24901
R12870 VSSD.n771 VSSD.n766 2.24901
R12871 VSSD.n2393 VSSD.n2368 2.24901
R12872 VSSD.n2395 VSSD.n2377 2.24901
R12873 VSSD.n2398 VSSD.n2397 2.24901
R12874 VSSD.n2387 VSSD.n2375 2.24901
R12875 VSSD.n1010 VSSD.n1003 2.24901
R12876 VSSD.n1011 VSSD.n1010 2.24901
R12877 VSSD.n2323 VSSD.n2308 2.24901
R12878 VSSD.n2319 VSSD.n2309 2.24901
R12879 VSSD.n1038 VSSD.n1037 2.24901
R12880 VSSD.n2318 VSSD.n2314 2.24901
R12881 VSSD.n1038 VSSD.n1036 2.24901
R12882 VSSD.n2318 VSSD.n2315 2.24901
R12883 VSSD.n1038 VSSD.n1035 2.24901
R12884 VSSD.n2318 VSSD.n2316 2.24901
R12885 VSSD.n1038 VSSD.n1034 2.24901
R12886 VSSD.n2318 VSSD.n2317 2.24901
R12887 VSSD.n1038 VSSD.n1033 2.24901
R12888 VSSD.n2318 VSSD.n1032 2.24901
R12889 VSSD.n1050 VSSD.n1046 2.24901
R12890 VSSD.n1052 VSSD.n1046 2.24901
R12891 VSSD.n2199 VSSD.n2174 2.24901
R12892 VSSD.n2201 VSSD.n2183 2.24901
R12893 VSSD.n2204 VSSD.n2203 2.24901
R12894 VSSD.n2193 VSSD.n2181 2.24901
R12895 VSSD.n1684 VSSD.n1672 2.24901
R12896 VSSD.n1688 VSSD.n1687 2.24901
R12897 VSSD.n1689 VSSD.n1635 2.24901
R12898 VSSD.n1687 VSSD.n1634 2.24901
R12899 VSSD.n1598 VSSD.n1597 2.24901
R12900 VSSD.n1613 VSSD.n1596 2.24901
R12901 VSSD.n1611 VSSD.n1606 2.24901
R12902 VSSD.n1626 VSSD.n1622 2.24901
R12903 VSSD.n1614 VSSD.n1606 2.24901
R12904 VSSD.n1626 VSSD.n1623 2.24901
R12905 VSSD.n1616 VSSD.n1606 2.24901
R12906 VSSD.n1626 VSSD.n1624 2.24901
R12907 VSSD.n1618 VSSD.n1606 2.24901
R12908 VSSD.n1626 VSSD.n1625 2.24901
R12909 VSSD.n1620 VSSD.n1606 2.24901
R12910 VSSD.n1627 VSSD.n1626 2.24901
R12911 VSSD.n1902 VSSD.n1488 2.24901
R12912 VSSD.n1491 VSSD.n1490 2.24901
R12913 VSSD.n1482 VSSD.n1481 2.24901
R12914 VSSD.n1496 VSSD.n1480 2.24901
R12915 VSSD.n1282 VSSD.n1273 2.24901
R12916 VSSD.n1284 VSSD.n1273 2.24901
R12917 VSSD.n1981 VSSD.n1968 2.24901
R12918 VSSD.n2002 VSSD.n1963 2.24901
R12919 VSSD.n1973 VSSD.n1964 2.24901
R12920 VSSD.n1984 VSSD.n1965 2.24901
R12921 VSSD.n268 VSSD.n267 2.24901
R12922 VSSD.n267 VSSD.n264 2.24901
R12923 VSSD.n3309 VSSD.n3308 2.24901
R12924 VSSD.n3313 VSSD.n243 2.24901
R12925 VSSD.n1866 VSSD.n1865 2.24901
R12926 VSSD.n1866 VSSD.n1523 2.24901
R12927 VSSD.n2710 VSSD.n2709 2.24901
R12928 VSSD.n2710 VSSD.n863 2.24901
R12929 VSSD.n3540 VSSD.n3539 2.24901
R12930 VSSD.n3540 VSSD.n108 2.24901
R12931 VSSD.n3658 VSSD.n3657 2.24901
R12932 VSSD.n3658 VSSD.n13 2.24901
R12933 VSSD.n2622 VSSD.n2621 2.24901
R12934 VSSD.n2621 VSSD.n957 2.24901
R12935 VSSD.n3257 VSSD.n3256 2.24901
R12936 VSSD.n3257 VSSD.n3255 2.24901
R12937 VSSD.n3153 VSSD.n336 2.24901
R12938 VSSD.n3153 VSSD.n335 2.24901
R12939 VSSD.n2033 VSSD.n1251 2.24901
R12940 VSSD.n2033 VSSD.n1240 2.24901
R12941 VSSD.n2052 VSSD.n2051 2.24901
R12942 VSSD.n2052 VSSD.n2050 2.24901
R12943 VSSD.n2866 VSSD.n670 2.24901
R12944 VSSD.n2866 VSSD.n659 2.24901
R12945 VSSD.n2891 VSSD.n2890 2.24901
R12946 VSSD.n2891 VSSD.n2889 2.24901
R12947 VSSD.n3005 VSSD.n487 2.24901
R12948 VSSD.n3005 VSSD.n476 2.24901
R12949 VSSD.n3030 VSSD.n3029 2.24901
R12950 VSSD.n3030 VSSD.n3028 2.24901
R12951 VSSD.n2814 VSSD.n2813 2.24901
R12952 VSSD.n2814 VSSD.n764 2.24901
R12953 VSSD.n2338 VSSD.n1002 2.24901
R12954 VSSD.n2338 VSSD.n1001 2.24901
R12955 VSSD.n2256 VSSD.n2255 2.24901
R12956 VSSD.n2256 VSSD.n2254 2.24901
R12957 VSSD.n1935 VSSD.n1934 2.24901
R12958 VSSD.n1935 VSSD.n1269 2.24901
R12959 VSSD.n3298 VSSD.n263 2.24901
R12960 VSSD.n3298 VSSD.n252 2.24901
R12961 VSSD.n2682 VSSD.n897 2.24868
R12962 VSSD.n2655 VSSD.n903 2.24868
R12963 VSSD.n2682 VSSD.n896 2.24868
R12964 VSSD.n2657 VSSD.n903 2.24868
R12965 VSSD.n2682 VSSD.n895 2.24868
R12966 VSSD.n2671 VSSD.n903 2.24868
R12967 VSSD.n2682 VSSD.n894 2.24868
R12968 VSSD.n912 VSSD.n903 2.24868
R12969 VSSD.n2673 VSSD.n901 2.24868
R12970 VSSD.n2682 VSSD.n2681 2.24868
R12971 VSSD.n3630 VSSD.n47 2.24868
R12972 VSSD.n3603 VSSD.n53 2.24868
R12973 VSSD.n3630 VSSD.n46 2.24868
R12974 VSSD.n3605 VSSD.n53 2.24868
R12975 VSSD.n3630 VSSD.n45 2.24868
R12976 VSSD.n3619 VSSD.n53 2.24868
R12977 VSSD.n3630 VSSD.n44 2.24868
R12978 VSSD.n62 VSSD.n53 2.24868
R12979 VSSD.n3621 VSSD.n51 2.24868
R12980 VSSD.n3630 VSSD.n3629 2.24868
R12981 VSSD.n3239 VSSD.n308 2.24868
R12982 VSSD.n3212 VSSD.n314 2.24868
R12983 VSSD.n3239 VSSD.n307 2.24868
R12984 VSSD.n3214 VSSD.n314 2.24868
R12985 VSSD.n3239 VSSD.n306 2.24868
R12986 VSSD.n3228 VSSD.n314 2.24868
R12987 VSSD.n3239 VSSD.n305 2.24868
R12988 VSSD.n323 VSSD.n314 2.24868
R12989 VSSD.n3230 VSSD.n312 2.24868
R12990 VSSD.n3239 VSSD.n3238 2.24868
R12991 VSSD.n1199 VSSD.n1110 2.24868
R12992 VSSD.n2095 VSSD.n1184 2.24868
R12993 VSSD.n2070 VSSD.n2068 2.24868
R12994 VSSD.n2095 VSSD.n1185 2.24868
R12995 VSSD.n2070 VSSD.n2067 2.24868
R12996 VSSD.n2095 VSSD.n1186 2.24868
R12997 VSSD.n2071 VSSD.n2070 2.24868
R12998 VSSD.n2095 VSSD.n1187 2.24868
R12999 VSSD.n2070 VSSD.n1189 2.24868
R13000 VSSD.n2095 VSSD.n2094 2.24868
R13001 VSSD.n622 VSSD.n581 2.24868
R13002 VSSD.n2934 VSSD.n607 2.24868
R13003 VSSD.n2909 VSSD.n2907 2.24868
R13004 VSSD.n2934 VSSD.n608 2.24868
R13005 VSSD.n2909 VSSD.n2906 2.24868
R13006 VSSD.n2934 VSSD.n609 2.24868
R13007 VSSD.n2910 VSSD.n2909 2.24868
R13008 VSSD.n2934 VSSD.n610 2.24868
R13009 VSSD.n2909 VSSD.n612 2.24868
R13010 VSSD.n2934 VSSD.n2933 2.24868
R13011 VSSD.n439 VSSD.n398 2.24868
R13012 VSSD.n3073 VSSD.n424 2.24868
R13013 VSSD.n3048 VSSD.n3046 2.24868
R13014 VSSD.n3073 VSSD.n425 2.24868
R13015 VSSD.n3048 VSSD.n3045 2.24868
R13016 VSSD.n3073 VSSD.n426 2.24868
R13017 VSSD.n3049 VSSD.n3048 2.24868
R13018 VSSD.n3073 VSSD.n427 2.24868
R13019 VSSD.n3048 VSSD.n429 2.24868
R13020 VSSD.n3073 VSSD.n3072 2.24868
R13021 VSSD.n2803 VSSD.n795 2.24868
R13022 VSSD.n2780 VSSD.n790 2.24868
R13023 VSSD.n2768 VSSD.n2767 2.24868
R13024 VSSD.n2757 VSSD.n790 2.24868
R13025 VSSD.n2768 VSSD.n2766 2.24868
R13026 VSSD.n2759 VSSD.n790 2.24868
R13027 VSSD.n2768 VSSD.n2765 2.24868
R13028 VSSD.n2761 VSSD.n790 2.24868
R13029 VSSD.n2768 VSSD.n2764 2.24868
R13030 VSSD.n2763 VSSD.n790 2.24868
R13031 VSSD.n1085 VSSD.n1044 2.24868
R13032 VSSD.n2299 VSSD.n1070 2.24868
R13033 VSSD.n2274 VSSD.n2272 2.24868
R13034 VSSD.n2299 VSSD.n1071 2.24868
R13035 VSSD.n2274 VSSD.n2271 2.24868
R13036 VSSD.n2299 VSSD.n1072 2.24868
R13037 VSSD.n2275 VSSD.n2274 2.24868
R13038 VSSD.n2299 VSSD.n1073 2.24868
R13039 VSSD.n2274 VSSD.n1075 2.24868
R13040 VSSD.n2299 VSSD.n2298 2.24868
R13041 VSSD.n1824 VSSD.n1823 2.24868
R13042 VSSD.n1570 VSSD.n1566 2.24868
R13043 VSSD.n1824 VSSD.n1822 2.24868
R13044 VSSD.n1570 VSSD.n1567 2.24868
R13045 VSSD.n1824 VSSD.n1821 2.24868
R13046 VSSD.n1570 VSSD.n1568 2.24868
R13047 VSSD.n1824 VSSD.n1820 2.24868
R13048 VSSD.n1570 VSSD.n1569 2.24868
R13049 VSSD.n1836 VSSD.n1819 2.24868
R13050 VSSD.n1824 VSSD.n1565 2.24868
R13051 VSSD.n1952 VSSD.n1290 2.24868
R13052 VSSD.n1305 VSSD.n1291 2.24868
R13053 VSSD.n1306 VSSD.n1293 2.24868
R13054 VSSD.n1308 VSSD.n1291 2.24868
R13055 VSSD.n1309 VSSD.n1293 2.24868
R13056 VSSD.n1311 VSSD.n1291 2.24868
R13057 VSSD.n1312 VSSD.n1293 2.24868
R13058 VSSD.n1314 VSSD.n1291 2.24868
R13059 VSSD.n1315 VSSD.n1293 2.24868
R13060 VSSD.n1317 VSSD.n1291 2.24868
R13061 VSSD.n1893 VSSD.n1891 2.2479
R13062 VSSD.n1893 VSSD.n1890 2.2479
R13063 VSSD.n1893 VSSD.n1889 2.2479
R13064 VSSD.n1894 VSSD.n1893 2.2479
R13065 VSSD.n1888 VSSD.n1887 2.2479
R13066 VSSD.n1899 VSSD.n1898 2.2479
R13067 VSSD.n3567 VSSD.n3565 2.2479
R13068 VSSD.n3567 VSSD.n3564 2.2479
R13069 VSSD.n3567 VSSD.n3563 2.2479
R13070 VSSD.n3568 VSSD.n3567 2.2479
R13071 VSSD.n3562 VSSD.n3561 2.2479
R13072 VSSD.n3573 VSSD.n3572 2.2479
R13073 VSSD.n973 VSSD.n972 2.2479
R13074 VSSD.n973 VSSD.n971 2.2479
R13075 VSSD.n2624 VSSD.n973 2.2479
R13076 VSSD.n968 VSSD.n967 2.2479
R13077 VSSD.n968 VSSD.n966 2.2479
R13078 VSSD.n2628 VSSD.n964 2.2479
R13079 VSSD.n3152 VSSD.n341 2.2479
R13080 VSSD.n3152 VSSD.n340 2.2479
R13081 VSSD.n3152 VSSD.n339 2.2479
R13082 VSSD.n353 VSSD.n345 2.2479
R13083 VSSD.n349 VSSD.n345 2.2479
R13084 VSSD.n3148 VSSD.n343 2.2479
R13085 VSSD.n2034 VSSD.n1248 2.2479
R13086 VSSD.n2034 VSSD.n1258 2.2479
R13087 VSSD.n2034 VSSD.n1257 2.2479
R13088 VSSD.n1254 VSSD.n1250 2.2479
R13089 VSSD.n1254 VSSD.n1253 2.2479
R13090 VSSD.n2038 VSSD.n1245 2.2479
R13091 VSSD.n2867 VSSD.n667 2.2479
R13092 VSSD.n2867 VSSD.n677 2.2479
R13093 VSSD.n2867 VSSD.n676 2.2479
R13094 VSSD.n673 VSSD.n669 2.2479
R13095 VSSD.n673 VSSD.n672 2.2479
R13096 VSSD.n2871 VSSD.n664 2.2479
R13097 VSSD.n3006 VSSD.n484 2.2479
R13098 VSSD.n3006 VSSD.n494 2.2479
R13099 VSSD.n3006 VSSD.n493 2.2479
R13100 VSSD.n490 VSSD.n486 2.2479
R13101 VSSD.n490 VSSD.n489 2.2479
R13102 VSSD.n3010 VSSD.n481 2.2479
R13103 VSSD.n2737 VSSD.n2735 2.2479
R13104 VSSD.n2737 VSSD.n2734 2.2479
R13105 VSSD.n2737 VSSD.n2733 2.2479
R13106 VSSD.n2738 VSSD.n2737 2.2479
R13107 VSSD.n2732 VSSD.n2731 2.2479
R13108 VSSD.n2743 VSSD.n2742 2.2479
R13109 VSSD.n2337 VSSD.n1006 2.2479
R13110 VSSD.n2337 VSSD.n1005 2.2479
R13111 VSSD.n2337 VSSD.n1004 2.2479
R13112 VSSD.n2331 VSSD.n1009 2.2479
R13113 VSSD.n1015 VSSD.n1009 2.2479
R13114 VSSD.n2335 VSSD.n2334 2.2479
R13115 VSSD.n1685 VSSD.n1683 2.2479
R13116 VSSD.n1685 VSSD.n1682 2.2479
R13117 VSSD.n1685 VSSD.n1681 2.2479
R13118 VSSD.n1686 VSSD.n1685 2.2479
R13119 VSSD.n1680 VSSD.n1679 2.2479
R13120 VSSD.n1691 VSSD.n1690 2.2479
R13121 VSSD.n3299 VSSD.n260 2.2479
R13122 VSSD.n3299 VSSD.n270 2.2479
R13123 VSSD.n3299 VSSD.n269 2.2479
R13124 VSSD.n266 VSSD.n262 2.2479
R13125 VSSD.n266 VSSD.n265 2.2479
R13126 VSSD.n3303 VSSD.n257 2.2479
R13127 VSSD.n1494 VSSD.n1478 2.24712
R13128 VSSD.n1495 VSSD.n1478 2.24712
R13129 VSSD.n1904 VSSD.n1477 2.24712
R13130 VSSD.n1905 VSSD.n1904 2.24712
R13131 VSSD.n1904 VSSD.n1903 2.24712
R13132 VSSD.n1487 VSSD.n1479 2.24712
R13133 VSSD.n1492 VSSD.n1479 2.24712
R13134 VSSD.n1486 VSSD.n1476 2.24712
R13135 VSSD.n1489 VSSD.n1476 2.24712
R13136 VSSD.n1864 VSSD.n1528 2.24702
R13137 VSSD.n1864 VSSD.n1527 2.24702
R13138 VSSD.n1864 VSSD.n1526 2.24702
R13139 VSSD.n1843 VSSD.n1524 2.24702
R13140 VSSD.n1845 VSSD.n1524 2.24702
R13141 VSSD.n1860 VSSD.n1524 2.24702
R13142 VSSD.n1532 VSSD.n1531 2.24702
R13143 VSSD.n1714 VSSD.n1712 2.24702
R13144 VSSD.n1714 VSSD.n1711 2.24702
R13145 VSSD.n1714 VSSD.n1710 2.24702
R13146 VSSD.n1714 VSSD.n1549 2.24702
R13147 VSSD.n1708 VSSD.n1707 2.24702
R13148 VSSD.n1708 VSSD.n1706 2.24702
R13149 VSSD.n1708 VSSD.n1705 2.24702
R13150 VSSD.n1708 VSSD.n1550 2.24702
R13151 VSSD.n1842 VSSD.n1539 2.24702
R13152 VSSD.n2708 VSSD.n868 2.24702
R13153 VSSD.n2708 VSSD.n867 2.24702
R13154 VSSD.n2708 VSSD.n866 2.24702
R13155 VSSD.n2687 VSSD.n864 2.24702
R13156 VSSD.n2689 VSSD.n864 2.24702
R13157 VSSD.n2691 VSSD.n864 2.24702
R13158 VSSD.n872 VSSD.n871 2.24702
R13159 VSSD.n2649 VSSD.n2647 2.24702
R13160 VSSD.n2649 VSSD.n2646 2.24702
R13161 VSSD.n2649 VSSD.n2645 2.24702
R13162 VSSD.n2649 VSSD.n889 2.24702
R13163 VSSD.n2643 VSSD.n2642 2.24702
R13164 VSSD.n2643 VSSD.n2641 2.24702
R13165 VSSD.n2643 VSSD.n2640 2.24702
R13166 VSSD.n2643 VSSD.n890 2.24702
R13167 VSSD.n2686 VSSD.n879 2.24702
R13168 VSSD.n3538 VSSD.n113 2.24702
R13169 VSSD.n3538 VSSD.n112 2.24702
R13170 VSSD.n3538 VSSD.n111 2.24702
R13171 VSSD.n3517 VSSD.n109 2.24702
R13172 VSSD.n3519 VSSD.n109 2.24702
R13173 VSSD.n3534 VSSD.n109 2.24702
R13174 VSSD.n117 VSSD.n116 2.24702
R13175 VSSD.n3507 VSSD.n3505 2.24702
R13176 VSSD.n3507 VSSD.n3504 2.24702
R13177 VSSD.n3507 VSSD.n3503 2.24702
R13178 VSSD.n3507 VSSD.n134 2.24702
R13179 VSSD.n3501 VSSD.n3500 2.24702
R13180 VSSD.n3501 VSSD.n3499 2.24702
R13181 VSSD.n3501 VSSD.n3498 2.24702
R13182 VSSD.n3501 VSSD.n135 2.24702
R13183 VSSD.n3516 VSSD.n124 2.24702
R13184 VSSD.n3656 VSSD.n18 2.24702
R13185 VSSD.n3656 VSSD.n17 2.24702
R13186 VSSD.n3656 VSSD.n16 2.24702
R13187 VSSD.n3635 VSSD.n14 2.24702
R13188 VSSD.n3637 VSSD.n14 2.24702
R13189 VSSD.n3639 VSSD.n14 2.24702
R13190 VSSD.n22 VSSD.n21 2.24702
R13191 VSSD.n3597 VSSD.n3595 2.24702
R13192 VSSD.n3597 VSSD.n3594 2.24702
R13193 VSSD.n3597 VSSD.n3593 2.24702
R13194 VSSD.n3597 VSSD.n39 2.24702
R13195 VSSD.n3591 VSSD.n3590 2.24702
R13196 VSSD.n3591 VSSD.n3589 2.24702
R13197 VSSD.n3591 VSSD.n3588 2.24702
R13198 VSSD.n3591 VSSD.n40 2.24702
R13199 VSSD.n3634 VSSD.n29 2.24702
R13200 VSSD.n3252 VSSD.n281 2.24702
R13201 VSSD.n3246 VSSD.n281 2.24702
R13202 VSSD.n3249 VSSD.n281 2.24702
R13203 VSSD.n3244 VSSD.n280 2.24702
R13204 VSSD.n3247 VSSD.n280 2.24702
R13205 VSSD.n3269 VSSD.n280 2.24702
R13206 VSSD.n285 VSSD.n279 2.24702
R13207 VSSD.n3206 VSSD.n3204 2.24702
R13208 VSSD.n3206 VSSD.n3203 2.24702
R13209 VSSD.n3206 VSSD.n3202 2.24702
R13210 VSSD.n3206 VSSD.n300 2.24702
R13211 VSSD.n3200 VSSD.n3199 2.24702
R13212 VSSD.n3200 VSSD.n3198 2.24702
R13213 VSSD.n3200 VSSD.n3197 2.24702
R13214 VSSD.n3200 VSSD.n301 2.24702
R13215 VSSD.n3243 VSSD.n290 2.24702
R13216 VSSD.n2055 VSSD.n1163 2.24702
R13217 VSSD.n1173 VSSD.n1163 2.24702
R13218 VSSD.n1176 VSSD.n1163 2.24702
R13219 VSSD.n1172 VSSD.n1162 2.24702
R13220 VSSD.n1175 VSSD.n1162 2.24702
R13221 VSSD.n1179 VSSD.n1162 2.24702
R13222 VSSD.n1178 VSSD.n1161 2.24702
R13223 VSSD.n1158 VSSD.n1157 2.24702
R13224 VSSD.n1158 VSSD.n1156 2.24702
R13225 VSSD.n1158 VSSD.n1155 2.24702
R13226 VSSD.n1158 VSSD.n1154 2.24702
R13227 VSSD.n1152 VSSD.n1151 2.24702
R13228 VSSD.n1152 VSSD.n1150 2.24702
R13229 VSSD.n1152 VSSD.n1149 2.24702
R13230 VSSD.n1152 VSSD.n1148 2.24702
R13231 VSSD.n1144 VSSD.n1143 2.24702
R13232 VSSD.n2894 VSSD.n586 2.24702
R13233 VSSD.n596 VSSD.n586 2.24702
R13234 VSSD.n599 VSSD.n586 2.24702
R13235 VSSD.n595 VSSD.n585 2.24702
R13236 VSSD.n598 VSSD.n585 2.24702
R13237 VSSD.n602 VSSD.n585 2.24702
R13238 VSSD.n601 VSSD.n584 2.24702
R13239 VSSD.n706 VSSD.n704 2.24702
R13240 VSSD.n706 VSSD.n703 2.24702
R13241 VSSD.n707 VSSD.n706 2.24702
R13242 VSSD.n706 VSSD.n696 2.24702
R13243 VSSD.n701 VSSD.n700 2.24702
R13244 VSSD.n701 VSSD.n699 2.24702
R13245 VSSD.n701 VSSD.n698 2.24702
R13246 VSSD.n702 VSSD.n701 2.24702
R13247 VSSD.n725 VSSD.n724 2.24702
R13248 VSSD.n3033 VSSD.n403 2.24702
R13249 VSSD.n413 VSSD.n403 2.24702
R13250 VSSD.n416 VSSD.n403 2.24702
R13251 VSSD.n412 VSSD.n402 2.24702
R13252 VSSD.n415 VSSD.n402 2.24702
R13253 VSSD.n419 VSSD.n402 2.24702
R13254 VSSD.n418 VSSD.n401 2.24702
R13255 VSSD.n522 VSSD.n520 2.24702
R13256 VSSD.n522 VSSD.n519 2.24702
R13257 VSSD.n523 VSSD.n522 2.24702
R13258 VSSD.n522 VSSD.n512 2.24702
R13259 VSSD.n517 VSSD.n516 2.24702
R13260 VSSD.n517 VSSD.n515 2.24702
R13261 VSSD.n517 VSSD.n514 2.24702
R13262 VSSD.n518 VSSD.n517 2.24702
R13263 VSSD.n541 VSSD.n540 2.24702
R13264 VSSD.n2812 VSSD.n769 2.24702
R13265 VSSD.n2812 VSSD.n768 2.24702
R13266 VSSD.n2812 VSSD.n767 2.24702
R13267 VSSD.n783 VSSD.n765 2.24702
R13268 VSSD.n785 VSSD.n765 2.24702
R13269 VSSD.n778 VSSD.n765 2.24702
R13270 VSSD.n773 VSSD.n772 2.24702
R13271 VSSD.n2394 VSSD.n2392 2.24702
R13272 VSSD.n2394 VSSD.n2391 2.24702
R13273 VSSD.n2394 VSSD.n2386 2.24702
R13274 VSSD.n2394 VSSD.n2378 2.24702
R13275 VSSD.n2396 VSSD.n2385 2.24702
R13276 VSSD.n2396 VSSD.n2384 2.24702
R13277 VSSD.n2396 VSSD.n2383 2.24702
R13278 VSSD.n2396 VSSD.n2382 2.24702
R13279 VSSD.n2389 VSSD.n2380 2.24702
R13280 VSSD.n2259 VSSD.n1049 2.24702
R13281 VSSD.n1059 VSSD.n1049 2.24702
R13282 VSSD.n1062 VSSD.n1049 2.24702
R13283 VSSD.n1058 VSSD.n1048 2.24702
R13284 VSSD.n1061 VSSD.n1048 2.24702
R13285 VSSD.n1065 VSSD.n1048 2.24702
R13286 VSSD.n1064 VSSD.n1047 2.24702
R13287 VSSD.n2200 VSSD.n2198 2.24702
R13288 VSSD.n2200 VSSD.n2197 2.24702
R13289 VSSD.n2200 VSSD.n2192 2.24702
R13290 VSSD.n2200 VSSD.n2184 2.24702
R13291 VSSD.n2202 VSSD.n2191 2.24702
R13292 VSSD.n2202 VSSD.n2190 2.24702
R13293 VSSD.n2202 VSSD.n2189 2.24702
R13294 VSSD.n2202 VSSD.n2188 2.24702
R13295 VSSD.n2195 VSSD.n2186 2.24702
R13296 VSSD.n1281 VSSD.n1280 2.24702
R13297 VSSD.n1281 VSSD.n1279 2.24702
R13298 VSSD.n1281 VSSD.n1278 2.24702
R13299 VSSD.n1276 VSSD.n1275 2.24702
R13300 VSSD.n1276 VSSD.n1274 2.24702
R13301 VSSD.n1285 VSSD.n1276 2.24702
R13302 VSSD.n1960 VSSD.n1265 2.24702
R13303 VSSD.n1982 VSSD.n1980 2.24702
R13304 VSSD.n1982 VSSD.n1979 2.24702
R13305 VSSD.n1983 VSSD.n1982 2.24702
R13306 VSSD.n1982 VSSD.n1972 2.24702
R13307 VSSD.n1977 VSSD.n1976 2.24702
R13308 VSSD.n1977 VSSD.n1975 2.24702
R13309 VSSD.n1977 VSSD.n1974 2.24702
R13310 VSSD.n1978 VSSD.n1977 2.24702
R13311 VSSD.n2001 VSSD.n2000 2.24702
R13312 VSSD.n1862 VSSD.n1522 2.24702
R13313 VSSD.n2706 VSSD.n862 2.24702
R13314 VSSD.n3536 VSSD.n107 2.24702
R13315 VSSD.n3654 VSSD.n12 2.24702
R13316 VSSD.n3271 VSSD.n289 2.24702
R13317 VSSD.n2099 VSSD.n1171 2.24702
R13318 VSSD.n2938 VSSD.n594 2.24702
R13319 VSSD.n3077 VSSD.n411 2.24702
R13320 VSSD.n2810 VSSD.n763 2.24702
R13321 VSSD.n2303 VSSD.n1057 2.24702
R13322 VSSD.n1958 VSSD.n1287 2.24702
R13323 VSSD.n1883 VSSD.n1882 2.04125
R13324 VSSD.n3557 VSSD.n3556 2.04125
R13325 VSSD.n975 VSSD.n974 2.04125
R13326 VSSD.n347 VSSD.n337 2.04125
R13327 VSSD.n2032 VSSD.n2031 2.04125
R13328 VSSD.n2865 VSSD.n2864 2.04125
R13329 VSSD.n3004 VSSD.n3003 2.04125
R13330 VSSD.n2727 VSSD.n2726 2.04125
R13331 VSSD.n1013 VSSD.n1000 2.04125
R13332 VSSD.n1675 VSSD.n1674 2.04125
R13333 VSSD.n3297 VSSD.n3296 2.04125
R13334 VSSD.n3326 VSSD.n3317 1.88681
R13335 VSSD.n3169 VSSD.n0 1.8708
R13336 VSSD.n3105 VSSD.n386 1.8708
R13337 VSSD.n2830 VSSD.n739 1.8708
R13338 VSSD.n2961 VSSD.n2960 1.8708
R13339 VSSD.n2135 VSSD.n2106 1.8708
R13340 VSSD.n1739 VSSD.n1107 1.8708
R13341 VSSD.n2234 VSSD.n1090 1.8708
R13342 VSSD.n2474 VSSD.n2421 1.8708
R13343 VSSD.n2512 VSSD.n2489 1.8708
R13344 VSSD.n2566 VSSD.n985 1.8708
R13345 VSSD.n3171 VSSD.n0 1.23706
R13346 VSSD.n395 VSSD.n386 1.23706
R13347 VSSD.n2830 VSSD.n740 1.23706
R13348 VSSD.n2960 VSSD.n577 1.23706
R13349 VSSD.n2135 VSSD.n2105 1.23706
R13350 VSSD.n1741 VSSD.n1107 1.23706
R13351 VSSD.n2234 VSSD.n1091 1.23706
R13352 VSSD.n2474 VSSD.n2422 1.23706
R13353 VSSD.n2566 VSSD.n2565 1.23706
R13354 VSSD.n2512 VSSD.n2490 1.23706
R13355 VSSD.n3669 VSSD.n3668 1.0405
R13356 VSSD.t442 VSSD.n3669 1.0405
R13357 VSSD.n4 VSSD.n1 1.0405
R13358 VSSD.n6 VSSD.n4 1.0405
R13359 VSSD.n3667 VSSD.n5 1.0405
R13360 VSSD.n3666 VSSD.n5 1.0405
R13361 VSSD.n2500 VSSD.n2494 1.0405
R13362 VSSD.n2494 VSSD.t158 1.0405
R13363 VSSD.n2499 VSSD.n2498 1.0405
R13364 VSSD.n2498 VSSD.n2497 1.0405
R13365 VSSD.n2502 VSSD.n2501 1.0405
R13366 VSSD.n2503 VSSD.n2502 1.0405
R13367 VSSD.n2495 VSSD.n2491 1.0405
R13368 VSSD.n2495 VSSD.t158 1.0405
R13369 VSSD.n2510 VSSD.n2509 1.0405
R13370 VSSD.t578 VSSD.n2510 1.0405
R13371 VSSD.n2492 VSSD.n2489 1.0405
R13372 VSSD.n2504 VSSD.n2492 1.0405
R13373 VSSD.n2508 VSSD.n2493 1.0405
R13374 VSSD.n2507 VSSD.n2493 1.0405
R13375 VSSD.n2512 VSSD.n2511 1.0405
R13376 VSSD.n2511 VSSD.t578 1.0405
R13377 VSSD.n987 VSSD.n986 1.0405
R13378 VSSD.t505 VSSD.n987 1.0405
R13379 VSSD.n2558 VSSD.n985 1.0405
R13380 VSSD.n2559 VSSD.n2558 1.0405
R13381 VSSD.n2564 VSSD.n2563 1.0405
R13382 VSSD.n2563 VSSD.n2562 1.0405
R13383 VSSD.n2566 VSSD.n984 1.0405
R13384 VSSD.t505 VSSD.n984 1.0405
R13385 VSSD.n2553 VSSD.n991 1.0405
R13386 VSSD.n991 VSSD.t535 1.0405
R13387 VSSD.n2552 VSSD.n2551 1.0405
R13388 VSSD.n2551 VSSD.n2550 1.0405
R13389 VSSD.n2555 VSSD.n2554 1.0405
R13390 VSSD.n2556 VSSD.n2555 1.0405
R13391 VSSD.n992 VSSD.n983 1.0405
R13392 VSSD.n992 VSSD.t535 1.0405
R13393 VSSD.n2472 VSSD.n2471 1.0405
R13394 VSSD.t192 VSSD.n2472 1.0405
R13395 VSSD.n2424 VSSD.n2421 1.0405
R13396 VSSD.n2429 VSSD.n2424 1.0405
R13397 VSSD.n2470 VSSD.n2425 1.0405
R13398 VSSD.n2469 VSSD.n2425 1.0405
R13399 VSSD.n2474 VSSD.n2473 1.0405
R13400 VSSD.n2473 VSSD.t192 1.0405
R13401 VSSD.n2232 VSSD.n2231 1.0405
R13402 VSSD.t91 VSSD.n2232 1.0405
R13403 VSSD.n1093 VSSD.n1090 1.0405
R13404 VSSD.n1095 VSSD.n1093 1.0405
R13405 VSSD.n2230 VSSD.n1094 1.0405
R13406 VSSD.n2229 VSSD.n1094 1.0405
R13407 VSSD.n2234 VSSD.n2233 1.0405
R13408 VSSD.n2233 VSSD.t91 1.0405
R13409 VSSD.n1740 VSSD.n1736 1.0405
R13410 VSSD.n1736 VSSD.t585 1.0405
R13411 VSSD.n1743 VSSD.n1742 1.0405
R13412 VSSD.n1744 VSSD.n1743 1.0405
R13413 VSSD.n1739 VSSD.n1738 1.0405
R13414 VSSD.n1738 VSSD.n1109 1.0405
R13415 VSSD.n1737 VSSD.n1107 1.0405
R13416 VSSD.n1737 VSSD.t585 1.0405
R13417 VSSD.n1731 VSSD.n1729 1.0405
R13418 VSSD.n1729 VSSD.t60 1.0405
R13419 VSSD.n1773 VSSD.n1772 1.0405
R13420 VSSD.n1772 VSSD.n1771 1.0405
R13421 VSSD.n1779 VSSD.n1778 1.0405
R13422 VSSD.n1780 VSSD.n1779 1.0405
R13423 VSSD.n1776 VSSD.n1730 1.0405
R13424 VSSD.n1730 VSSD.t60 1.0405
R13425 VSSD.n1795 VSSD.n1794 1.0405
R13426 VSSD.t387 VSSD.n1795 1.0405
R13427 VSSD.n1792 VSSD.n1727 1.0405
R13428 VSSD.n1782 VSSD.n1727 1.0405
R13429 VSSD.n1793 VSSD.n1728 1.0405
R13430 VSSD.n1791 VSSD.n1728 1.0405
R13431 VSSD.n1797 VSSD.n1796 1.0405
R13432 VSSD.n1796 VSSD.t387 1.0405
R13433 VSSD.n1660 VSSD.n1654 1.0405
R13434 VSSD.n1654 VSSD.t100 1.0405
R13435 VSSD.n1659 VSSD.n1658 1.0405
R13436 VSSD.n1658 VSSD.n1657 1.0405
R13437 VSSD.n1662 VSSD.n1661 1.0405
R13438 VSSD.n1663 VSSD.n1662 1.0405
R13439 VSSD.n1655 VSSD.n1092 1.0405
R13440 VSSD.n1655 VSSD.t100 1.0405
R13441 VSSD.n2163 VSSD.n2162 1.0405
R13442 VSSD.n2164 VSSD.n2163 1.0405
R13443 VSSD.n1106 VSSD.n1104 1.0405
R13444 VSSD.n1104 VSSD.n1103 1.0405
R13445 VSSD.n2161 VSSD.n1105 1.0405
R13446 VSSD.n1105 VSSD.n1103 1.0405
R13447 VSSD.n2159 VSSD.n2158 1.0405
R13448 VSSD.n2158 VSSD.n2157 1.0405
R13449 VSSD.n2133 VSSD.n2132 1.0405
R13450 VSSD.t11 VSSD.n2133 1.0405
R13451 VSSD.n2131 VSSD.n2107 1.0405
R13452 VSSD.n2111 VSSD.n2107 1.0405
R13453 VSSD.n2108 VSSD.n2106 1.0405
R13454 VSSD.n2130 VSSD.n2108 1.0405
R13455 VSSD.n2135 VSSD.n2134 1.0405
R13456 VSSD.n2134 VSSD.t11 1.0405
R13457 VSSD.n576 VSSD.n574 1.0405
R13458 VSSD.n574 VSSD.t261 1.0405
R13459 VSSD.n2113 VSSD.n2112 1.0405
R13460 VSSD.n2114 VSSD.n2113 1.0405
R13461 VSSD.n2962 VSSD.n2961 1.0405
R13462 VSSD.n2963 VSSD.n2962 1.0405
R13463 VSSD.n2960 VSSD.n575 1.0405
R13464 VSSD.n575 VSSD.t261 1.0405
R13465 VSSD.n2121 VSSD.n2119 1.0405
R13466 VSSD.n2124 VSSD.n2119 1.0405
R13467 VSSD.n2120 VSSD.n2118 1.0405
R13468 VSSD.n2125 VSSD.n2118 1.0405
R13469 VSSD.n2126 VSSD.n2123 1.0405
R13470 VSSD.n2126 VSSD.n2125 1.0405
R13471 VSSD.n2127 VSSD.n637 1.0405
R13472 VSSD.n2128 VSSD.n2127 1.0405
R13473 VSSD.n736 VSSD.n734 1.0405
R13474 VSSD.n734 VSSD.t66 1.0405
R13475 VSSD.n2834 VSSD.n2833 1.0405
R13476 VSSD.n2835 VSSD.n2834 1.0405
R13477 VSSD.n997 VSSD.n737 1.0405
R13478 VSSD.n998 VSSD.n997 1.0405
R13479 VSSD.n2831 VSSD.n735 1.0405
R13480 VSSD.n735 VSSD.t66 1.0405
R13481 VSSD.n2828 VSSD.n2827 1.0405
R13482 VSSD.t328 VSSD.n2828 1.0405
R13483 VSSD.n742 VSSD.n739 1.0405
R13484 VSSD.n744 VSSD.n742 1.0405
R13485 VSSD.n2826 VSSD.n743 1.0405
R13486 VSSD.n2825 VSSD.n743 1.0405
R13487 VSSD.n2830 VSSD.n2829 1.0405
R13488 VSSD.n2829 VSSD.t328 1.0405
R13489 VSSD.n2419 VSSD.n2417 1.0405
R13490 VSSD.n2417 VSSD.t464 1.0405
R13491 VSSD.n2478 VSSD.n2477 1.0405
R13492 VSSD.n2479 VSSD.n2478 1.0405
R13493 VSSD.n2426 VSSD.n2420 1.0405
R13494 VSSD.n2427 VSSD.n2426 1.0405
R13495 VSSD.n2475 VSSD.n2418 1.0405
R13496 VSSD.n2418 VSSD.t464 1.0405
R13497 VSSD.n2974 VSSD.n2973 1.0405
R13498 VSSD.n2975 VSSD.n2974 1.0405
R13499 VSSD.n2970 VSSD.n573 1.0405
R13500 VSSD.n573 VSSD.n572 1.0405
R13501 VSSD.n2972 VSSD.n2969 1.0405
R13502 VSSD.n2969 VSSD.n572 1.0405
R13503 VSSD.n2968 VSSD.n454 1.0405
R13504 VSSD.n2968 VSSD.n2967 1.0405
R13505 VSSD.n3104 VSSD.n393 1.0405
R13506 VSSD.n393 VSSD.t112 1.0405
R13507 VSSD.n3103 VSSD.n3102 1.0405
R13508 VSSD.n3102 VSSD.n3101 1.0405
R13509 VSSD.n3106 VSSD.n3105 1.0405
R13510 VSSD.n3107 VSSD.n3106 1.0405
R13511 VSSD.n394 VSSD.n386 1.0405
R13512 VSSD.n394 VSSD.t112 1.0405
R13513 VSSD.n3170 VSSD.n329 1.0405
R13514 VSSD.n329 VSSD.t156 1.0405
R13515 VSSD.n3173 VSSD.n3172 1.0405
R13516 VSSD.n3174 VSSD.n3173 1.0405
R13517 VSSD.n3169 VSSD.n3168 1.0405
R13518 VSSD.n3168 VSSD.n3167 1.0405
R13519 VSSD.n389 VSSD.n388 1.0405
R13520 VSSD.n388 VSSD.n331 1.0405
R13521 VSSD.n387 VSSD.n384 1.0405
R13522 VSSD.n392 VSSD.n387 1.0405
R13523 VSSD.n391 VSSD.n390 1.0405
R13524 VSSD.n392 VSSD.n391 1.0405
R13525 VSSD.n3113 VSSD.n3112 1.0405
R13526 VSSD.n3112 VSSD.n3111 1.0405
R13527 VSSD.n330 VSSD.n0 1.0405
R13528 VSSD.n330 VSSD.t156 1.0405
R13529 VSSD.n3671 VSSD.n3670 1.0405
R13530 VSSD.n3670 VSSD.t442 1.0405
R13531 VSSD.n1863 VSSD.n1533 0.908963
R13532 VSSD.n2707 VSSD.n873 0.908963
R13533 VSSD.n3537 VSSD.n118 0.908963
R13534 VSSD.n3655 VSSD.n23 0.908963
R13535 VSSD.n3258 VSSD.n3257 0.908963
R13536 VSSD.n1142 VSSD.n1141 0.908963
R13537 VSSD.n713 VSSD.n692 0.908963
R13538 VSSD.n529 VSSD.n508 0.908963
R13539 VSSD.n2400 VSSD.n2377 0.908963
R13540 VSSD.n2206 VSSD.n2183 0.908963
R13541 VSSD.n1989 VSSD.n1968 0.908963
R13542 VSSD.n956 VSSD.n955 0.902387
R13543 VSSD.n357 VSSD.n356 0.902387
R13544 VSSD.n1239 VSSD.n1238 0.902387
R13545 VSSD.n658 VSSD.n657 0.902387
R13546 VSSD.n475 VSSD.n474 0.902387
R13547 VSSD.n1019 VSSD.n1018 0.902387
R13548 VSSD.n251 VSSD.n250 0.902387
R13549 VSSD.n3577 VSSD.n81 0.902207
R13550 VSSD.n2747 VSSD.n836 0.902207
R13551 VSSD.n1695 VSSD.n1633 0.902207
R13552 VSSD.n2629 VSSD.n955 0.901972
R13553 VSSD.n3147 VSSD.n356 0.901972
R13554 VSSD.n2039 VSSD.n1238 0.901972
R13555 VSSD.n2872 VSSD.n657 0.901972
R13556 VSSD.n3011 VSSD.n474 0.901972
R13557 VSSD.n2329 VSSD.n1018 0.901972
R13558 VSSD.n3304 VSSD.n250 0.901972
R13559 VSSD.n3577 VSSD.n3576 0.901913
R13560 VSSD.n2747 VSSD.n2746 0.901913
R13561 VSSD.n1695 VSSD.n1694 0.901913
R13562 VSSD.n1868 VSSD.n1867 0.9005
R13563 VSSD.n1858 VSSD.n1856 0.9005
R13564 VSSD.n1859 VSSD.n1855 0.9005
R13565 VSSD.n1854 VSSD.n1847 0.9005
R13566 VSSD.n1853 VSSD.n1852 0.9005
R13567 VSSD.n1851 VSSD.n1848 0.9005
R13568 VSSD.n1850 VSSD.n1849 0.9005
R13569 VSSD.n1521 VSSD.n1520 0.9005
R13570 VSSD.n1867 VSSD.n1866 0.9005
R13571 VSSD.n1535 VSSD.n1521 0.9005
R13572 VSSD.n1850 VSSD.n1844 0.9005
R13573 VSSD.n1851 VSSD.n1538 0.9005
R13574 VSSD.n1852 VSSD.n1846 0.9005
R13575 VSSD.n1847 VSSD.n1537 0.9005
R13576 VSSD.n1861 VSSD.n1859 0.9005
R13577 VSSD.n1858 VSSD.n1529 0.9005
R13578 VSSD.n1857 VSSD.n1530 0.9005
R13579 VSSD.n1825 VSSD.n1543 0.9005
R13580 VSSD.n1834 VSSD.n1544 0.9005
R13581 VSSD.n1833 VSSD.n1542 0.9005
R13582 VSSD.n1831 VSSD.n1545 0.9005
R13583 VSSD.n1829 VSSD.n1541 0.9005
R13584 VSSD.n1827 VSSD.n1546 0.9005
R13585 VSSD.n1709 VSSD.n1551 0.9005
R13586 VSSD.n1841 VSSD.n1840 0.9005
R13587 VSSD.n1703 VSSD.n1552 0.9005
R13588 VSSD.n1717 VSSD.n1716 0.9005
R13589 VSSD.n2711 VSSD.n2710 0.9005
R13590 VSSD.n875 VSSD.n861 0.9005
R13591 VSSD.n2697 VSSD.n2688 0.9005
R13592 VSSD.n2698 VSSD.n878 0.9005
R13593 VSSD.n2699 VSSD.n2690 0.9005
R13594 VSSD.n2692 VSSD.n877 0.9005
R13595 VSSD.n2705 VSSD.n2704 0.9005
R13596 VSSD.n2694 VSSD.n869 0.9005
R13597 VSSD.n2693 VSSD.n870 0.9005
R13598 VSSD.n2459 VSSD.n883 0.9005
R13599 VSSD.n2458 VSSD.n884 0.9005
R13600 VSSD.n2456 VSSD.n882 0.9005
R13601 VSSD.n2454 VSSD.n885 0.9005
R13602 VSSD.n2452 VSSD.n881 0.9005
R13603 VSSD.n2450 VSSD.n886 0.9005
R13604 VSSD.n2644 VSSD.n891 0.9005
R13605 VSSD.n2685 VSSD.n2684 0.9005
R13606 VSSD.n2638 VSSD.n892 0.9005
R13607 VSSD.n2652 VSSD.n2651 0.9005
R13608 VSSD.n2460 VSSD.n2459 0.9005
R13609 VSSD.n2458 VSSD.n2457 0.9005
R13610 VSSD.n2456 VSSD.n2455 0.9005
R13611 VSSD.n2454 VSSD.n2453 0.9005
R13612 VSSD.n2452 VSSD.n2451 0.9005
R13613 VSSD.n2450 VSSD.n2449 0.9005
R13614 VSSD.n902 VSSD.n891 0.9005
R13615 VSSD.n2684 VSSD.n2683 0.9005
R13616 VSSD.n898 VSSD.n892 0.9005
R13617 VSSD.n2653 VSSD.n2652 0.9005
R13618 VSSD.n3542 VSSD.n3541 0.9005
R13619 VSSD.n3532 VSSD.n3530 0.9005
R13620 VSSD.n3533 VSSD.n3529 0.9005
R13621 VSSD.n3528 VSSD.n3521 0.9005
R13622 VSSD.n3527 VSSD.n3526 0.9005
R13623 VSSD.n3525 VSSD.n3522 0.9005
R13624 VSSD.n3524 VSSD.n3523 0.9005
R13625 VSSD.n106 VSSD.n105 0.9005
R13626 VSSD.n3541 VSSD.n3540 0.9005
R13627 VSSD.n120 VSSD.n106 0.9005
R13628 VSSD.n3524 VSSD.n3518 0.9005
R13629 VSSD.n3525 VSSD.n123 0.9005
R13630 VSSD.n3526 VSSD.n3520 0.9005
R13631 VSSD.n3521 VSSD.n122 0.9005
R13632 VSSD.n3535 VSSD.n3533 0.9005
R13633 VSSD.n3532 VSSD.n114 0.9005
R13634 VSSD.n3531 VSSD.n115 0.9005
R13635 VSSD.n2540 VSSD.n128 0.9005
R13636 VSSD.n2539 VSSD.n129 0.9005
R13637 VSSD.n2538 VSSD.n127 0.9005
R13638 VSSD.n2531 VSSD.n130 0.9005
R13639 VSSD.n2534 VSSD.n126 0.9005
R13640 VSSD.n2533 VSSD.n131 0.9005
R13641 VSSD.n3502 VSSD.n136 0.9005
R13642 VSSD.n3515 VSSD.n3514 0.9005
R13643 VSSD.n3496 VSSD.n137 0.9005
R13644 VSSD.n3510 VSSD.n3509 0.9005
R13645 VSSD.n3511 VSSD.n3510 0.9005
R13646 VSSD.n2541 VSSD.n2540 0.9005
R13647 VSSD.n2539 VSSD.n2530 0.9005
R13648 VSSD.n2538 VSSD.n2537 0.9005
R13649 VSSD.n2536 VSSD.n2531 0.9005
R13650 VSSD.n2535 VSSD.n2534 0.9005
R13651 VSSD.n2533 VSSD.n2532 0.9005
R13652 VSSD.n138 VSSD.n136 0.9005
R13653 VSSD.n3514 VSSD.n3513 0.9005
R13654 VSSD.n3512 VSSD.n137 0.9005
R13655 VSSD.n3659 VSSD.n3658 0.9005
R13656 VSSD.n25 VSSD.n11 0.9005
R13657 VSSD.n3645 VSSD.n3636 0.9005
R13658 VSSD.n3646 VSSD.n28 0.9005
R13659 VSSD.n3647 VSSD.n3638 0.9005
R13660 VSSD.n3640 VSSD.n27 0.9005
R13661 VSSD.n3653 VSSD.n3652 0.9005
R13662 VSSD.n3642 VSSD.n19 0.9005
R13663 VSSD.n3641 VSSD.n20 0.9005
R13664 VSSD.n2594 VSSD.n33 0.9005
R13665 VSSD.n2593 VSSD.n34 0.9005
R13666 VSSD.n2591 VSSD.n32 0.9005
R13667 VSSD.n2589 VSSD.n35 0.9005
R13668 VSSD.n2587 VSSD.n31 0.9005
R13669 VSSD.n2585 VSSD.n36 0.9005
R13670 VSSD.n3592 VSSD.n41 0.9005
R13671 VSSD.n3633 VSSD.n3632 0.9005
R13672 VSSD.n3586 VSSD.n42 0.9005
R13673 VSSD.n3600 VSSD.n3599 0.9005
R13674 VSSD.n2595 VSSD.n2594 0.9005
R13675 VSSD.n2593 VSSD.n2592 0.9005
R13676 VSSD.n2591 VSSD.n2590 0.9005
R13677 VSSD.n2589 VSSD.n2588 0.9005
R13678 VSSD.n2587 VSSD.n2586 0.9005
R13679 VSSD.n2585 VSSD.n2584 0.9005
R13680 VSSD.n52 VSSD.n41 0.9005
R13681 VSSD.n3632 VSSD.n3631 0.9005
R13682 VSSD.n48 VSSD.n42 0.9005
R13683 VSSD.n3601 VSSD.n3600 0.9005
R13684 VSSD.n3660 VSSD.n3659 0.9005
R13685 VSSD.n3650 VSSD.n3642 0.9005
R13686 VSSD.n3652 VSSD.n3651 0.9005
R13687 VSSD.n3649 VSSD.n3640 0.9005
R13688 VSSD.n3648 VSSD.n3647 0.9005
R13689 VSSD.n3646 VSSD.n3643 0.9005
R13690 VSSD.n3645 VSSD.n3644 0.9005
R13691 VSSD.n11 VSSD.n10 0.9005
R13692 VSSD.n3274 VSSD.n3273 0.9005
R13693 VSSD.n277 VSSD.n276 0.9005
R13694 VSSD.n3267 VSSD.n3266 0.9005
R13695 VSSD.n3268 VSSD.n3265 0.9005
R13696 VSSD.n3264 VSSD.n3250 0.9005
R13697 VSSD.n3263 VSSD.n3262 0.9005
R13698 VSSD.n3261 VSSD.n3251 0.9005
R13699 VSSD.n3260 VSSD.n3259 0.9005
R13700 VSSD.n3254 VSSD.n3253 0.9005
R13701 VSSD.n3260 VSSD.n3245 0.9005
R13702 VSSD.n3261 VSSD.n288 0.9005
R13703 VSSD.n3262 VSSD.n3248 0.9005
R13704 VSSD.n3250 VSSD.n287 0.9005
R13705 VSSD.n3270 VSSD.n3268 0.9005
R13706 VSSD.n3267 VSSD.n286 0.9005
R13707 VSSD.n278 VSSD.n277 0.9005
R13708 VSSD.n3273 VSSD.n3272 0.9005
R13709 VSSD.n376 VSSD.n294 0.9005
R13710 VSSD.n375 VSSD.n295 0.9005
R13711 VSSD.n373 VSSD.n293 0.9005
R13712 VSSD.n371 VSSD.n296 0.9005
R13713 VSSD.n369 VSSD.n292 0.9005
R13714 VSSD.n367 VSSD.n297 0.9005
R13715 VSSD.n3201 VSSD.n302 0.9005
R13716 VSSD.n3242 VSSD.n3241 0.9005
R13717 VSSD.n3195 VSSD.n303 0.9005
R13718 VSSD.n3209 VSSD.n3208 0.9005
R13719 VSSD.n377 VSSD.n376 0.9005
R13720 VSSD.n375 VSSD.n374 0.9005
R13721 VSSD.n373 VSSD.n372 0.9005
R13722 VSSD.n371 VSSD.n370 0.9005
R13723 VSSD.n369 VSSD.n368 0.9005
R13724 VSSD.n367 VSSD.n366 0.9005
R13725 VSSD.n313 VSSD.n302 0.9005
R13726 VSSD.n3241 VSSD.n3240 0.9005
R13727 VSSD.n309 VSSD.n303 0.9005
R13728 VSSD.n3210 VSSD.n3209 0.9005
R13729 VSSD.n2053 VSSD.n2049 0.9005
R13730 VSSD.n2057 VSSD.n2054 0.9005
R13731 VSSD.n2059 VSSD.n2058 0.9005
R13732 VSSD.n2061 VSSD.n2060 0.9005
R13733 VSSD.n2062 VSSD.n1195 0.9005
R13734 VSSD.n2064 VSSD.n2063 0.9005
R13735 VSSD.n2069 VSSD.n1180 0.9005
R13736 VSSD.n2097 VSSD.n2096 0.9005
R13737 VSSD.n1182 VSSD.n1111 0.9005
R13738 VSSD.n2102 VSSD.n2101 0.9005
R13739 VSSD.n2053 VSSD.n2052 0.9005
R13740 VSSD.n2057 VSSD.n2056 0.9005
R13741 VSSD.n2059 VSSD.n1169 0.9005
R13742 VSSD.n2061 VSSD.n1174 0.9005
R13743 VSSD.n2062 VSSD.n1168 0.9005
R13744 VSSD.n2063 VSSD.n1177 0.9005
R13745 VSSD.n1180 VSSD.n1167 0.9005
R13746 VSSD.n2098 VSSD.n2097 0.9005
R13747 VSSD.n1112 VSSD.n1111 0.9005
R13748 VSSD.n2101 VSSD.n2100 0.9005
R13749 VSSD.n1122 VSSD.n1117 0.9005
R13750 VSSD.n1139 VSSD.n1118 0.9005
R13751 VSSD.n1138 VSSD.n1116 0.9005
R13752 VSSD.n1137 VSSD.n1119 0.9005
R13753 VSSD.n1124 VSSD.n1115 0.9005
R13754 VSSD.n1133 VSSD.n1120 0.9005
R13755 VSSD.n1132 VSSD.n1114 0.9005
R13756 VSSD.n1131 VSSD.n1121 0.9005
R13757 VSSD.n1126 VSSD.n1113 0.9005
R13758 VSSD.n1129 VSSD.n1126 0.9005
R13759 VSSD.n1131 VSSD.n1130 0.9005
R13760 VSSD.n1132 VSSD.n1125 0.9005
R13761 VSSD.n1134 VSSD.n1133 0.9005
R13762 VSSD.n1135 VSSD.n1124 0.9005
R13763 VSSD.n1137 VSSD.n1136 0.9005
R13764 VSSD.n1138 VSSD.n1123 0.9005
R13765 VSSD.n1140 VSSD.n1139 0.9005
R13766 VSSD.n2892 VSSD.n2888 0.9005
R13767 VSSD.n2896 VSSD.n2893 0.9005
R13768 VSSD.n2898 VSSD.n2897 0.9005
R13769 VSSD.n2900 VSSD.n2899 0.9005
R13770 VSSD.n2901 VSSD.n618 0.9005
R13771 VSSD.n2903 VSSD.n2902 0.9005
R13772 VSSD.n2908 VSSD.n603 0.9005
R13773 VSSD.n2936 VSSD.n2935 0.9005
R13774 VSSD.n605 VSSD.n582 0.9005
R13775 VSSD.n2941 VSSD.n2940 0.9005
R13776 VSSD.n2892 VSSD.n2891 0.9005
R13777 VSSD.n2896 VSSD.n2895 0.9005
R13778 VSSD.n2898 VSSD.n592 0.9005
R13779 VSSD.n2900 VSSD.n597 0.9005
R13780 VSSD.n2901 VSSD.n591 0.9005
R13781 VSSD.n2902 VSSD.n600 0.9005
R13782 VSSD.n603 VSSD.n590 0.9005
R13783 VSSD.n2937 VSSD.n2936 0.9005
R13784 VSSD.n583 VSSD.n582 0.9005
R13785 VSSD.n2940 VSSD.n2939 0.9005
R13786 VSSD.n712 VSSD.n693 0.9005
R13787 VSSD.n711 VSSD.n691 0.9005
R13788 VSSD.n716 VSSD.n694 0.9005
R13789 VSSD.n717 VSSD.n690 0.9005
R13790 VSSD.n718 VSSD.n695 0.9005
R13791 VSSD.n709 VSSD.n708 0.9005
R13792 VSSD.n723 VSSD.n722 0.9005
R13793 VSSD.n688 VSSD.n684 0.9005
R13794 VSSD.n727 VSSD.n726 0.9005
R13795 VSSD.n728 VSSD.n727 0.9005
R13796 VSSD.n684 VSSD.n683 0.9005
R13797 VSSD.n722 VSSD.n721 0.9005
R13798 VSSD.n720 VSSD.n709 0.9005
R13799 VSSD.n719 VSSD.n718 0.9005
R13800 VSSD.n717 VSSD.n710 0.9005
R13801 VSSD.n716 VSSD.n715 0.9005
R13802 VSSD.n714 VSSD.n711 0.9005
R13803 VSSD.n3031 VSSD.n3027 0.9005
R13804 VSSD.n3035 VSSD.n3032 0.9005
R13805 VSSD.n3037 VSSD.n3036 0.9005
R13806 VSSD.n3039 VSSD.n3038 0.9005
R13807 VSSD.n3040 VSSD.n435 0.9005
R13808 VSSD.n3042 VSSD.n3041 0.9005
R13809 VSSD.n3047 VSSD.n420 0.9005
R13810 VSSD.n3075 VSSD.n3074 0.9005
R13811 VSSD.n422 VSSD.n399 0.9005
R13812 VSSD.n3080 VSSD.n3079 0.9005
R13813 VSSD.n3031 VSSD.n3030 0.9005
R13814 VSSD.n3035 VSSD.n3034 0.9005
R13815 VSSD.n3037 VSSD.n409 0.9005
R13816 VSSD.n3039 VSSD.n414 0.9005
R13817 VSSD.n3040 VSSD.n408 0.9005
R13818 VSSD.n3041 VSSD.n417 0.9005
R13819 VSSD.n420 VSSD.n407 0.9005
R13820 VSSD.n3076 VSSD.n3075 0.9005
R13821 VSSD.n400 VSSD.n399 0.9005
R13822 VSSD.n3079 VSSD.n3078 0.9005
R13823 VSSD.n528 VSSD.n509 0.9005
R13824 VSSD.n527 VSSD.n507 0.9005
R13825 VSSD.n532 VSSD.n510 0.9005
R13826 VSSD.n533 VSSD.n506 0.9005
R13827 VSSD.n534 VSSD.n511 0.9005
R13828 VSSD.n525 VSSD.n524 0.9005
R13829 VSSD.n539 VSSD.n538 0.9005
R13830 VSSD.n504 VSSD.n500 0.9005
R13831 VSSD.n543 VSSD.n542 0.9005
R13832 VSSD.n544 VSSD.n543 0.9005
R13833 VSSD.n500 VSSD.n499 0.9005
R13834 VSSD.n538 VSSD.n537 0.9005
R13835 VSSD.n536 VSSD.n525 0.9005
R13836 VSSD.n535 VSSD.n534 0.9005
R13837 VSSD.n533 VSSD.n526 0.9005
R13838 VSSD.n532 VSSD.n531 0.9005
R13839 VSSD.n530 VSSD.n527 0.9005
R13840 VSSD.n2712 VSSD.n2711 0.9005
R13841 VSSD.n2702 VSSD.n2694 0.9005
R13842 VSSD.n2704 VSSD.n2703 0.9005
R13843 VSSD.n2701 VSSD.n2692 0.9005
R13844 VSSD.n2700 VSSD.n2699 0.9005
R13845 VSSD.n2698 VSSD.n2695 0.9005
R13846 VSSD.n2697 VSSD.n2696 0.9005
R13847 VSSD.n861 VSSD.n860 0.9005
R13848 VSSD.n2816 VSSD.n2815 0.9005
R13849 VSSD.n2770 VSSD.n762 0.9005
R13850 VSSD.n2774 VSSD.n2773 0.9005
R13851 VSSD.n2776 VSSD.n2775 0.9005
R13852 VSSD.n2778 VSSD.n786 0.9005
R13853 VSSD.n2808 VSSD.n787 0.9005
R13854 VSSD.n2807 VSSD.n788 0.9005
R13855 VSSD.n2806 VSSD.n789 0.9005
R13856 VSSD.n2805 VSSD.n2804 0.9005
R13857 VSSD.n2755 VSSD.n774 0.9005
R13858 VSSD.n2815 VSSD.n2814 0.9005
R13859 VSSD.n776 VSSD.n762 0.9005
R13860 VSSD.n2774 VSSD.n781 0.9005
R13861 VSSD.n2775 VSSD.n784 0.9005
R13862 VSSD.n786 VSSD.n780 0.9005
R13863 VSSD.n2809 VSSD.n2808 0.9005
R13864 VSSD.n2807 VSSD.n779 0.9005
R13865 VSSD.n2806 VSSD.n770 0.9005
R13866 VSSD.n2805 VSSD.n771 0.9005
R13867 VSSD.n2811 VSSD.n774 0.9005
R13868 VSSD.n2411 VSSD.n2368 0.9005
R13869 VSSD.n2410 VSSD.n2369 0.9005
R13870 VSSD.n2409 VSSD.n2370 0.9005
R13871 VSSD.n2390 VSSD.n2371 0.9005
R13872 VSSD.n2405 VSSD.n2373 0.9005
R13873 VSSD.n2404 VSSD.n2374 0.9005
R13874 VSSD.n2403 VSSD.n2375 0.9005
R13875 VSSD.n2388 VSSD.n2376 0.9005
R13876 VSSD.n2399 VSSD.n2398 0.9005
R13877 VSSD.n2412 VSSD.n2411 0.9005
R13878 VSSD.n2401 VSSD.n2376 0.9005
R13879 VSSD.n2403 VSSD.n2402 0.9005
R13880 VSSD.n2404 VSSD.n2372 0.9005
R13881 VSSD.n2406 VSSD.n2405 0.9005
R13882 VSSD.n2407 VSSD.n2371 0.9005
R13883 VSSD.n2409 VSSD.n2408 0.9005
R13884 VSSD.n2410 VSSD.n2367 0.9005
R13885 VSSD.n2257 VSSD.n2253 0.9005
R13886 VSSD.n2261 VSSD.n2258 0.9005
R13887 VSSD.n2263 VSSD.n2262 0.9005
R13888 VSSD.n2265 VSSD.n2264 0.9005
R13889 VSSD.n2266 VSSD.n1081 0.9005
R13890 VSSD.n2268 VSSD.n2267 0.9005
R13891 VSSD.n2273 VSSD.n1066 0.9005
R13892 VSSD.n2301 VSSD.n2300 0.9005
R13893 VSSD.n1068 VSSD.n1045 0.9005
R13894 VSSD.n2306 VSSD.n2305 0.9005
R13895 VSSD.n2257 VSSD.n2256 0.9005
R13896 VSSD.n2261 VSSD.n2260 0.9005
R13897 VSSD.n2263 VSSD.n1055 0.9005
R13898 VSSD.n2265 VSSD.n1060 0.9005
R13899 VSSD.n2266 VSSD.n1054 0.9005
R13900 VSSD.n2267 VSSD.n1063 0.9005
R13901 VSSD.n1066 VSSD.n1053 0.9005
R13902 VSSD.n2302 VSSD.n2301 0.9005
R13903 VSSD.n1046 VSSD.n1045 0.9005
R13904 VSSD.n2305 VSSD.n2304 0.9005
R13905 VSSD.n2217 VSSD.n2174 0.9005
R13906 VSSD.n2216 VSSD.n2175 0.9005
R13907 VSSD.n2215 VSSD.n2176 0.9005
R13908 VSSD.n2196 VSSD.n2177 0.9005
R13909 VSSD.n2211 VSSD.n2179 0.9005
R13910 VSSD.n2210 VSSD.n2180 0.9005
R13911 VSSD.n2209 VSSD.n2181 0.9005
R13912 VSSD.n2194 VSSD.n2182 0.9005
R13913 VSSD.n2205 VSSD.n2204 0.9005
R13914 VSSD.n2218 VSSD.n2217 0.9005
R13915 VSSD.n2207 VSSD.n2182 0.9005
R13916 VSSD.n2209 VSSD.n2208 0.9005
R13917 VSSD.n2210 VSSD.n2178 0.9005
R13918 VSSD.n2212 VSSD.n2211 0.9005
R13919 VSSD.n2213 VSSD.n2177 0.9005
R13920 VSSD.n2215 VSSD.n2214 0.9005
R13921 VSSD.n2216 VSSD.n2173 0.9005
R13922 VSSD.n1825 VSSD.n1818 0.9005
R13923 VSSD.n1835 VSSD.n1834 0.9005
R13924 VSSD.n1833 VSSD.n1832 0.9005
R13925 VSSD.n1831 VSSD.n1830 0.9005
R13926 VSSD.n1829 VSSD.n1828 0.9005
R13927 VSSD.n1827 VSSD.n1826 0.9005
R13928 VSSD.n1571 VSSD.n1551 0.9005
R13929 VSSD.n1840 VSSD.n1839 0.9005
R13930 VSSD.n1559 VSSD.n1552 0.9005
R13931 VSSD.n1718 VSSD.n1717 0.9005
R13932 VSSD.n1936 VSSD.n1933 0.9005
R13933 VSSD.n1304 VSSD.n1277 0.9005
R13934 VSSD.n1943 VSSD.n1298 0.9005
R13935 VSSD.n1944 VSSD.n1942 0.9005
R13936 VSSD.n1945 VSSD.n1941 0.9005
R13937 VSSD.n1946 VSSD.n1940 0.9005
R13938 VSSD.n1947 VSSD.n1939 0.9005
R13939 VSSD.n1948 VSSD.n1938 0.9005
R13940 VSSD.n1949 VSSD.n1937 0.9005
R13941 VSSD.n1951 VSSD.n1950 0.9005
R13942 VSSD.n1936 VSSD.n1935 0.9005
R13943 VSSD.n1950 VSSD.n1270 0.9005
R13944 VSSD.n1949 VSSD.n1268 0.9005
R13945 VSSD.n1948 VSSD.n1271 0.9005
R13946 VSSD.n1947 VSSD.n1267 0.9005
R13947 VSSD.n1946 VSSD.n1272 0.9005
R13948 VSSD.n1945 VSSD.n1266 0.9005
R13949 VSSD.n1944 VSSD.n1286 0.9005
R13950 VSSD.n1943 VSSD.n1273 0.9005
R13951 VSSD.n1959 VSSD.n1277 0.9005
R13952 VSSD.n1988 VSSD.n1969 0.9005
R13953 VSSD.n1987 VSSD.n1967 0.9005
R13954 VSSD.n1992 VSSD.n1970 0.9005
R13955 VSSD.n1993 VSSD.n1966 0.9005
R13956 VSSD.n1994 VSSD.n1971 0.9005
R13957 VSSD.n1985 VSSD.n1984 0.9005
R13958 VSSD.n1999 VSSD.n1998 0.9005
R13959 VSSD.n1964 VSSD.n1264 0.9005
R13960 VSSD.n2003 VSSD.n2002 0.9005
R13961 VSSD.n2004 VSSD.n2003 0.9005
R13962 VSSD.n1264 VSSD.n1263 0.9005
R13963 VSSD.n1998 VSSD.n1997 0.9005
R13964 VSSD.n1996 VSSD.n1985 0.9005
R13965 VSSD.n1995 VSSD.n1994 0.9005
R13966 VSSD.n1993 VSSD.n1986 0.9005
R13967 VSSD.n1992 VSSD.n1991 0.9005
R13968 VSSD.n1990 VSSD.n1987 0.9005
R13969 VSSD.n389 VSSD.n384 0.806947
R13970 VSSD.n3170 VSSD.n3169 0.806947
R13971 VSSD.n3105 VSSD.n3104 0.806947
R13972 VSSD.n2973 VSSD.n2970 0.806947
R13973 VSSD.n2420 VSSD.n2419 0.806947
R13974 VSSD.n2827 VSSD.n739 0.806947
R13975 VSSD.n737 VSSD.n736 0.806947
R13976 VSSD.n2121 VSSD.n2120 0.806947
R13977 VSSD.n2961 VSSD.n576 0.806947
R13978 VSSD.n2132 VSSD.n2106 0.806947
R13979 VSSD.n2162 VSSD.n1106 0.806947
R13980 VSSD.n1661 VSSD.n1660 0.806947
R13981 VSSD.n1740 VSSD.n1739 0.806947
R13982 VSSD.n2231 VSSD.n1090 0.806947
R13983 VSSD.n2471 VSSD.n2421 0.806947
R13984 VSSD.n2554 VSSD.n2553 0.806947
R13985 VSSD.n3668 VSSD.n1 0.806947
R13986 VSSD.n2509 VSSD.n2489 0.806947
R13987 VSSD.n2501 VSSD.n2500 0.806947
R13988 VSSD.n986 VSSD.n985 0.806947
R13989 VSSD.n1794 VSSD.n1792 0.806947
R13990 VSSD.n1778 VSSD.n1731 0.806947
R13991 VSSD.n390 VSSD.n389 0.721759
R13992 VSSD.n3172 VSSD.n3170 0.721759
R13993 VSSD.n3104 VSSD.n3103 0.721759
R13994 VSSD.n2973 VSSD.n2972 0.721759
R13995 VSSD.n2477 VSSD.n2419 0.721759
R13996 VSSD.n2827 VSSD.n2826 0.721759
R13997 VSSD.n2833 VSSD.n736 0.721759
R13998 VSSD.n2123 VSSD.n2121 0.721759
R13999 VSSD.n2112 VSSD.n576 0.721759
R14000 VSSD.n2132 VSSD.n2131 0.721759
R14001 VSSD.n2162 VSSD.n2161 0.721759
R14002 VSSD.n1660 VSSD.n1659 0.721759
R14003 VSSD.n1742 VSSD.n1740 0.721759
R14004 VSSD.n2231 VSSD.n2230 0.721759
R14005 VSSD.n2471 VSSD.n2470 0.721759
R14006 VSSD.n2553 VSSD.n2552 0.721759
R14007 VSSD.n2564 VSSD.n986 0.721759
R14008 VSSD.n3668 VSSD.n3667 0.721759
R14009 VSSD.n2509 VSSD.n2508 0.721759
R14010 VSSD.n2500 VSSD.n2499 0.721759
R14011 VSSD.n1794 VSSD.n1793 0.721759
R14012 VSSD.n1773 VSSD.n1731 0.721759
R14013 VSSD.n1879 VSSD.n1878 0.643903
R14014 VSSD.n3553 VSSD.n3552 0.643903
R14015 VSSD.n2621 VSSD.n2620 0.643903
R14016 VSSD.n3154 VSSD.n3153 0.643903
R14017 VSSD.n2033 VSSD.n2030 0.643903
R14018 VSSD.n2866 VSSD.n2863 0.643903
R14019 VSSD.n3005 VSSD.n3002 0.643903
R14020 VSSD.n2723 VSSD.n2722 0.643903
R14021 VSSD.n2355 VSSD.n2338 0.643903
R14022 VSSD.n1671 VSSD.n1670 0.643903
R14023 VSSD.n3298 VSSD.n3295 0.643903
R14024 VSSD.n1509 VSSD.n1508 0.565534
R14025 VSSD.n94 VSSD.n93 0.565534
R14026 VSSD.n2612 VSSD.n2611 0.565534
R14027 VSSD.n3287 VSSD.n3286 0.565534
R14028 VSSD.n553 VSSD.n552 0.565534
R14029 VSSD.n2994 VSSD.n2993 0.565534
R14030 VSSD.n2855 VSSD.n2854 0.565534
R14031 VSSD.n849 VSSD.n848 0.565534
R14032 VSSD.n2347 VSSD.n2346 0.565534
R14033 VSSD.n1646 VSSD.n1645 0.565534
R14034 VSSD.n2015 VSSD.n2014 0.565534
R14035 VSSD.n2631 VSSD.n2630 0.520521
R14036 VSSD.n3146 VSSD.n3145 0.520521
R14037 VSSD.n2041 VSSD.n2040 0.520521
R14038 VSSD.n2874 VSSD.n2873 0.520521
R14039 VSSD.n3013 VSSD.n3012 0.520521
R14040 VSSD.n2328 VSSD.n2327 0.520521
R14041 VSSD.n3306 VSSD.n3305 0.520521
R14042 VSSD.n3578 VSSD.n80 0.520128
R14043 VSSD.n2748 VSSD.n835 0.520128
R14044 VSSD.n1696 VSSD.n1632 0.520128
R14045 VSSD.n1953 VSSD.n1333 0.505644
R14046 VSSD.n1837 VSSD.n1592 0.505644
R14047 VSSD.n2292 VSSD.n1074 0.505644
R14048 VSSD.n2802 VSSD.n2772 0.505644
R14049 VSSD.n2678 VSSD.n900 0.505644
R14050 VSSD.n3626 VSSD.n50 0.505644
R14051 VSSD.n3066 VSSD.n428 0.505644
R14052 VSSD.n3235 VSSD.n311 0.505644
R14053 VSSD.n2927 VSSD.n611 0.505644
R14054 VSSD.n2088 VSSD.n1188 0.505644
R14055 VSSD.n1318 VSSD.n1299 0.5005
R14056 VSSD.n1331 VSSD.n1316 0.5005
R14057 VSSD.n1330 VSSD.n1300 0.5005
R14058 VSSD.n1329 VSSD.n1313 0.5005
R14059 VSSD.n1320 VSSD.n1301 0.5005
R14060 VSSD.n1325 VSSD.n1310 0.5005
R14061 VSSD.n1324 VSSD.n1302 0.5005
R14062 VSSD.n1323 VSSD.n1307 0.5005
R14063 VSSD.n1303 VSSD.n1289 0.5005
R14064 VSSD.n1956 VSSD.n1955 0.5005
R14065 VSSD.n1573 VSSD.n1554 0.5005
R14066 VSSD.n1590 VSSD.n1564 0.5005
R14067 VSSD.n1589 VSSD.n1555 0.5005
R14068 VSSD.n1588 VSSD.n1563 0.5005
R14069 VSSD.n1575 VSSD.n1556 0.5005
R14070 VSSD.n1584 VSSD.n1562 0.5005
R14071 VSSD.n1583 VSSD.n1557 0.5005
R14072 VSSD.n1582 VSSD.n1561 0.5005
R14073 VSSD.n1577 VSSD.n1558 0.5005
R14074 VSSD.n1578 VSSD.n1560 0.5005
R14075 VSSD.n1591 VSSD.n1590 0.5005
R14076 VSSD.n1589 VSSD.n1574 0.5005
R14077 VSSD.n1588 VSSD.n1587 0.5005
R14078 VSSD.n1586 VSSD.n1575 0.5005
R14079 VSSD.n1585 VSSD.n1584 0.5005
R14080 VSSD.n1583 VSSD.n1576 0.5005
R14081 VSSD.n1582 VSSD.n1581 0.5005
R14082 VSSD.n1580 VSSD.n1577 0.5005
R14083 VSSD.n1579 VSSD.n1578 0.5005
R14084 VSSD.n2297 VSSD.n1078 0.5005
R14085 VSSD.n2295 VSSD.n2294 0.5005
R14086 VSSD.n2277 VSSD.n1082 0.5005
R14087 VSSD.n2289 VSSD.n2276 0.5005
R14088 VSSD.n2288 VSSD.n1083 0.5005
R14089 VSSD.n2287 VSSD.n2270 0.5005
R14090 VSSD.n2279 VSSD.n1084 0.5005
R14091 VSSD.n2283 VSSD.n2269 0.5005
R14092 VSSD.n2282 VSSD.n1086 0.5005
R14093 VSSD.n2281 VSSD.n1069 0.5005
R14094 VSSD.n2786 VSSD.n791 0.5005
R14095 VSSD.n2787 VSSD.n2762 0.5005
R14096 VSSD.n2788 VSSD.n792 0.5005
R14097 VSSD.n2784 VSSD.n2760 0.5005
R14098 VSSD.n2792 VSSD.n793 0.5005
R14099 VSSD.n2793 VSSD.n2758 0.5005
R14100 VSSD.n2794 VSSD.n794 0.5005
R14101 VSSD.n2782 VSSD.n2756 0.5005
R14102 VSSD.n2798 VSSD.n2781 0.5005
R14103 VSSD.n2800 VSSD.n2799 0.5005
R14104 VSSD.n2680 VSSD.n2679 0.5005
R14105 VSSD.n909 VSSD.n899 0.5005
R14106 VSSD.n2675 VSSD.n2674 0.5005
R14107 VSSD.n2672 VSSD.n911 0.5005
R14108 VSSD.n2659 VSSD.n913 0.5005
R14109 VSSD.n2670 VSSD.n2669 0.5005
R14110 VSSD.n2658 VSSD.n914 0.5005
R14111 VSSD.n2664 VSSD.n2656 0.5005
R14112 VSSD.n2663 VSSD.n915 0.5005
R14113 VSSD.n2662 VSSD.n2654 0.5005
R14114 VSSD.n2677 VSSD.n909 0.5005
R14115 VSSD.n2676 VSSD.n2675 0.5005
R14116 VSSD.n911 VSSD.n910 0.5005
R14117 VSSD.n2667 VSSD.n2659 0.5005
R14118 VSSD.n2669 VSSD.n2668 0.5005
R14119 VSSD.n2666 VSSD.n2658 0.5005
R14120 VSSD.n2665 VSSD.n2664 0.5005
R14121 VSSD.n2663 VSSD.n2660 0.5005
R14122 VSSD.n2662 VSSD.n2661 0.5005
R14123 VSSD.n3628 VSSD.n3627 0.5005
R14124 VSSD.n59 VSSD.n49 0.5005
R14125 VSSD.n3623 VSSD.n3622 0.5005
R14126 VSSD.n3620 VSSD.n61 0.5005
R14127 VSSD.n3607 VSSD.n63 0.5005
R14128 VSSD.n3618 VSSD.n3617 0.5005
R14129 VSSD.n3606 VSSD.n64 0.5005
R14130 VSSD.n3612 VSSD.n3604 0.5005
R14131 VSSD.n3611 VSSD.n65 0.5005
R14132 VSSD.n3610 VSSD.n3602 0.5005
R14133 VSSD.n3625 VSSD.n59 0.5005
R14134 VSSD.n3624 VSSD.n3623 0.5005
R14135 VSSD.n61 VSSD.n60 0.5005
R14136 VSSD.n3615 VSSD.n3607 0.5005
R14137 VSSD.n3617 VSSD.n3616 0.5005
R14138 VSSD.n3614 VSSD.n3606 0.5005
R14139 VSSD.n3613 VSSD.n3612 0.5005
R14140 VSSD.n3611 VSSD.n3608 0.5005
R14141 VSSD.n3610 VSSD.n3609 0.5005
R14142 VSSD.n3071 VSSD.n432 0.5005
R14143 VSSD.n3069 VSSD.n3068 0.5005
R14144 VSSD.n3051 VSSD.n436 0.5005
R14145 VSSD.n3063 VSSD.n3050 0.5005
R14146 VSSD.n3062 VSSD.n437 0.5005
R14147 VSSD.n3061 VSSD.n3044 0.5005
R14148 VSSD.n3053 VSSD.n438 0.5005
R14149 VSSD.n3057 VSSD.n3043 0.5005
R14150 VSSD.n3056 VSSD.n440 0.5005
R14151 VSSD.n3055 VSSD.n423 0.5005
R14152 VSSD.n3237 VSSD.n3236 0.5005
R14153 VSSD.n320 VSSD.n310 0.5005
R14154 VSSD.n3232 VSSD.n3231 0.5005
R14155 VSSD.n3229 VSSD.n322 0.5005
R14156 VSSD.n3216 VSSD.n324 0.5005
R14157 VSSD.n3227 VSSD.n3226 0.5005
R14158 VSSD.n3215 VSSD.n325 0.5005
R14159 VSSD.n3221 VSSD.n3213 0.5005
R14160 VSSD.n3220 VSSD.n326 0.5005
R14161 VSSD.n3219 VSSD.n3211 0.5005
R14162 VSSD.n3234 VSSD.n320 0.5005
R14163 VSSD.n3233 VSSD.n3232 0.5005
R14164 VSSD.n322 VSSD.n321 0.5005
R14165 VSSD.n3224 VSSD.n3216 0.5005
R14166 VSSD.n3226 VSSD.n3225 0.5005
R14167 VSSD.n3223 VSSD.n3215 0.5005
R14168 VSSD.n3222 VSSD.n3221 0.5005
R14169 VSSD.n3220 VSSD.n3217 0.5005
R14170 VSSD.n3219 VSSD.n3218 0.5005
R14171 VSSD.n2932 VSSD.n615 0.5005
R14172 VSSD.n2930 VSSD.n2929 0.5005
R14173 VSSD.n2912 VSSD.n619 0.5005
R14174 VSSD.n2924 VSSD.n2911 0.5005
R14175 VSSD.n2923 VSSD.n620 0.5005
R14176 VSSD.n2922 VSSD.n2905 0.5005
R14177 VSSD.n2914 VSSD.n621 0.5005
R14178 VSSD.n2918 VSSD.n2904 0.5005
R14179 VSSD.n2917 VSSD.n623 0.5005
R14180 VSSD.n2916 VSSD.n606 0.5005
R14181 VSSD.n2093 VSSD.n1192 0.5005
R14182 VSSD.n2091 VSSD.n2090 0.5005
R14183 VSSD.n2073 VSSD.n1196 0.5005
R14184 VSSD.n2085 VSSD.n2072 0.5005
R14185 VSSD.n2084 VSSD.n1197 0.5005
R14186 VSSD.n2083 VSSD.n2066 0.5005
R14187 VSSD.n2075 VSSD.n1198 0.5005
R14188 VSSD.n2079 VSSD.n2065 0.5005
R14189 VSSD.n2078 VSSD.n1200 0.5005
R14190 VSSD.n2077 VSSD.n1183 0.5005
R14191 VSSD.n2090 VSSD.n2089 0.5005
R14192 VSSD.n2087 VSSD.n2073 0.5005
R14193 VSSD.n2086 VSSD.n2085 0.5005
R14194 VSSD.n2084 VSSD.n2074 0.5005
R14195 VSSD.n2083 VSSD.n2082 0.5005
R14196 VSSD.n2081 VSSD.n2075 0.5005
R14197 VSSD.n2080 VSSD.n2079 0.5005
R14198 VSSD.n2078 VSSD.n2076 0.5005
R14199 VSSD.n2077 VSSD.n1170 0.5005
R14200 VSSD.n2929 VSSD.n2928 0.5005
R14201 VSSD.n2926 VSSD.n2912 0.5005
R14202 VSSD.n2925 VSSD.n2924 0.5005
R14203 VSSD.n2923 VSSD.n2913 0.5005
R14204 VSSD.n2922 VSSD.n2921 0.5005
R14205 VSSD.n2920 VSSD.n2914 0.5005
R14206 VSSD.n2919 VSSD.n2918 0.5005
R14207 VSSD.n2917 VSSD.n2915 0.5005
R14208 VSSD.n2916 VSSD.n593 0.5005
R14209 VSSD.n3068 VSSD.n3067 0.5005
R14210 VSSD.n3065 VSSD.n3051 0.5005
R14211 VSSD.n3064 VSSD.n3063 0.5005
R14212 VSSD.n3062 VSSD.n3052 0.5005
R14213 VSSD.n3061 VSSD.n3060 0.5005
R14214 VSSD.n3059 VSSD.n3053 0.5005
R14215 VSSD.n3058 VSSD.n3057 0.5005
R14216 VSSD.n3056 VSSD.n3054 0.5005
R14217 VSSD.n3055 VSSD.n410 0.5005
R14218 VSSD.n2787 VSSD.n2785 0.5005
R14219 VSSD.n2789 VSSD.n2788 0.5005
R14220 VSSD.n2790 VSSD.n2784 0.5005
R14221 VSSD.n2792 VSSD.n2791 0.5005
R14222 VSSD.n2793 VSSD.n2783 0.5005
R14223 VSSD.n2795 VSSD.n2794 0.5005
R14224 VSSD.n2796 VSSD.n2782 0.5005
R14225 VSSD.n2798 VSSD.n2797 0.5005
R14226 VSSD.n2799 VSSD.n782 0.5005
R14227 VSSD.n2294 VSSD.n2293 0.5005
R14228 VSSD.n2291 VSSD.n2277 0.5005
R14229 VSSD.n2290 VSSD.n2289 0.5005
R14230 VSSD.n2288 VSSD.n2278 0.5005
R14231 VSSD.n2287 VSSD.n2286 0.5005
R14232 VSSD.n2285 VSSD.n2279 0.5005
R14233 VSSD.n2284 VSSD.n2283 0.5005
R14234 VSSD.n2282 VSSD.n2280 0.5005
R14235 VSSD.n2281 VSSD.n1056 0.5005
R14236 VSSD.n1332 VSSD.n1331 0.5005
R14237 VSSD.n1330 VSSD.n1319 0.5005
R14238 VSSD.n1329 VSSD.n1328 0.5005
R14239 VSSD.n1327 VSSD.n1320 0.5005
R14240 VSSD.n1326 VSSD.n1325 0.5005
R14241 VSSD.n1324 VSSD.n1321 0.5005
R14242 VSSD.n1323 VSSD.n1322 0.5005
R14243 VSSD.n1289 VSSD.n1288 0.5005
R14244 VSSD.n1957 VSSD.n1956 0.5005
R14245 VSSD.n1856 VSSD.n1533 0.464417
R14246 VSSD.n3530 VSSD.n118 0.464417
R14247 VSSD.n3650 VSSD.n23 0.464417
R14248 VSSD.n3259 VSSD.n3258 0.464417
R14249 VSSD.n1141 VSSD.n1140 0.464417
R14250 VSSD.n714 VSSD.n713 0.464417
R14251 VSSD.n530 VSSD.n529 0.464417
R14252 VSSD.n2702 VSSD.n873 0.464417
R14253 VSSD.n2401 VSSD.n2400 0.464417
R14254 VSSD.n2207 VSSD.n2206 0.464417
R14255 VSSD.n1990 VSSD.n1989 0.464417
R14256 VSSD.n1792 VSSD.n1726 0.373526
R14257 VSSD.n1778 VSSD.n1777 0.373526
R14258 VSSD.n1801 VSSD.n1800 0.366249
R14259 VSSD.n3511 VSSD.n3495 0.364192
R14260 VSSD.n1872 VSSD.n1516 0.360101
R14261 VSSD.n3546 VSSD.n101 0.360101
R14262 VSSD.n3279 VSSD.n3278 0.360101
R14263 VSSD.n561 VSSD.n560 0.360101
R14264 VSSD.n2986 VSSD.n2985 0.360101
R14265 VSSD.n2847 VSSD.n2846 0.360101
R14266 VSSD.n2339 VSSD.n996 0.360101
R14267 VSSD.n2604 VSSD.n2603 0.360101
R14268 VSSD.n2716 VSSD.n856 0.360101
R14269 VSSD.n1638 VSSD.n1096 0.360101
R14270 VSSD.n2023 VSSD.n2022 0.360101
R14271 VSSD.n3369 VSSD.n199 0.325526
R14272 VSSD.n3435 VSSD.n3429 0.325526
R14273 VSSD.n3325 VSSD.n3324 0.321929
R14274 VSSD.n240 VSSD.n167 0.321929
R14275 VSSD.n3329 VSSD.n169 0.321929
R14276 VSSD.n3330 VSSD.n166 0.321929
R14277 VSSD.n3331 VSSD.n170 0.321929
R14278 VSSD.n238 VSSD.n165 0.321929
R14279 VSSD.n3335 VSSD.n171 0.321929
R14280 VSSD.n3336 VSSD.n164 0.321929
R14281 VSSD.n3337 VSSD.n172 0.321929
R14282 VSSD.n236 VSSD.n163 0.321929
R14283 VSSD.n3341 VSSD.n173 0.321929
R14284 VSSD.n3342 VSSD.n162 0.321929
R14285 VSSD.n3343 VSSD.n174 0.321929
R14286 VSSD.n234 VSSD.n161 0.321929
R14287 VSSD.n3347 VSSD.n175 0.321929
R14288 VSSD.n3348 VSSD.n160 0.321929
R14289 VSSD.n3349 VSSD.n176 0.321929
R14290 VSSD.n232 VSSD.n159 0.321929
R14291 VSSD.n3353 VSSD.n177 0.321929
R14292 VSSD.n3354 VSSD.n158 0.321929
R14293 VSSD.n3355 VSSD.n178 0.321929
R14294 VSSD.n230 VSSD.n157 0.321929
R14295 VSSD.n3359 VSSD.n179 0.321929
R14296 VSSD.n3360 VSSD.n156 0.321929
R14297 VSSD.n3361 VSSD.n180 0.321929
R14298 VSSD.n226 VSSD.n155 0.321929
R14299 VSSD.n3365 VSSD.n228 0.321929
R14300 VSSD.n3367 VSSD.n3366 0.321929
R14301 VSSD.n3494 VSSD.n140 0.321929
R14302 VSSD.n3493 VSSD.n3492 0.321929
R14303 VSSD.n3488 VSSD.n141 0.321929
R14304 VSSD.n3399 VSSD.n3385 0.321929
R14305 VSSD.n3485 VSSD.n3484 0.321929
R14306 VSSD.n3401 VSSD.n3400 0.321929
R14307 VSSD.n3480 VSSD.n3479 0.321929
R14308 VSSD.n3478 VSSD.n3477 0.321929
R14309 VSSD.n3476 VSSD.n3407 0.321929
R14310 VSSD.n3406 VSSD.n3405 0.321929
R14311 VSSD.n3472 VSSD.n3471 0.321929
R14312 VSSD.n3470 VSSD.n3469 0.321929
R14313 VSSD.n3468 VSSD.n3411 0.321929
R14314 VSSD.n3410 VSSD.n3409 0.321929
R14315 VSSD.n3464 VSSD.n3463 0.321929
R14316 VSSD.n3462 VSSD.n3461 0.321929
R14317 VSSD.n3460 VSSD.n3415 0.321929
R14318 VSSD.n3414 VSSD.n3413 0.321929
R14319 VSSD.n3456 VSSD.n3455 0.321929
R14320 VSSD.n3454 VSSD.n3453 0.321929
R14321 VSSD.n3452 VSSD.n3419 0.321929
R14322 VSSD.n3418 VSSD.n3417 0.321929
R14323 VSSD.n3448 VSSD.n3447 0.321929
R14324 VSSD.n3446 VSSD.n3445 0.321929
R14325 VSSD.n3444 VSSD.n3428 0.321929
R14326 VSSD.n3427 VSSD.n3426 0.321929
R14327 VSSD.n3440 VSSD.n3439 0.321929
R14328 VSSD.n3438 VSSD.n3437 0.321929
R14329 VSSD.n3441 VSSD.n3440 0.321929
R14330 VSSD.n3442 VSSD.n3427 0.321929
R14331 VSSD.n3444 VSSD.n3443 0.321929
R14332 VSSD.n3446 VSSD.n3420 0.321929
R14333 VSSD.n3449 VSSD.n3448 0.321929
R14334 VSSD.n3450 VSSD.n3418 0.321929
R14335 VSSD.n3452 VSSD.n3451 0.321929
R14336 VSSD.n3454 VSSD.n3416 0.321929
R14337 VSSD.n3457 VSSD.n3456 0.321929
R14338 VSSD.n3458 VSSD.n3414 0.321929
R14339 VSSD.n3460 VSSD.n3459 0.321929
R14340 VSSD.n3462 VSSD.n3412 0.321929
R14341 VSSD.n3465 VSSD.n3464 0.321929
R14342 VSSD.n3466 VSSD.n3410 0.321929
R14343 VSSD.n3468 VSSD.n3467 0.321929
R14344 VSSD.n3470 VSSD.n3408 0.321929
R14345 VSSD.n3473 VSSD.n3472 0.321929
R14346 VSSD.n3474 VSSD.n3406 0.321929
R14347 VSSD.n3476 VSSD.n3475 0.321929
R14348 VSSD.n3478 VSSD.n3404 0.321929
R14349 VSSD.n3481 VSSD.n3480 0.321929
R14350 VSSD.n3482 VSSD.n3401 0.321929
R14351 VSSD.n3484 VSSD.n3483 0.321929
R14352 VSSD.n3403 VSSD.n3399 0.321929
R14353 VSSD.n3402 VSSD.n141 0.321929
R14354 VSSD.n3493 VSSD.n139 0.321929
R14355 VSSD.n3495 VSSD.n3494 0.321929
R14356 VSSD.n3326 VSSD.n3325 0.321929
R14357 VSSD.n3365 VSSD.n3364 0.321929
R14358 VSSD.n3363 VSSD.n226 0.321929
R14359 VSSD.n3362 VSSD.n3361 0.321929
R14360 VSSD.n3360 VSSD.n229 0.321929
R14361 VSSD.n3359 VSSD.n3358 0.321929
R14362 VSSD.n3357 VSSD.n230 0.321929
R14363 VSSD.n3356 VSSD.n3355 0.321929
R14364 VSSD.n3354 VSSD.n231 0.321929
R14365 VSSD.n3353 VSSD.n3352 0.321929
R14366 VSSD.n3351 VSSD.n232 0.321929
R14367 VSSD.n3350 VSSD.n3349 0.321929
R14368 VSSD.n3348 VSSD.n233 0.321929
R14369 VSSD.n3347 VSSD.n3346 0.321929
R14370 VSSD.n3345 VSSD.n234 0.321929
R14371 VSSD.n3344 VSSD.n3343 0.321929
R14372 VSSD.n3342 VSSD.n235 0.321929
R14373 VSSD.n3341 VSSD.n3340 0.321929
R14374 VSSD.n3339 VSSD.n236 0.321929
R14375 VSSD.n3338 VSSD.n3337 0.321929
R14376 VSSD.n3336 VSSD.n237 0.321929
R14377 VSSD.n3335 VSSD.n3334 0.321929
R14378 VSSD.n3333 VSSD.n238 0.321929
R14379 VSSD.n3332 VSSD.n3331 0.321929
R14380 VSSD.n3330 VSSD.n239 0.321929
R14381 VSSD.n3329 VSSD.n3328 0.321929
R14382 VSSD.n3327 VSSD.n240 0.321929
R14383 VSSD.n1777 VSSD.n1726 0.321649
R14384 VSSD.n2653 VSSD.n2637 0.308842
R14385 VSSD.n3601 VSSD.n3585 0.308842
R14386 VSSD.n378 VSSD.n377 0.308842
R14387 VSSD.n2049 VSSD.n2048 0.308842
R14388 VSSD.n2888 VSSD.n2887 0.308842
R14389 VSSD.n3027 VSSD.n3026 0.308842
R14390 VSSD.n2755 VSSD.n2754 0.308842
R14391 VSSD.n2307 VSSD.n2306 0.308842
R14392 VSSD.n1718 VSSD.n1702 0.308842
R14393 VSSD.n1926 VSSD.n1913 0.28022
R14394 VSSD.n3371 VSSD.n3370 0.27923
R14395 VSSD.n1869 VSSD.n1868 0.276448
R14396 VSSD.n3543 VSSD.n3542 0.276448
R14397 VSSD.n3661 VSSD.n3660 0.276448
R14398 VSSD.n3275 VSSD.n3274 0.276448
R14399 VSSD.n1129 VSSD.n1128 0.276448
R14400 VSSD.n729 VSSD.n728 0.276448
R14401 VSSD.n569 VSSD.n544 0.276448
R14402 VSSD.n2713 VSSD.n2712 0.276448
R14403 VSSD.n2413 VSSD.n2412 0.276448
R14404 VSSD.n2219 VSSD.n2218 0.276448
R14405 VSSD.n2005 VSSD.n2004 0.276448
R14406 VSSD.n1878 VSSD.n1501 0.265516
R14407 VSSD.n3552 VSSD.n86 0.265516
R14408 VSSD.n2620 VSSD.n2619 0.265516
R14409 VSSD.n3295 VSSD.n3294 0.265516
R14410 VSSD.n3154 VSSD.n334 0.265516
R14411 VSSD.n3002 VSSD.n3001 0.265516
R14412 VSSD.n2863 VSSD.n2862 0.265516
R14413 VSSD.n2722 VSSD.n841 0.265516
R14414 VSSD.n2355 VSSD.n2354 0.265516
R14415 VSSD.n1670 VSSD.n1653 0.265516
R14416 VSSD.n2030 VSSD.n1259 0.265516
R14417 VSSD.n1592 VSSD.n1591 0.258645
R14418 VSSD.n2678 VSSD.n2677 0.258645
R14419 VSSD.n3626 VSSD.n3625 0.258645
R14420 VSSD.n3235 VSSD.n3234 0.258645
R14421 VSSD.n2089 VSSD.n2088 0.258645
R14422 VSSD.n2928 VSSD.n2927 0.258645
R14423 VSSD.n3067 VSSD.n3066 0.258645
R14424 VSSD.n2785 VSSD.n2772 0.258645
R14425 VSSD.n2293 VSSD.n2292 0.258645
R14426 VSSD.n1333 VSSD.n1332 0.258645
R14427 VSSD.n1909 VSSD.n1908 0.255027
R14428 VSSD.n2235 VSSD.n1088 0.248526
R14429 VSSD.n2467 VSSD.n2423 0.248526
R14430 VSSD.n3177 VSSD.n3176 0.248526
R14431 VSSD.n2513 VSSD.n2487 0.248526
R14432 VSSD.n2567 VSSD.n981 0.248526
R14433 VSSD.n3099 VSSD.n3098 0.248526
R14434 VSSD.n2959 VSSD.n579 0.248526
R14435 VSSD.n2136 VSSD.n2104 0.248526
R14436 VSSD.n1747 VSSD.n1746 0.248526
R14437 VSSD.n2823 VSSD.n741 0.248526
R14438 VSSD.n1862 VSSD.n1842 0.235657
R14439 VSSD.n2706 VSSD.n2686 0.235657
R14440 VSSD.n3536 VSSD.n3516 0.235657
R14441 VSSD.n3654 VSSD.n3634 0.235657
R14442 VSSD.n3271 VSSD.n3243 0.235657
R14443 VSSD.n1161 VSSD.n1160 0.235657
R14444 VSSD.n685 VSSD.n584 0.235657
R14445 VSSD.n501 VSSD.n401 0.235657
R14446 VSSD.n2379 VSSD.n773 0.235657
R14447 VSSD.n2185 VSSD.n1047 0.235657
R14448 VSSD.n1961 VSSD.n1960 0.235657
R14449 VSSD.n1904 VSSD.n1901 0.216886
R14450 VSSD.n3576 VSSD.n3575 0.216886
R14451 VSSD.n2629 VSSD.n2628 0.216886
R14452 VSSD.n3148 VSSD.n3147 0.216886
R14453 VSSD.n2039 VSSD.n2038 0.216886
R14454 VSSD.n2872 VSSD.n2871 0.216886
R14455 VSSD.n3011 VSSD.n3010 0.216886
R14456 VSSD.n2746 VSSD.n2745 0.216886
R14457 VSSD.n2335 VSSD.n2329 0.216886
R14458 VSSD.n1694 VSSD.n1693 0.216886
R14459 VSSD.n3304 VSSD.n3303 0.216886
R14460 VSSD.n2462 VSSD.n2461 0.200262
R14461 VSSD.n2543 VSSD.n2542 0.200262
R14462 VSSD.n2597 VSSD.n2596 0.200262
R14463 VSSD.n3194 VSSD.n327 0.200262
R14464 VSSD.n2154 VSSD.n2153 0.200262
R14465 VSSD.n2942 VSSD.n580 0.200262
R14466 VSSD.n3081 VSSD.n397 0.200262
R14467 VSSD.n2818 VSSD.n2817 0.200262
R14468 VSSD.n2252 VSSD.n1087 0.200262
R14469 VSSD.n1817 VSSD.n1722 0.200262
R14470 VSSD.n1765 VSSD.n1764 0.200262
R14471 VSSD.n2461 VSSD.n2460 0.182776
R14472 VSSD.n2542 VSSD.n2541 0.182776
R14473 VSSD.n2596 VSSD.n2595 0.182776
R14474 VSSD.n3210 VSSD.n3194 0.182776
R14475 VSSD.n2153 VSSD.n2102 0.182776
R14476 VSSD.n2942 VSSD.n2941 0.182776
R14477 VSSD.n3081 VSSD.n3080 0.182776
R14478 VSSD.n2817 VSSD.n2816 0.182776
R14479 VSSD.n2253 VSSD.n2252 0.182776
R14480 VSSD.n1818 VSSD.n1817 0.182776
R14481 VSSD.n1764 VSSD.n1304 0.182776
R14482 VSSD.n3177 VSSD.n328 0.17684
R14483 VSSD.n2513 VSSD.n2488 0.17684
R14484 VSSD.n2567 VSSD.n982 0.17684
R14485 VSSD.n3098 VSSD.n396 0.17684
R14486 VSSD.n2959 VSSD.n578 0.17684
R14487 VSSD.n2136 VSSD.n2103 0.17684
R14488 VSSD.n1747 VSSD.n1734 0.17684
R14489 VSSD.n2465 VSSD.n2423 0.17684
R14490 VSSD.n2821 VSSD.n741 0.17684
R14491 VSSD.n2235 VSSD.n1089 0.17684
R14492 VSSD.n1799 VSSD.n1798 0.172982
R14493 VSSD.n3441 VSSD.n3429 0.167142
R14494 VSSD.n3364 VSSD.n199 0.167142
R14495 VSSD.n1933 VSSD.n1932 0.159532
R14496 VSSD.n1511 VSSD.n1510 0.154293
R14497 VSSD.n1515 VSSD.n1514 0.154293
R14498 VSSD.n1503 VSSD.n1502 0.154293
R14499 VSSD.n1507 VSSD.n1506 0.154293
R14500 VSSD.n88 VSSD.n87 0.154293
R14501 VSSD.n92 VSSD.n91 0.154293
R14502 VSSD.n96 VSSD.n95 0.154293
R14503 VSSD.n100 VSSD.n99 0.154293
R14504 VSSD.n2610 VSSD.n2609 0.154293
R14505 VSSD.n2606 VSSD.n2605 0.154293
R14506 VSSD.n2618 VSSD.n2617 0.154293
R14507 VSSD.n2614 VSSD.n2613 0.154293
R14508 VSSD.n3289 VSSD.n3288 0.154293
R14509 VSSD.n3293 VSSD.n3292 0.154293
R14510 VSSD.n3281 VSSD.n3280 0.154293
R14511 VSSD.n3285 VSSD.n3284 0.154293
R14512 VSSD.n559 VSSD.n558 0.154293
R14513 VSSD.n555 VSSD.n554 0.154293
R14514 VSSD.n551 VSSD.n550 0.154293
R14515 VSSD.n547 VSSD.n546 0.154293
R14516 VSSD.n2996 VSSD.n2995 0.154293
R14517 VSSD.n3000 VSSD.n2999 0.154293
R14518 VSSD.n2988 VSSD.n2987 0.154293
R14519 VSSD.n2992 VSSD.n2991 0.154293
R14520 VSSD.n2857 VSSD.n2856 0.154293
R14521 VSSD.n2861 VSSD.n2860 0.154293
R14522 VSSD.n2849 VSSD.n2848 0.154293
R14523 VSSD.n2853 VSSD.n2852 0.154293
R14524 VSSD.n851 VSSD.n850 0.154293
R14525 VSSD.n855 VSSD.n854 0.154293
R14526 VSSD.n843 VSSD.n842 0.154293
R14527 VSSD.n847 VSSD.n846 0.154293
R14528 VSSD.n2353 VSSD.n2352 0.154293
R14529 VSSD.n2349 VSSD.n2348 0.154293
R14530 VSSD.n2345 VSSD.n2344 0.154293
R14531 VSSD.n2341 VSSD.n2340 0.154293
R14532 VSSD.n1644 VSSD.n1643 0.154293
R14533 VSSD.n1640 VSSD.n1639 0.154293
R14534 VSSD.n1652 VSSD.n1651 0.154293
R14535 VSSD.n1648 VSSD.n1647 0.154293
R14536 VSSD.n2021 VSSD.n2020 0.154293
R14537 VSSD.n2017 VSSD.n2016 0.154293
R14538 VSSD.n2013 VSSD.n2012 0.154293
R14539 VSSD.n2009 VSSD.n2008 0.154293
R14540 VSSD.n2441 VSSD.n2440 0.144511
R14541 VSSD.n2522 VSSD.n2521 0.144511
R14542 VSSD.n2576 VSSD.n2575 0.144511
R14543 VSSD.n3186 VSSD.n3185 0.144511
R14544 VSSD.n3090 VSSD.n3089 0.144511
R14545 VSSD.n2951 VSSD.n2950 0.144511
R14546 VSSD.n2145 VSSD.n2144 0.144511
R14547 VSSD.n1756 VSSD.n1755 0.144511
R14548 VSSD.n753 VSSD.n752 0.144511
R14549 VSSD.n2244 VSSD.n2243 0.144511
R14550 VSSD.n1809 VSSD.n1808 0.144511
R14551 VSSD.n1775 VSSD.n1485 0.117713
R14552 VSSD.n2512 VSSD.n2491 0.10859
R14553 VSSD.n2566 VSSD.n983 0.10859
R14554 VSSD.n3113 VSSD.n386 0.10859
R14555 VSSD.n2159 VSSD.n1107 0.10859
R14556 VSSD.n2135 VSSD.n637 0.10859
R14557 VSSD.n2960 VSSD.n454 0.10859
R14558 VSSD.n2475 VSSD.n2474 0.10859
R14559 VSSD.n2831 VSSD.n2830 0.10859
R14560 VSSD.n2234 VSSD.n1092 0.10859
R14561 VSSD.n1873 VSSD.n1872 0.105416
R14562 VSSD.n1878 VSSD.n1877 0.105416
R14563 VSSD.n1871 VSSD.n1517 0.105416
R14564 VSSD.n1870 VSSD.n1518 0.105416
R14565 VSSD.n1869 VSSD.n1519 0.105416
R14566 VSSD.n2714 VSSD.n858 0.105416
R14567 VSSD.n978 VSSD.n9 0.105416
R14568 VSSD.n3547 VSSD.n3546 0.105416
R14569 VSSD.n3545 VSSD.n102 0.105416
R14570 VSSD.n3544 VSSD.n103 0.105416
R14571 VSSD.n3543 VSSD.n104 0.105416
R14572 VSSD.n3552 VSSD.n3551 0.105416
R14573 VSSD.n3662 VSSD.n3661 0.105416
R14574 VSSD.n2603 VSSD.n977 0.105416
R14575 VSSD.n2602 VSSD.n2601 0.105416
R14576 VSSD.n2620 VSSD.n976 0.105416
R14577 VSSD.n3277 VSSD.n273 0.105416
R14578 VSSD.n3278 VSSD.n272 0.105416
R14579 VSSD.n3275 VSSD.n275 0.105416
R14580 VSSD.n3276 VSSD.n274 0.105416
R14581 VSSD.n3155 VSSD.n3154 0.105416
R14582 VSSD.n1128 VSSD.n1127 0.105416
R14583 VSSD.n1100 VSSD.n680 0.105416
R14584 VSSD.n2846 VSSD.n679 0.105416
R14585 VSSD.n2845 VSSD.n2844 0.105416
R14586 VSSD.n2863 VSSD.n678 0.105416
R14587 VSSD.n730 VSSD.n729 0.105416
R14588 VSSD.n681 VSSD.n497 0.105416
R14589 VSSD.n2985 VSSD.n496 0.105416
R14590 VSSD.n2984 VSSD.n2983 0.105416
R14591 VSSD.n3002 VSSD.n495 0.105416
R14592 VSSD.n570 VSSD.n569 0.105416
R14593 VSSD.n568 VSSD.n545 0.105416
R14594 VSSD.n563 VSSD.n561 0.105416
R14595 VSSD.n567 VSSD.n566 0.105416
R14596 VSSD.n2713 VSSD.n859 0.105416
R14597 VSSD.n2717 VSSD.n2716 0.105416
R14598 VSSD.n2715 VSSD.n857 0.105416
R14599 VSSD.n2722 VSSD.n2721 0.105416
R14600 VSSD.n2366 VSSD.n995 0.105416
R14601 VSSD.n2414 VSSD.n2413 0.105416
R14602 VSSD.n2359 VSSD.n996 0.105416
R14603 VSSD.n2365 VSSD.n2364 0.105416
R14604 VSSD.n2356 VSSD.n2355 0.105416
R14605 VSSD.n2220 VSSD.n1097 0.105416
R14606 VSSD.n2219 VSSD.n2172 0.105416
R14607 VSSD.n1665 VSSD.n1096 0.105416
R14608 VSSD.n2222 VSSD.n2221 0.105416
R14609 VSSD.n1670 VSSD.n1669 0.105416
R14610 VSSD.n1799 VSSD.n1724 0.105416
R14611 VSSD.n1800 VSSD.n1723 0.105416
R14612 VSSD.n2005 VSSD.n1262 0.105416
R14613 VSSD.n2006 VSSD.n1261 0.105416
R14614 VSSD.n2007 VSSD.n1260 0.105416
R14615 VSSD.n2024 VSSD.n2023 0.105416
R14616 VSSD.n2030 VSSD.n2029 0.105416
R14617 VSSD.n3295 VSSD.n271 0.105416
R14618 VSSD VSSD.n3671 0.10382
R14619 VSSD.n1871 VSSD.n1870 0.101554
R14620 VSSD.n3545 VSSD.n3544 0.101554
R14621 VSSD.n2602 VSSD.n9 0.101554
R14622 VSSD.n3277 VSSD.n3276 0.101554
R14623 VSSD.n2845 VSSD.n680 0.101554
R14624 VSSD.n2984 VSSD.n497 0.101554
R14625 VSSD.n568 VSSD.n567 0.101554
R14626 VSSD.n2715 VSSD.n2714 0.101554
R14627 VSSD.n2366 VSSD.n2365 0.101554
R14628 VSSD.n2221 VSSD.n2220 0.101554
R14629 VSSD.n2007 VSSD.n2006 0.101554
R14630 VSSD.n1870 VSSD.n1869 0.1006
R14631 VSSD.n3544 VSSD.n3543 0.1006
R14632 VSSD.n3661 VSSD.n9 0.1006
R14633 VSSD.n3276 VSSD.n3275 0.1006
R14634 VSSD.n1128 VSSD.n680 0.1006
R14635 VSSD.n729 VSSD.n497 0.1006
R14636 VSSD.n569 VSSD.n568 0.1006
R14637 VSSD.n2714 VSSD.n2713 0.1006
R14638 VSSD.n2413 VSSD.n2366 0.1006
R14639 VSSD.n2220 VSSD.n2219 0.1006
R14640 VSSD.n2006 VSSD.n2005 0.1006
R14641 VSSD.n1798 VSSD.n1725 0.0997857
R14642 VSSD.n1775 VSSD.n1774 0.0997857
R14643 VSSD.n1872 VSSD.n1871 0.09275
R14644 VSSD.n3546 VSSD.n3545 0.09275
R14645 VSSD.n2603 VSSD.n2602 0.09275
R14646 VSSD.n3278 VSSD.n3277 0.09275
R14647 VSSD.n2846 VSSD.n2845 0.09275
R14648 VSSD.n2985 VSSD.n2984 0.09275
R14649 VSSD.n567 VSSD.n561 0.09275
R14650 VSSD.n2716 VSSD.n2715 0.09275
R14651 VSSD.n2365 VSSD.n996 0.09275
R14652 VSSD.n2221 VSSD.n1096 0.09275
R14653 VSSD.n1800 VSSD.n1799 0.09275
R14654 VSSD.n2023 VSSD.n2007 0.09275
R14655 VSSD.n2433 VSSD.n2423 0.0822802
R14656 VSSD.n2514 VSSD.n2513 0.0822802
R14657 VSSD.n2568 VSSD.n2567 0.0822802
R14658 VSSD.n3178 VSSD.n3177 0.0822802
R14659 VSSD.n3098 VSSD.n3097 0.0822802
R14660 VSSD.n2959 VSSD.n2958 0.0822802
R14661 VSSD.n2137 VSSD.n2136 0.0822802
R14662 VSSD.n1748 VSSD.n1747 0.0822802
R14663 VSSD.n745 VSSD.n741 0.0822802
R14664 VSSD.n2236 VSSD.n2235 0.0822802
R14665 VSSD.n2513 VSSD.n2512 0.08114
R14666 VSSD.n2567 VSSD.n2566 0.08114
R14667 VSSD.n3098 VSSD.n386 0.08114
R14668 VSSD.n1747 VSSD.n1107 0.08114
R14669 VSSD.n2136 VSSD.n2135 0.08114
R14670 VSSD.n2960 VSSD.n2959 0.08114
R14671 VSSD.n2474 VSSD.n2423 0.08114
R14672 VSSD.n2830 VSSD.n741 0.08114
R14673 VSSD.n2235 VSSD.n2234 0.08114
R14674 VSSD.n3177 VSSD.n0 0.08114
R14675 VSSD.n3194 VSSD.n3193 0.0756435
R14676 VSSD.n3082 VSSD.n3081 0.0756435
R14677 VSSD.n2943 VSSD.n2942 0.0756435
R14678 VSSD.n2153 VSSD.n2152 0.0756435
R14679 VSSD.n2461 VSSD.n2448 0.0756435
R14680 VSSD.n2542 VSSD.n2529 0.0756435
R14681 VSSD.n2596 VSSD.n2583 0.0756435
R14682 VSSD.n1764 VSSD.n1763 0.0756435
R14683 VSSD.n2817 VSSD.n760 0.0756435
R14684 VSSD.n2252 VSSD.n2251 0.0756435
R14685 VSSD.n1817 VSSD.n1816 0.0756435
R14686 VSSD.n3578 VSSD.n3577 0.0731932
R14687 VSSD.n2748 VSSD.n2747 0.0731932
R14688 VSSD.n1696 VSSD.n1695 0.0731932
R14689 VSSD.n2631 VSSD.n955 0.0730184
R14690 VSSD.n3145 VSSD.n356 0.0730184
R14691 VSSD.n2041 VSSD.n1238 0.0730184
R14692 VSSD.n2874 VSSD.n657 0.0730184
R14693 VSSD.n3013 VSSD.n474 0.0730184
R14694 VSSD.n2327 VSSD.n1018 0.0730184
R14695 VSSD.n3306 VSSD.n250 0.0730184
R14696 VSSD.n1777 VSSD.n1776 0.0724214
R14697 VSSD.n1797 VSSD.n1726 0.0694121
R14698 VSSD.n1505 VSSD.n1504 0.0653276
R14699 VSSD.n90 VSSD.n89 0.0653276
R14700 VSSD.n2616 VSSD.n2615 0.0653276
R14701 VSSD.n3291 VSSD.n3290 0.0653276
R14702 VSSD.n549 VSSD.n548 0.0653276
R14703 VSSD.n2998 VSSD.n2997 0.0653276
R14704 VSSD.n2859 VSSD.n2858 0.0653276
R14705 VSSD.n845 VSSD.n844 0.0653276
R14706 VSSD.n2351 VSSD.n2350 0.0653276
R14707 VSSD.n1650 VSSD.n1649 0.0653276
R14708 VSSD.n2011 VSSD.n2010 0.0653276
R14709 VSSD.n1513 VSSD.n1512 0.0632586
R14710 VSSD.n98 VSSD.n97 0.0632586
R14711 VSSD.n2608 VSSD.n2607 0.0632586
R14712 VSSD.n3283 VSSD.n3282 0.0632586
R14713 VSSD.n557 VSSD.n556 0.0632586
R14714 VSSD.n2990 VSSD.n2989 0.0632586
R14715 VSSD.n2851 VSSD.n2850 0.0632586
R14716 VSSD.n853 VSSD.n852 0.0632586
R14717 VSSD.n2343 VSSD.n2342 0.0632586
R14718 VSSD.n1642 VSSD.n1641 0.0632586
R14719 VSSD.n2019 VSSD.n2018 0.0632586
R14720 VSSD.n1776 VSSD.n1775 0.0551288
R14721 VSSD.n1798 VSSD.n1797 0.0528431
R14722 VSSD.n2491 VSSD.n73 0.04127
R14723 VSSD.n983 VSSD.n924 0.04127
R14724 VSSD.n3142 VSSD.n3113 0.04127
R14725 VSSD.n2159 VSSD.n1108 0.04127
R14726 VSSD.n2885 VSSD.n637 0.04127
R14727 VSSD.n3024 VSSD.n454 0.04127
R14728 VSSD.n2475 VSSD.n804 0.04127
R14729 VSSD.n2831 VSSD.n738 0.04127
R14730 VSSD.n1601 VSSD.n1092 0.04127
R14731 VSSD.n3671 VSSD.n3 0.04127
R14732 VSSD.n2435 VSSD.n2434 0.0393577
R14733 VSSD.n2439 VSSD.n2438 0.0393577
R14734 VSSD.n2443 VSSD.n2442 0.0393577
R14735 VSSD.n2447 VSSD.n2446 0.0393577
R14736 VSSD.n2524 VSSD.n2523 0.0393577
R14737 VSSD.n2528 VSSD.n2527 0.0393577
R14738 VSSD.n2516 VSSD.n2515 0.0393577
R14739 VSSD.n2520 VSSD.n2519 0.0393577
R14740 VSSD.n2570 VSSD.n2569 0.0393577
R14741 VSSD.n2574 VSSD.n2573 0.0393577
R14742 VSSD.n2578 VSSD.n2577 0.0393577
R14743 VSSD.n2582 VSSD.n2581 0.0393577
R14744 VSSD.n3184 VSSD.n3183 0.0393577
R14745 VSSD.n3180 VSSD.n3179 0.0393577
R14746 VSSD.n3192 VSSD.n3191 0.0393577
R14747 VSSD.n3188 VSSD.n3187 0.0393577
R14748 VSSD.n3092 VSSD.n3091 0.0393577
R14749 VSSD.n3096 VSSD.n3095 0.0393577
R14750 VSSD.n3084 VSSD.n3083 0.0393577
R14751 VSSD.n3088 VSSD.n3087 0.0393577
R14752 VSSD.n2953 VSSD.n2952 0.0393577
R14753 VSSD.n2957 VSSD.n2956 0.0393577
R14754 VSSD.n2945 VSSD.n2944 0.0393577
R14755 VSSD.n2949 VSSD.n2948 0.0393577
R14756 VSSD.n2143 VSSD.n2142 0.0393577
R14757 VSSD.n2139 VSSD.n2138 0.0393577
R14758 VSSD.n2151 VSSD.n2150 0.0393577
R14759 VSSD.n2147 VSSD.n2146 0.0393577
R14760 VSSD.n1762 VSSD.n1761 0.0393577
R14761 VSSD.n1758 VSSD.n1757 0.0393577
R14762 VSSD.n1754 VSSD.n1753 0.0393577
R14763 VSSD.n1750 VSSD.n1749 0.0393577
R14764 VSSD.n747 VSSD.n746 0.0393577
R14765 VSSD.n751 VSSD.n750 0.0393577
R14766 VSSD.n755 VSSD.n754 0.0393577
R14767 VSSD.n759 VSSD.n758 0.0393577
R14768 VSSD.n2238 VSSD.n2237 0.0393577
R14769 VSSD.n2242 VSSD.n2241 0.0393577
R14770 VSSD.n2246 VSSD.n2245 0.0393577
R14771 VSSD.n2250 VSSD.n2249 0.0393577
R14772 VSSD.n1811 VSSD.n1810 0.0393577
R14773 VSSD.n1815 VSSD.n1814 0.0393577
R14774 VSSD.n1803 VSSD.n1802 0.0393577
R14775 VSSD.n1807 VSSD.n1806 0.0393577
R14776 VSSD.n1512 VSSD.n1511 0.0356724
R14777 VSSD.n1516 VSSD.n1515 0.0356724
R14778 VSSD.n1504 VSSD.n1503 0.0356724
R14779 VSSD.n1508 VSSD.n1507 0.0356724
R14780 VSSD.n89 VSSD.n88 0.0356724
R14781 VSSD.n93 VSSD.n92 0.0356724
R14782 VSSD.n97 VSSD.n96 0.0356724
R14783 VSSD.n101 VSSD.n100 0.0356724
R14784 VSSD.n2609 VSSD.n2608 0.0356724
R14785 VSSD.n2605 VSSD.n2604 0.0356724
R14786 VSSD.n2617 VSSD.n2616 0.0356724
R14787 VSSD.n2613 VSSD.n2612 0.0356724
R14788 VSSD.n3288 VSSD.n3287 0.0356724
R14789 VSSD.n3292 VSSD.n3291 0.0356724
R14790 VSSD.n3280 VSSD.n3279 0.0356724
R14791 VSSD.n3284 VSSD.n3283 0.0356724
R14792 VSSD.n560 VSSD.n559 0.0356724
R14793 VSSD.n556 VSSD.n555 0.0356724
R14794 VSSD.n552 VSSD.n551 0.0356724
R14795 VSSD.n548 VSSD.n547 0.0356724
R14796 VSSD.n2995 VSSD.n2994 0.0356724
R14797 VSSD.n2999 VSSD.n2998 0.0356724
R14798 VSSD.n2987 VSSD.n2986 0.0356724
R14799 VSSD.n2991 VSSD.n2990 0.0356724
R14800 VSSD.n2856 VSSD.n2855 0.0356724
R14801 VSSD.n2860 VSSD.n2859 0.0356724
R14802 VSSD.n2848 VSSD.n2847 0.0356724
R14803 VSSD.n2852 VSSD.n2851 0.0356724
R14804 VSSD.n852 VSSD.n851 0.0356724
R14805 VSSD.n856 VSSD.n855 0.0356724
R14806 VSSD.n844 VSSD.n843 0.0356724
R14807 VSSD.n848 VSSD.n847 0.0356724
R14808 VSSD.n2352 VSSD.n2351 0.0356724
R14809 VSSD.n2348 VSSD.n2347 0.0356724
R14810 VSSD.n2344 VSSD.n2343 0.0356724
R14811 VSSD.n2340 VSSD.n2339 0.0356724
R14812 VSSD.n1643 VSSD.n1642 0.0356724
R14813 VSSD.n1639 VSSD.n1638 0.0356724
R14814 VSSD.n1651 VSSD.n1650 0.0356724
R14815 VSSD.n1647 VSSD.n1646 0.0356724
R14816 VSSD.n2022 VSSD.n2021 0.0356724
R14817 VSSD.n2018 VSSD.n2017 0.0356724
R14818 VSSD.n2014 VSSD.n2013 0.0356724
R14819 VSSD.n2010 VSSD.n2009 0.0356724
R14820 VSSD.n1510 VSSD.n1509 0.0294655
R14821 VSSD.n1514 VSSD.n1513 0.0294655
R14822 VSSD.n1502 VSSD.n1501 0.0294655
R14823 VSSD.n1506 VSSD.n1505 0.0294655
R14824 VSSD.n87 VSSD.n86 0.0294655
R14825 VSSD.n91 VSSD.n90 0.0294655
R14826 VSSD.n95 VSSD.n94 0.0294655
R14827 VSSD.n99 VSSD.n98 0.0294655
R14828 VSSD.n2611 VSSD.n2610 0.0294655
R14829 VSSD.n2607 VSSD.n2606 0.0294655
R14830 VSSD.n2619 VSSD.n2618 0.0294655
R14831 VSSD.n2615 VSSD.n2614 0.0294655
R14832 VSSD.n3290 VSSD.n3289 0.0294655
R14833 VSSD.n3294 VSSD.n3293 0.0294655
R14834 VSSD.n3282 VSSD.n3281 0.0294655
R14835 VSSD.n3286 VSSD.n3285 0.0294655
R14836 VSSD.n558 VSSD.n557 0.0294655
R14837 VSSD.n554 VSSD.n553 0.0294655
R14838 VSSD.n550 VSSD.n549 0.0294655
R14839 VSSD.n546 VSSD.n334 0.0294655
R14840 VSSD.n2997 VSSD.n2996 0.0294655
R14841 VSSD.n3001 VSSD.n3000 0.0294655
R14842 VSSD.n2989 VSSD.n2988 0.0294655
R14843 VSSD.n2993 VSSD.n2992 0.0294655
R14844 VSSD.n2858 VSSD.n2857 0.0294655
R14845 VSSD.n2862 VSSD.n2861 0.0294655
R14846 VSSD.n2850 VSSD.n2849 0.0294655
R14847 VSSD.n2854 VSSD.n2853 0.0294655
R14848 VSSD.n850 VSSD.n849 0.0294655
R14849 VSSD.n854 VSSD.n853 0.0294655
R14850 VSSD.n842 VSSD.n841 0.0294655
R14851 VSSD.n846 VSSD.n845 0.0294655
R14852 VSSD.n2354 VSSD.n2353 0.0294655
R14853 VSSD.n2350 VSSD.n2349 0.0294655
R14854 VSSD.n2346 VSSD.n2345 0.0294655
R14855 VSSD.n2342 VSSD.n2341 0.0294655
R14856 VSSD.n1645 VSSD.n1644 0.0294655
R14857 VSSD.n1641 VSSD.n1640 0.0294655
R14858 VSSD.n1653 VSSD.n1652 0.0294655
R14859 VSSD.n1649 VSSD.n1648 0.0294655
R14860 VSSD.n2020 VSSD.n2019 0.0294655
R14861 VSSD.n2016 VSSD.n2015 0.0294655
R14862 VSSD.n2012 VSSD.n2011 0.0294655
R14863 VSSD.n2008 VSSD.n1259 0.0294655
R14864 VSSD.n1579 VSSD.n1547 0.0179857
R14865 VSSD.n2661 VSSD.n887 0.0179857
R14866 VSSD.n3609 VSSD.n37 0.0179857
R14867 VSSD.n3218 VSSD.n298 0.0179857
R14868 VSSD.n2099 VSSD.n1170 0.0179857
R14869 VSSD.n2938 VSSD.n593 0.0179857
R14870 VSSD.n3077 VSSD.n410 0.0179857
R14871 VSSD.n2810 VSSD.n782 0.0179857
R14872 VSSD.n2303 VSSD.n1056 0.0179857
R14873 VSSD.n1958 VSSD.n1957 0.0179857
R14874 VSSD.n2636 VSSD.n925 0.0177286
R14875 VSSD.n3143 VSSD.n379 0.0177286
R14876 VSSD.n2047 VSSD.n1209 0.0177286
R14877 VSSD.n2886 VSSD.n632 0.0177286
R14878 VSSD.n3025 VSSD.n449 0.0177286
R14879 VSSD.n2753 VSSD.n805 0.0177286
R14880 VSSD.n2322 VSSD.n1027 0.0177286
R14881 VSSD.n1701 VSSD.n1602 0.0177286
R14882 VSSD.n2445 VSSD.n2444 0.0168795
R14883 VSSD.n2526 VSSD.n2525 0.0168795
R14884 VSSD.n2580 VSSD.n2579 0.0168795
R14885 VSSD.n3190 VSSD.n3189 0.0168795
R14886 VSSD.n3086 VSSD.n3085 0.0168795
R14887 VSSD.n2947 VSSD.n2946 0.0168795
R14888 VSSD.n2149 VSSD.n2148 0.0168795
R14889 VSSD.n1760 VSSD.n1759 0.0168795
R14890 VSSD.n757 VSSD.n756 0.0168795
R14891 VSSD.n2248 VSSD.n2247 0.0168795
R14892 VSSD.n1813 VSSD.n1812 0.0168795
R14893 VSSD.n1867 VSSD.n1521 0.0164429
R14894 VSSD.n1850 VSSD.n1521 0.0164429
R14895 VSSD.n1851 VSSD.n1850 0.0164429
R14896 VSSD.n1852 VSSD.n1851 0.0164429
R14897 VSSD.n1852 VSSD.n1847 0.0164429
R14898 VSSD.n1859 VSSD.n1847 0.0164429
R14899 VSSD.n1859 VSSD.n1858 0.0164429
R14900 VSSD.n1858 VSSD.n1857 0.0164429
R14901 VSSD.n1863 VSSD.n1530 0.0164429
R14902 VSSD.n1834 VSSD.n1825 0.0164429
R14903 VSSD.n1834 VSSD.n1833 0.0164429
R14904 VSSD.n1833 VSSD.n1831 0.0164429
R14905 VSSD.n1831 VSSD.n1829 0.0164429
R14906 VSSD.n1829 VSSD.n1827 0.0164429
R14907 VSSD.n1827 VSSD.n1551 0.0164429
R14908 VSSD.n1840 VSSD.n1551 0.0164429
R14909 VSSD.n1840 VSSD.n1552 0.0164429
R14910 VSSD.n1717 VSSD.n1552 0.0164429
R14911 VSSD.n2711 VSSD.n861 0.0164429
R14912 VSSD.n2697 VSSD.n861 0.0164429
R14913 VSSD.n2698 VSSD.n2697 0.0164429
R14914 VSSD.n2699 VSSD.n2698 0.0164429
R14915 VSSD.n2699 VSSD.n2692 0.0164429
R14916 VSSD.n2704 VSSD.n2692 0.0164429
R14917 VSSD.n2704 VSSD.n2694 0.0164429
R14918 VSSD.n2694 VSSD.n2693 0.0164429
R14919 VSSD.n2707 VSSD.n870 0.0164429
R14920 VSSD.n2459 VSSD.n2458 0.0164429
R14921 VSSD.n2458 VSSD.n2456 0.0164429
R14922 VSSD.n2456 VSSD.n2454 0.0164429
R14923 VSSD.n2454 VSSD.n2452 0.0164429
R14924 VSSD.n2452 VSSD.n2450 0.0164429
R14925 VSSD.n2450 VSSD.n891 0.0164429
R14926 VSSD.n2684 VSSD.n891 0.0164429
R14927 VSSD.n2684 VSSD.n892 0.0164429
R14928 VSSD.n2652 VSSD.n892 0.0164429
R14929 VSSD.n3541 VSSD.n106 0.0164429
R14930 VSSD.n3524 VSSD.n106 0.0164429
R14931 VSSD.n3525 VSSD.n3524 0.0164429
R14932 VSSD.n3526 VSSD.n3525 0.0164429
R14933 VSSD.n3526 VSSD.n3521 0.0164429
R14934 VSSD.n3533 VSSD.n3521 0.0164429
R14935 VSSD.n3533 VSSD.n3532 0.0164429
R14936 VSSD.n3532 VSSD.n3531 0.0164429
R14937 VSSD.n3537 VSSD.n115 0.0164429
R14938 VSSD.n2540 VSSD.n2539 0.0164429
R14939 VSSD.n2539 VSSD.n2538 0.0164429
R14940 VSSD.n2538 VSSD.n2531 0.0164429
R14941 VSSD.n2534 VSSD.n2531 0.0164429
R14942 VSSD.n2534 VSSD.n2533 0.0164429
R14943 VSSD.n2533 VSSD.n136 0.0164429
R14944 VSSD.n3514 VSSD.n136 0.0164429
R14945 VSSD.n3514 VSSD.n137 0.0164429
R14946 VSSD.n3510 VSSD.n137 0.0164429
R14947 VSSD.n3659 VSSD.n11 0.0164429
R14948 VSSD.n3645 VSSD.n11 0.0164429
R14949 VSSD.n3646 VSSD.n3645 0.0164429
R14950 VSSD.n3647 VSSD.n3646 0.0164429
R14951 VSSD.n3647 VSSD.n3640 0.0164429
R14952 VSSD.n3652 VSSD.n3640 0.0164429
R14953 VSSD.n3652 VSSD.n3642 0.0164429
R14954 VSSD.n3642 VSSD.n3641 0.0164429
R14955 VSSD.n3655 VSSD.n20 0.0164429
R14956 VSSD.n2594 VSSD.n2593 0.0164429
R14957 VSSD.n2593 VSSD.n2591 0.0164429
R14958 VSSD.n2591 VSSD.n2589 0.0164429
R14959 VSSD.n2589 VSSD.n2587 0.0164429
R14960 VSSD.n2587 VSSD.n2585 0.0164429
R14961 VSSD.n2585 VSSD.n41 0.0164429
R14962 VSSD.n3632 VSSD.n41 0.0164429
R14963 VSSD.n3632 VSSD.n42 0.0164429
R14964 VSSD.n3600 VSSD.n42 0.0164429
R14965 VSSD.n3260 VSSD.n3254 0.0164429
R14966 VSSD.n3261 VSSD.n3260 0.0164429
R14967 VSSD.n3262 VSSD.n3261 0.0164429
R14968 VSSD.n3262 VSSD.n3250 0.0164429
R14969 VSSD.n3268 VSSD.n3250 0.0164429
R14970 VSSD.n3268 VSSD.n3267 0.0164429
R14971 VSSD.n3267 VSSD.n277 0.0164429
R14972 VSSD.n3273 VSSD.n277 0.0164429
R14973 VSSD.n3272 VSSD.n278 0.0164429
R14974 VSSD.n376 VSSD.n375 0.0164429
R14975 VSSD.n375 VSSD.n373 0.0164429
R14976 VSSD.n373 VSSD.n371 0.0164429
R14977 VSSD.n371 VSSD.n369 0.0164429
R14978 VSSD.n369 VSSD.n367 0.0164429
R14979 VSSD.n367 VSSD.n302 0.0164429
R14980 VSSD.n3241 VSSD.n302 0.0164429
R14981 VSSD.n3241 VSSD.n303 0.0164429
R14982 VSSD.n3209 VSSD.n303 0.0164429
R14983 VSSD.n2057 VSSD.n2053 0.0164429
R14984 VSSD.n2059 VSSD.n2057 0.0164429
R14985 VSSD.n2061 VSSD.n2059 0.0164429
R14986 VSSD.n2062 VSSD.n2061 0.0164429
R14987 VSSD.n2063 VSSD.n2062 0.0164429
R14988 VSSD.n2063 VSSD.n1180 0.0164429
R14989 VSSD.n2097 VSSD.n1180 0.0164429
R14990 VSSD.n2097 VSSD.n1111 0.0164429
R14991 VSSD.n2101 VSSD.n1111 0.0164429
R14992 VSSD.n2100 VSSD.n1112 0.0164429
R14993 VSSD.n1139 VSSD.n1122 0.0164429
R14994 VSSD.n1139 VSSD.n1138 0.0164429
R14995 VSSD.n1138 VSSD.n1137 0.0164429
R14996 VSSD.n1137 VSSD.n1124 0.0164429
R14997 VSSD.n1133 VSSD.n1124 0.0164429
R14998 VSSD.n1133 VSSD.n1132 0.0164429
R14999 VSSD.n1132 VSSD.n1131 0.0164429
R15000 VSSD.n1131 VSSD.n1126 0.0164429
R15001 VSSD.n2896 VSSD.n2892 0.0164429
R15002 VSSD.n2898 VSSD.n2896 0.0164429
R15003 VSSD.n2900 VSSD.n2898 0.0164429
R15004 VSSD.n2901 VSSD.n2900 0.0164429
R15005 VSSD.n2902 VSSD.n2901 0.0164429
R15006 VSSD.n2902 VSSD.n603 0.0164429
R15007 VSSD.n2936 VSSD.n603 0.0164429
R15008 VSSD.n2936 VSSD.n582 0.0164429
R15009 VSSD.n2940 VSSD.n582 0.0164429
R15010 VSSD.n2939 VSSD.n583 0.0164429
R15011 VSSD.n712 VSSD.n711 0.0164429
R15012 VSSD.n716 VSSD.n711 0.0164429
R15013 VSSD.n717 VSSD.n716 0.0164429
R15014 VSSD.n718 VSSD.n717 0.0164429
R15015 VSSD.n718 VSSD.n709 0.0164429
R15016 VSSD.n722 VSSD.n709 0.0164429
R15017 VSSD.n722 VSSD.n684 0.0164429
R15018 VSSD.n727 VSSD.n684 0.0164429
R15019 VSSD.n3035 VSSD.n3031 0.0164429
R15020 VSSD.n3037 VSSD.n3035 0.0164429
R15021 VSSD.n3039 VSSD.n3037 0.0164429
R15022 VSSD.n3040 VSSD.n3039 0.0164429
R15023 VSSD.n3041 VSSD.n3040 0.0164429
R15024 VSSD.n3041 VSSD.n420 0.0164429
R15025 VSSD.n3075 VSSD.n420 0.0164429
R15026 VSSD.n3075 VSSD.n399 0.0164429
R15027 VSSD.n3079 VSSD.n399 0.0164429
R15028 VSSD.n3078 VSSD.n400 0.0164429
R15029 VSSD.n528 VSSD.n527 0.0164429
R15030 VSSD.n532 VSSD.n527 0.0164429
R15031 VSSD.n533 VSSD.n532 0.0164429
R15032 VSSD.n534 VSSD.n533 0.0164429
R15033 VSSD.n534 VSSD.n525 0.0164429
R15034 VSSD.n538 VSSD.n525 0.0164429
R15035 VSSD.n538 VSSD.n500 0.0164429
R15036 VSSD.n543 VSSD.n500 0.0164429
R15037 VSSD.n2815 VSSD.n762 0.0164429
R15038 VSSD.n2774 VSSD.n762 0.0164429
R15039 VSSD.n2775 VSSD.n2774 0.0164429
R15040 VSSD.n2775 VSSD.n786 0.0164429
R15041 VSSD.n2808 VSSD.n786 0.0164429
R15042 VSSD.n2808 VSSD.n2807 0.0164429
R15043 VSSD.n2807 VSSD.n2806 0.0164429
R15044 VSSD.n2806 VSSD.n2805 0.0164429
R15045 VSSD.n2805 VSSD.n774 0.0164429
R15046 VSSD.n2811 VSSD.n771 0.0164429
R15047 VSSD.n2411 VSSD.n2410 0.0164429
R15048 VSSD.n2410 VSSD.n2409 0.0164429
R15049 VSSD.n2409 VSSD.n2371 0.0164429
R15050 VSSD.n2405 VSSD.n2371 0.0164429
R15051 VSSD.n2405 VSSD.n2404 0.0164429
R15052 VSSD.n2404 VSSD.n2403 0.0164429
R15053 VSSD.n2403 VSSD.n2376 0.0164429
R15054 VSSD.n2399 VSSD.n2376 0.0164429
R15055 VSSD.n2261 VSSD.n2257 0.0164429
R15056 VSSD.n2263 VSSD.n2261 0.0164429
R15057 VSSD.n2265 VSSD.n2263 0.0164429
R15058 VSSD.n2266 VSSD.n2265 0.0164429
R15059 VSSD.n2267 VSSD.n2266 0.0164429
R15060 VSSD.n2267 VSSD.n1066 0.0164429
R15061 VSSD.n2301 VSSD.n1066 0.0164429
R15062 VSSD.n2301 VSSD.n1045 0.0164429
R15063 VSSD.n2305 VSSD.n1045 0.0164429
R15064 VSSD.n2304 VSSD.n1046 0.0164429
R15065 VSSD.n2217 VSSD.n2216 0.0164429
R15066 VSSD.n2216 VSSD.n2215 0.0164429
R15067 VSSD.n2215 VSSD.n2177 0.0164429
R15068 VSSD.n2211 VSSD.n2177 0.0164429
R15069 VSSD.n2211 VSSD.n2210 0.0164429
R15070 VSSD.n2210 VSSD.n2209 0.0164429
R15071 VSSD.n2209 VSSD.n2182 0.0164429
R15072 VSSD.n2205 VSSD.n2182 0.0164429
R15073 VSSD.n1950 VSSD.n1936 0.0164429
R15074 VSSD.n1950 VSSD.n1949 0.0164429
R15075 VSSD.n1949 VSSD.n1948 0.0164429
R15076 VSSD.n1948 VSSD.n1947 0.0164429
R15077 VSSD.n1947 VSSD.n1946 0.0164429
R15078 VSSD.n1946 VSSD.n1945 0.0164429
R15079 VSSD.n1945 VSSD.n1944 0.0164429
R15080 VSSD.n1944 VSSD.n1943 0.0164429
R15081 VSSD.n1943 VSSD.n1277 0.0164429
R15082 VSSD.n1959 VSSD.n1273 0.0164429
R15083 VSSD.n1988 VSSD.n1987 0.0164429
R15084 VSSD.n1992 VSSD.n1987 0.0164429
R15085 VSSD.n1993 VSSD.n1992 0.0164429
R15086 VSSD.n1994 VSSD.n1993 0.0164429
R15087 VSSD.n1994 VSSD.n1985 0.0164429
R15088 VSSD.n1998 VSSD.n1985 0.0164429
R15089 VSSD.n1998 VSSD.n1264 0.0164429
R15090 VSSD.n2003 VSSD.n1264 0.0164429
R15091 VSSD.n2437 VSSD.n2436 0.0163567
R15092 VSSD.n2518 VSSD.n2517 0.0163567
R15093 VSSD.n2572 VSSD.n2571 0.0163567
R15094 VSSD.n3182 VSSD.n3181 0.0163567
R15095 VSSD.n3094 VSSD.n3093 0.0163567
R15096 VSSD.n2955 VSSD.n2954 0.0163567
R15097 VSSD.n2141 VSSD.n2140 0.0163567
R15098 VSSD.n1752 VSSD.n1751 0.0163567
R15099 VSSD.n749 VSSD.n748 0.0163567
R15100 VSSD.n2240 VSSD.n2239 0.0163567
R15101 VSSD.n1805 VSSD.n1804 0.0163567
R15102 VSSD.n1868 VSSD.n1520 0.0144152
R15103 VSSD.n1849 VSSD.n1520 0.0144152
R15104 VSSD.n1849 VSSD.n1848 0.0144152
R15105 VSSD.n1853 VSSD.n1848 0.0144152
R15106 VSSD.n1854 VSSD.n1853 0.0144152
R15107 VSSD.n1855 VSSD.n1854 0.0144152
R15108 VSSD.n1856 VSSD.n1855 0.0144152
R15109 VSSD.n3542 VSSD.n105 0.0144152
R15110 VSSD.n3523 VSSD.n105 0.0144152
R15111 VSSD.n3523 VSSD.n3522 0.0144152
R15112 VSSD.n3527 VSSD.n3522 0.0144152
R15113 VSSD.n3528 VSSD.n3527 0.0144152
R15114 VSSD.n3529 VSSD.n3528 0.0144152
R15115 VSSD.n3530 VSSD.n3529 0.0144152
R15116 VSSD.n3660 VSSD.n10 0.0144152
R15117 VSSD.n3644 VSSD.n10 0.0144152
R15118 VSSD.n3644 VSSD.n3643 0.0144152
R15119 VSSD.n3648 VSSD.n3643 0.0144152
R15120 VSSD.n3649 VSSD.n3648 0.0144152
R15121 VSSD.n3651 VSSD.n3649 0.0144152
R15122 VSSD.n3651 VSSD.n3650 0.0144152
R15123 VSSD.n3259 VSSD.n3251 0.0144152
R15124 VSSD.n3263 VSSD.n3251 0.0144152
R15125 VSSD.n3264 VSSD.n3263 0.0144152
R15126 VSSD.n3265 VSSD.n3264 0.0144152
R15127 VSSD.n3266 VSSD.n3265 0.0144152
R15128 VSSD.n3266 VSSD.n276 0.0144152
R15129 VSSD.n3274 VSSD.n276 0.0144152
R15130 VSSD.n1140 VSSD.n1123 0.0144152
R15131 VSSD.n1136 VSSD.n1123 0.0144152
R15132 VSSD.n1136 VSSD.n1135 0.0144152
R15133 VSSD.n1135 VSSD.n1134 0.0144152
R15134 VSSD.n1134 VSSD.n1125 0.0144152
R15135 VSSD.n1130 VSSD.n1125 0.0144152
R15136 VSSD.n1130 VSSD.n1129 0.0144152
R15137 VSSD.n715 VSSD.n714 0.0144152
R15138 VSSD.n715 VSSD.n710 0.0144152
R15139 VSSD.n719 VSSD.n710 0.0144152
R15140 VSSD.n720 VSSD.n719 0.0144152
R15141 VSSD.n721 VSSD.n720 0.0144152
R15142 VSSD.n721 VSSD.n683 0.0144152
R15143 VSSD.n728 VSSD.n683 0.0144152
R15144 VSSD.n531 VSSD.n530 0.0144152
R15145 VSSD.n531 VSSD.n526 0.0144152
R15146 VSSD.n535 VSSD.n526 0.0144152
R15147 VSSD.n536 VSSD.n535 0.0144152
R15148 VSSD.n537 VSSD.n536 0.0144152
R15149 VSSD.n537 VSSD.n499 0.0144152
R15150 VSSD.n544 VSSD.n499 0.0144152
R15151 VSSD.n2712 VSSD.n860 0.0144152
R15152 VSSD.n2696 VSSD.n860 0.0144152
R15153 VSSD.n2696 VSSD.n2695 0.0144152
R15154 VSSD.n2700 VSSD.n2695 0.0144152
R15155 VSSD.n2701 VSSD.n2700 0.0144152
R15156 VSSD.n2703 VSSD.n2701 0.0144152
R15157 VSSD.n2703 VSSD.n2702 0.0144152
R15158 VSSD.n2412 VSSD.n2367 0.0144152
R15159 VSSD.n2408 VSSD.n2367 0.0144152
R15160 VSSD.n2408 VSSD.n2407 0.0144152
R15161 VSSD.n2407 VSSD.n2406 0.0144152
R15162 VSSD.n2406 VSSD.n2372 0.0144152
R15163 VSSD.n2402 VSSD.n2372 0.0144152
R15164 VSSD.n2402 VSSD.n2401 0.0144152
R15165 VSSD.n2218 VSSD.n2173 0.0144152
R15166 VSSD.n2214 VSSD.n2173 0.0144152
R15167 VSSD.n2214 VSSD.n2213 0.0144152
R15168 VSSD.n2213 VSSD.n2212 0.0144152
R15169 VSSD.n2212 VSSD.n2178 0.0144152
R15170 VSSD.n2208 VSSD.n2178 0.0144152
R15171 VSSD.n2208 VSSD.n2207 0.0144152
R15172 VSSD.n1991 VSSD.n1990 0.0144152
R15173 VSSD.n1991 VSSD.n1986 0.0144152
R15174 VSSD.n1995 VSSD.n1986 0.0144152
R15175 VSSD.n1996 VSSD.n1995 0.0144152
R15176 VSSD.n1997 VSSD.n1996 0.0144152
R15177 VSSD.n1997 VSSD.n1263 0.0144152
R15178 VSSD.n2004 VSSD.n1263 0.0144152
R15179 VSSD.n390 VSSD.n385 0.0137143
R15180 VSSD.n3172 VSSD.n3171 0.0137143
R15181 VSSD.n3103 VSSD.n395 0.0137143
R15182 VSSD.n2972 VSSD.n2971 0.0137143
R15183 VSSD.n2477 VSSD.n2476 0.0137143
R15184 VSSD.n2826 VSSD.n740 0.0137143
R15185 VSSD.n2833 VSSD.n2832 0.0137143
R15186 VSSD.n2123 VSSD.n2122 0.0137143
R15187 VSSD.n2112 VSSD.n577 0.0137143
R15188 VSSD.n2131 VSSD.n2105 0.0137143
R15189 VSSD.n2161 VSSD.n2160 0.0137143
R15190 VSSD.n1659 VSSD.n1656 0.0137143
R15191 VSSD.n1742 VSSD.n1741 0.0137143
R15192 VSSD.n2230 VSSD.n1091 0.0137143
R15193 VSSD.n2470 VSSD.n2422 0.0137143
R15194 VSSD.n2552 VSSD.n993 0.0137143
R15195 VSSD.n2565 VSSD.n2564 0.0137143
R15196 VSSD.n3667 VSSD.n2 0.0137143
R15197 VSSD.n2508 VSSD.n2490 0.0137143
R15198 VSSD.n2499 VSSD.n2496 0.0137143
R15199 VSSD.n1793 VSSD.n1725 0.0137143
R15200 VSSD.n1774 VSSD.n1773 0.0137143
R15201 VSSD.n1895 VSSD.n1885 0.0129276
R15202 VSSD.n3569 VSSD.n3559 0.0129276
R15203 VSSD.n2627 VSSD.n969 0.0129276
R15204 VSSD.n3149 VSSD.n355 0.0129276
R15205 VSSD.n1255 VSSD.n1244 0.0129276
R15206 VSSD.n674 VSSD.n663 0.0129276
R15207 VSSD.n491 VSSD.n480 0.0129276
R15208 VSSD.n2739 VSSD.n2729 0.0129276
R15209 VSSD.n2336 VSSD.n1010 0.0129276
R15210 VSSD.n1687 VSSD.n1677 0.0129276
R15211 VSSD.n267 VSSD.n256 0.0129276
R15212 VSSD.n1884 VSSD.n1883 0.0111236
R15213 VSSD.n3558 VSSD.n3557 0.0111236
R15214 VSSD.n974 VSSD.n963 0.0111236
R15215 VSSD.n347 VSSD.n342 0.0111236
R15216 VSSD.n2031 VSSD.n1243 0.0111236
R15217 VSSD.n2864 VSSD.n662 0.0111236
R15218 VSSD.n3003 VSSD.n479 0.0111236
R15219 VSSD.n2728 VSSD.n2727 0.0111236
R15220 VSSD.n1013 VSSD.n1007 0.0111236
R15221 VSSD.n1676 VSSD.n1675 0.0111236
R15222 VSSD.n3296 VSSD.n255 0.0111236
R15223 VSSD.n1956 VSSD.n1289 0.0098
R15224 VSSD.n1323 VSSD.n1289 0.0098
R15225 VSSD.n1324 VSSD.n1323 0.0098
R15226 VSSD.n1325 VSSD.n1324 0.0098
R15227 VSSD.n1325 VSSD.n1320 0.0098
R15228 VSSD.n1329 VSSD.n1320 0.0098
R15229 VSSD.n1330 VSSD.n1329 0.0098
R15230 VSSD.n1331 VSSD.n1330 0.0098
R15231 VSSD.n1331 VSSD.n1318 0.0098
R15232 VSSD.n1578 VSSD.n1577 0.0098
R15233 VSSD.n1582 VSSD.n1577 0.0098
R15234 VSSD.n1583 VSSD.n1582 0.0098
R15235 VSSD.n1584 VSSD.n1583 0.0098
R15236 VSSD.n1584 VSSD.n1575 0.0098
R15237 VSSD.n1588 VSSD.n1575 0.0098
R15238 VSSD.n1589 VSSD.n1588 0.0098
R15239 VSSD.n1590 VSSD.n1589 0.0098
R15240 VSSD.n1590 VSSD.n1573 0.0098
R15241 VSSD.n2282 VSSD.n2281 0.0098
R15242 VSSD.n2283 VSSD.n2282 0.0098
R15243 VSSD.n2283 VSSD.n2279 0.0098
R15244 VSSD.n2287 VSSD.n2279 0.0098
R15245 VSSD.n2288 VSSD.n2287 0.0098
R15246 VSSD.n2289 VSSD.n2288 0.0098
R15247 VSSD.n2289 VSSD.n2277 0.0098
R15248 VSSD.n2294 VSSD.n2277 0.0098
R15249 VSSD.n2294 VSSD.n1078 0.0098
R15250 VSSD.n2799 VSSD.n2798 0.0098
R15251 VSSD.n2798 VSSD.n2782 0.0098
R15252 VSSD.n2794 VSSD.n2782 0.0098
R15253 VSSD.n2794 VSSD.n2793 0.0098
R15254 VSSD.n2793 VSSD.n2792 0.0098
R15255 VSSD.n2792 VSSD.n2784 0.0098
R15256 VSSD.n2788 VSSD.n2784 0.0098
R15257 VSSD.n2788 VSSD.n2787 0.0098
R15258 VSSD.n2787 VSSD.n2786 0.0098
R15259 VSSD.n2663 VSSD.n2662 0.0098
R15260 VSSD.n2664 VSSD.n2663 0.0098
R15261 VSSD.n2664 VSSD.n2658 0.0098
R15262 VSSD.n2669 VSSD.n2658 0.0098
R15263 VSSD.n2669 VSSD.n2659 0.0098
R15264 VSSD.n2659 VSSD.n911 0.0098
R15265 VSSD.n2675 VSSD.n911 0.0098
R15266 VSSD.n2675 VSSD.n909 0.0098
R15267 VSSD.n2679 VSSD.n909 0.0098
R15268 VSSD.n3611 VSSD.n3610 0.0098
R15269 VSSD.n3612 VSSD.n3611 0.0098
R15270 VSSD.n3612 VSSD.n3606 0.0098
R15271 VSSD.n3617 VSSD.n3606 0.0098
R15272 VSSD.n3617 VSSD.n3607 0.0098
R15273 VSSD.n3607 VSSD.n61 0.0098
R15274 VSSD.n3623 VSSD.n61 0.0098
R15275 VSSD.n3623 VSSD.n59 0.0098
R15276 VSSD.n3627 VSSD.n59 0.0098
R15277 VSSD.n3056 VSSD.n3055 0.0098
R15278 VSSD.n3057 VSSD.n3056 0.0098
R15279 VSSD.n3057 VSSD.n3053 0.0098
R15280 VSSD.n3061 VSSD.n3053 0.0098
R15281 VSSD.n3062 VSSD.n3061 0.0098
R15282 VSSD.n3063 VSSD.n3062 0.0098
R15283 VSSD.n3063 VSSD.n3051 0.0098
R15284 VSSD.n3068 VSSD.n3051 0.0098
R15285 VSSD.n3068 VSSD.n432 0.0098
R15286 VSSD.n3220 VSSD.n3219 0.0098
R15287 VSSD.n3221 VSSD.n3220 0.0098
R15288 VSSD.n3221 VSSD.n3215 0.0098
R15289 VSSD.n3226 VSSD.n3215 0.0098
R15290 VSSD.n3226 VSSD.n3216 0.0098
R15291 VSSD.n3216 VSSD.n322 0.0098
R15292 VSSD.n3232 VSSD.n322 0.0098
R15293 VSSD.n3232 VSSD.n320 0.0098
R15294 VSSD.n3236 VSSD.n320 0.0098
R15295 VSSD.n2917 VSSD.n2916 0.0098
R15296 VSSD.n2918 VSSD.n2917 0.0098
R15297 VSSD.n2918 VSSD.n2914 0.0098
R15298 VSSD.n2922 VSSD.n2914 0.0098
R15299 VSSD.n2923 VSSD.n2922 0.0098
R15300 VSSD.n2924 VSSD.n2923 0.0098
R15301 VSSD.n2924 VSSD.n2912 0.0098
R15302 VSSD.n2929 VSSD.n2912 0.0098
R15303 VSSD.n2929 VSSD.n615 0.0098
R15304 VSSD.n2078 VSSD.n2077 0.0098
R15305 VSSD.n2079 VSSD.n2078 0.0098
R15306 VSSD.n2079 VSSD.n2075 0.0098
R15307 VSSD.n2083 VSSD.n2075 0.0098
R15308 VSSD.n2084 VSSD.n2083 0.0098
R15309 VSSD.n2085 VSSD.n2084 0.0098
R15310 VSSD.n2085 VSSD.n2073 0.0098
R15311 VSSD.n2090 VSSD.n2073 0.0098
R15312 VSSD.n2090 VSSD.n1192 0.0098
R15313 VSSD.n2434 VSSD.n2433 0.00938674
R15314 VSSD.n2438 VSSD.n2437 0.00938674
R15315 VSSD.n2442 VSSD.n2441 0.00938674
R15316 VSSD.n2446 VSSD.n2445 0.00938674
R15317 VSSD.n2523 VSSD.n2522 0.00938674
R15318 VSSD.n2527 VSSD.n2526 0.00938674
R15319 VSSD.n2515 VSSD.n2514 0.00938674
R15320 VSSD.n2519 VSSD.n2518 0.00938674
R15321 VSSD.n2569 VSSD.n2568 0.00938674
R15322 VSSD.n2573 VSSD.n2572 0.00938674
R15323 VSSD.n2577 VSSD.n2576 0.00938674
R15324 VSSD.n2581 VSSD.n2580 0.00938674
R15325 VSSD.n3183 VSSD.n3182 0.00938674
R15326 VSSD.n3179 VSSD.n3178 0.00938674
R15327 VSSD.n3191 VSSD.n3190 0.00938674
R15328 VSSD.n3187 VSSD.n3186 0.00938674
R15329 VSSD.n3093 VSSD.n3092 0.00938674
R15330 VSSD.n3097 VSSD.n3096 0.00938674
R15331 VSSD.n3085 VSSD.n3084 0.00938674
R15332 VSSD.n3089 VSSD.n3088 0.00938674
R15333 VSSD.n2954 VSSD.n2953 0.00938674
R15334 VSSD.n2958 VSSD.n2957 0.00938674
R15335 VSSD.n2946 VSSD.n2945 0.00938674
R15336 VSSD.n2950 VSSD.n2949 0.00938674
R15337 VSSD.n2142 VSSD.n2141 0.00938674
R15338 VSSD.n2138 VSSD.n2137 0.00938674
R15339 VSSD.n2150 VSSD.n2149 0.00938674
R15340 VSSD.n2146 VSSD.n2145 0.00938674
R15341 VSSD.n1761 VSSD.n1760 0.00938674
R15342 VSSD.n1757 VSSD.n1756 0.00938674
R15343 VSSD.n1753 VSSD.n1752 0.00938674
R15344 VSSD.n1749 VSSD.n1748 0.00938674
R15345 VSSD.n746 VSSD.n745 0.00938674
R15346 VSSD.n750 VSSD.n749 0.00938674
R15347 VSSD.n754 VSSD.n753 0.00938674
R15348 VSSD.n758 VSSD.n757 0.00938674
R15349 VSSD.n2237 VSSD.n2236 0.00938674
R15350 VSSD.n2241 VSSD.n2240 0.00938674
R15351 VSSD.n2245 VSSD.n2244 0.00938674
R15352 VSSD.n2249 VSSD.n2248 0.00938674
R15353 VSSD.n1810 VSSD.n1809 0.00938674
R15354 VSSD.n1814 VSSD.n1813 0.00938674
R15355 VSSD.n1802 VSSD.n1801 0.00938674
R15356 VSSD.n1806 VSSD.n1805 0.00938674
R15357 VSSD.n1844 VSSD.n1528 0.00895733
R15358 VSSD.n1844 VSSD.n1843 0.00895733
R15359 VSSD.n1846 VSSD.n1527 0.00895733
R15360 VSSD.n1846 VSSD.n1845 0.00895733
R15361 VSSD.n1861 VSSD.n1526 0.00895733
R15362 VSSD.n1861 VSSD.n1860 0.00895733
R15363 VSSD.n1531 VSSD.n1530 0.00895733
R15364 VSSD.n1535 VSSD.n1528 0.00895733
R15365 VSSD.n1538 VSSD.n1527 0.00895733
R15366 VSSD.n1537 VSSD.n1526 0.00895733
R15367 VSSD.n1843 VSSD.n1538 0.00895733
R15368 VSSD.n1845 VSSD.n1537 0.00895733
R15369 VSSD.n1860 VSSD.n1529 0.00895733
R15370 VSSD.n1531 VSSD.n1529 0.00895733
R15371 VSSD.n1707 VSSD.n1543 0.00895733
R15372 VSSD.n1712 VSSD.n1542 0.00895733
R15373 VSSD.n1706 VSSD.n1542 0.00895733
R15374 VSSD.n1711 VSSD.n1541 0.00895733
R15375 VSSD.n1705 VSSD.n1541 0.00895733
R15376 VSSD.n1710 VSSD.n1709 0.00895733
R15377 VSSD.n1709 VSSD.n1550 0.00895733
R15378 VSSD.n1703 VSSD.n1549 0.00895733
R15379 VSSD.n1703 VSSD.n1539 0.00895733
R15380 VSSD.n1712 VSSD.n1544 0.00895733
R15381 VSSD.n1711 VSSD.n1545 0.00895733
R15382 VSSD.n1710 VSSD.n1546 0.00895733
R15383 VSSD.n1841 VSSD.n1549 0.00895733
R15384 VSSD.n1707 VSSD.n1544 0.00895733
R15385 VSSD.n1706 VSSD.n1545 0.00895733
R15386 VSSD.n1705 VSSD.n1546 0.00895733
R15387 VSSD.n1841 VSSD.n1550 0.00895733
R15388 VSSD.n1716 VSSD.n1539 0.00895733
R15389 VSSD.n2688 VSSD.n868 0.00895733
R15390 VSSD.n2688 VSSD.n2687 0.00895733
R15391 VSSD.n2690 VSSD.n867 0.00895733
R15392 VSSD.n2690 VSSD.n2689 0.00895733
R15393 VSSD.n2705 VSSD.n866 0.00895733
R15394 VSSD.n2705 VSSD.n2691 0.00895733
R15395 VSSD.n871 VSSD.n870 0.00895733
R15396 VSSD.n875 VSSD.n868 0.00895733
R15397 VSSD.n878 VSSD.n867 0.00895733
R15398 VSSD.n877 VSSD.n866 0.00895733
R15399 VSSD.n2687 VSSD.n878 0.00895733
R15400 VSSD.n2689 VSSD.n877 0.00895733
R15401 VSSD.n2691 VSSD.n869 0.00895733
R15402 VSSD.n871 VSSD.n869 0.00895733
R15403 VSSD.n2642 VSSD.n883 0.00895733
R15404 VSSD.n2647 VSSD.n882 0.00895733
R15405 VSSD.n2641 VSSD.n882 0.00895733
R15406 VSSD.n2646 VSSD.n881 0.00895733
R15407 VSSD.n2640 VSSD.n881 0.00895733
R15408 VSSD.n2645 VSSD.n2644 0.00895733
R15409 VSSD.n2644 VSSD.n890 0.00895733
R15410 VSSD.n2638 VSSD.n889 0.00895733
R15411 VSSD.n2638 VSSD.n879 0.00895733
R15412 VSSD.n2647 VSSD.n884 0.00895733
R15413 VSSD.n2646 VSSD.n885 0.00895733
R15414 VSSD.n2645 VSSD.n886 0.00895733
R15415 VSSD.n2685 VSSD.n889 0.00895733
R15416 VSSD.n2642 VSSD.n884 0.00895733
R15417 VSSD.n2641 VSSD.n885 0.00895733
R15418 VSSD.n2640 VSSD.n886 0.00895733
R15419 VSSD.n2685 VSSD.n890 0.00895733
R15420 VSSD.n2651 VSSD.n879 0.00895733
R15421 VSSD.n3518 VSSD.n113 0.00895733
R15422 VSSD.n3518 VSSD.n3517 0.00895733
R15423 VSSD.n3520 VSSD.n112 0.00895733
R15424 VSSD.n3520 VSSD.n3519 0.00895733
R15425 VSSD.n3535 VSSD.n111 0.00895733
R15426 VSSD.n3535 VSSD.n3534 0.00895733
R15427 VSSD.n116 VSSD.n115 0.00895733
R15428 VSSD.n120 VSSD.n113 0.00895733
R15429 VSSD.n123 VSSD.n112 0.00895733
R15430 VSSD.n122 VSSD.n111 0.00895733
R15431 VSSD.n3517 VSSD.n123 0.00895733
R15432 VSSD.n3519 VSSD.n122 0.00895733
R15433 VSSD.n3534 VSSD.n114 0.00895733
R15434 VSSD.n116 VSSD.n114 0.00895733
R15435 VSSD.n3500 VSSD.n128 0.00895733
R15436 VSSD.n3505 VSSD.n127 0.00895733
R15437 VSSD.n3499 VSSD.n127 0.00895733
R15438 VSSD.n3504 VSSD.n126 0.00895733
R15439 VSSD.n3498 VSSD.n126 0.00895733
R15440 VSSD.n3503 VSSD.n3502 0.00895733
R15441 VSSD.n3502 VSSD.n135 0.00895733
R15442 VSSD.n3496 VSSD.n134 0.00895733
R15443 VSSD.n3496 VSSD.n124 0.00895733
R15444 VSSD.n3505 VSSD.n129 0.00895733
R15445 VSSD.n3504 VSSD.n130 0.00895733
R15446 VSSD.n3503 VSSD.n131 0.00895733
R15447 VSSD.n3515 VSSD.n134 0.00895733
R15448 VSSD.n3500 VSSD.n129 0.00895733
R15449 VSSD.n3499 VSSD.n130 0.00895733
R15450 VSSD.n3498 VSSD.n131 0.00895733
R15451 VSSD.n3515 VSSD.n135 0.00895733
R15452 VSSD.n3509 VSSD.n124 0.00895733
R15453 VSSD.n3636 VSSD.n18 0.00895733
R15454 VSSD.n3636 VSSD.n3635 0.00895733
R15455 VSSD.n3638 VSSD.n17 0.00895733
R15456 VSSD.n3638 VSSD.n3637 0.00895733
R15457 VSSD.n3653 VSSD.n16 0.00895733
R15458 VSSD.n3653 VSSD.n3639 0.00895733
R15459 VSSD.n21 VSSD.n20 0.00895733
R15460 VSSD.n25 VSSD.n18 0.00895733
R15461 VSSD.n28 VSSD.n17 0.00895733
R15462 VSSD.n27 VSSD.n16 0.00895733
R15463 VSSD.n3635 VSSD.n28 0.00895733
R15464 VSSD.n3637 VSSD.n27 0.00895733
R15465 VSSD.n3639 VSSD.n19 0.00895733
R15466 VSSD.n21 VSSD.n19 0.00895733
R15467 VSSD.n3590 VSSD.n33 0.00895733
R15468 VSSD.n3595 VSSD.n32 0.00895733
R15469 VSSD.n3589 VSSD.n32 0.00895733
R15470 VSSD.n3594 VSSD.n31 0.00895733
R15471 VSSD.n3588 VSSD.n31 0.00895733
R15472 VSSD.n3593 VSSD.n3592 0.00895733
R15473 VSSD.n3592 VSSD.n40 0.00895733
R15474 VSSD.n3586 VSSD.n39 0.00895733
R15475 VSSD.n3586 VSSD.n29 0.00895733
R15476 VSSD.n3595 VSSD.n34 0.00895733
R15477 VSSD.n3594 VSSD.n35 0.00895733
R15478 VSSD.n3593 VSSD.n36 0.00895733
R15479 VSSD.n3633 VSSD.n39 0.00895733
R15480 VSSD.n3590 VSSD.n34 0.00895733
R15481 VSSD.n3589 VSSD.n35 0.00895733
R15482 VSSD.n3588 VSSD.n36 0.00895733
R15483 VSSD.n3633 VSSD.n40 0.00895733
R15484 VSSD.n3599 VSSD.n29 0.00895733
R15485 VSSD.n3252 VSSD.n3245 0.00895733
R15486 VSSD.n3245 VSSD.n3244 0.00895733
R15487 VSSD.n3248 VSSD.n3246 0.00895733
R15488 VSSD.n3248 VSSD.n3247 0.00895733
R15489 VSSD.n3270 VSSD.n3249 0.00895733
R15490 VSSD.n3270 VSSD.n3269 0.00895733
R15491 VSSD.n285 VSSD.n278 0.00895733
R15492 VSSD.n3253 VSSD.n3252 0.00895733
R15493 VSSD.n3246 VSSD.n288 0.00895733
R15494 VSSD.n3249 VSSD.n287 0.00895733
R15495 VSSD.n3244 VSSD.n288 0.00895733
R15496 VSSD.n3247 VSSD.n287 0.00895733
R15497 VSSD.n3269 VSSD.n286 0.00895733
R15498 VSSD.n286 VSSD.n285 0.00895733
R15499 VSSD.n3199 VSSD.n294 0.00895733
R15500 VSSD.n3204 VSSD.n293 0.00895733
R15501 VSSD.n3198 VSSD.n293 0.00895733
R15502 VSSD.n3203 VSSD.n292 0.00895733
R15503 VSSD.n3197 VSSD.n292 0.00895733
R15504 VSSD.n3202 VSSD.n3201 0.00895733
R15505 VSSD.n3201 VSSD.n301 0.00895733
R15506 VSSD.n3195 VSSD.n300 0.00895733
R15507 VSSD.n3195 VSSD.n290 0.00895733
R15508 VSSD.n3204 VSSD.n295 0.00895733
R15509 VSSD.n3203 VSSD.n296 0.00895733
R15510 VSSD.n3202 VSSD.n297 0.00895733
R15511 VSSD.n3242 VSSD.n300 0.00895733
R15512 VSSD.n3199 VSSD.n295 0.00895733
R15513 VSSD.n3198 VSSD.n296 0.00895733
R15514 VSSD.n3197 VSSD.n297 0.00895733
R15515 VSSD.n3242 VSSD.n301 0.00895733
R15516 VSSD.n3208 VSSD.n290 0.00895733
R15517 VSSD.n2055 VSSD.n1169 0.00895733
R15518 VSSD.n1172 VSSD.n1169 0.00895733
R15519 VSSD.n1173 VSSD.n1168 0.00895733
R15520 VSSD.n1175 VSSD.n1168 0.00895733
R15521 VSSD.n1176 VSSD.n1167 0.00895733
R15522 VSSD.n1179 VSSD.n1167 0.00895733
R15523 VSSD.n1178 VSSD.n1112 0.00895733
R15524 VSSD.n2056 VSSD.n2055 0.00895733
R15525 VSSD.n1174 VSSD.n1173 0.00895733
R15526 VSSD.n1177 VSSD.n1176 0.00895733
R15527 VSSD.n1174 VSSD.n1172 0.00895733
R15528 VSSD.n1177 VSSD.n1175 0.00895733
R15529 VSSD.n2098 VSSD.n1179 0.00895733
R15530 VSSD.n2098 VSSD.n1178 0.00895733
R15531 VSSD.n1151 VSSD.n1142 0.00895733
R15532 VSSD.n1157 VSSD.n1118 0.00895733
R15533 VSSD.n1150 VSSD.n1118 0.00895733
R15534 VSSD.n1156 VSSD.n1119 0.00895733
R15535 VSSD.n1149 VSSD.n1119 0.00895733
R15536 VSSD.n1155 VSSD.n1120 0.00895733
R15537 VSSD.n1148 VSSD.n1120 0.00895733
R15538 VSSD.n1154 VSSD.n1121 0.00895733
R15539 VSSD.n1143 VSSD.n1121 0.00895733
R15540 VSSD.n1157 VSSD.n1117 0.00895733
R15541 VSSD.n1156 VSSD.n1116 0.00895733
R15542 VSSD.n1155 VSSD.n1115 0.00895733
R15543 VSSD.n1154 VSSD.n1114 0.00895733
R15544 VSSD.n1151 VSSD.n1117 0.00895733
R15545 VSSD.n1150 VSSD.n1116 0.00895733
R15546 VSSD.n1149 VSSD.n1115 0.00895733
R15547 VSSD.n1148 VSSD.n1114 0.00895733
R15548 VSSD.n1143 VSSD.n1113 0.00895733
R15549 VSSD.n2894 VSSD.n592 0.00895733
R15550 VSSD.n595 VSSD.n592 0.00895733
R15551 VSSD.n596 VSSD.n591 0.00895733
R15552 VSSD.n598 VSSD.n591 0.00895733
R15553 VSSD.n599 VSSD.n590 0.00895733
R15554 VSSD.n602 VSSD.n590 0.00895733
R15555 VSSD.n601 VSSD.n583 0.00895733
R15556 VSSD.n2895 VSSD.n2894 0.00895733
R15557 VSSD.n597 VSSD.n596 0.00895733
R15558 VSSD.n600 VSSD.n599 0.00895733
R15559 VSSD.n597 VSSD.n595 0.00895733
R15560 VSSD.n600 VSSD.n598 0.00895733
R15561 VSSD.n2937 VSSD.n602 0.00895733
R15562 VSSD.n2937 VSSD.n601 0.00895733
R15563 VSSD.n700 VSSD.n692 0.00895733
R15564 VSSD.n704 VSSD.n691 0.00895733
R15565 VSSD.n699 VSSD.n691 0.00895733
R15566 VSSD.n703 VSSD.n690 0.00895733
R15567 VSSD.n698 VSSD.n690 0.00895733
R15568 VSSD.n708 VSSD.n707 0.00895733
R15569 VSSD.n708 VSSD.n702 0.00895733
R15570 VSSD.n696 VSSD.n688 0.00895733
R15571 VSSD.n725 VSSD.n688 0.00895733
R15572 VSSD.n704 VSSD.n693 0.00895733
R15573 VSSD.n703 VSSD.n694 0.00895733
R15574 VSSD.n707 VSSD.n695 0.00895733
R15575 VSSD.n723 VSSD.n696 0.00895733
R15576 VSSD.n700 VSSD.n693 0.00895733
R15577 VSSD.n699 VSSD.n694 0.00895733
R15578 VSSD.n698 VSSD.n695 0.00895733
R15579 VSSD.n723 VSSD.n702 0.00895733
R15580 VSSD.n726 VSSD.n725 0.00895733
R15581 VSSD.n3033 VSSD.n409 0.00895733
R15582 VSSD.n412 VSSD.n409 0.00895733
R15583 VSSD.n413 VSSD.n408 0.00895733
R15584 VSSD.n415 VSSD.n408 0.00895733
R15585 VSSD.n416 VSSD.n407 0.00895733
R15586 VSSD.n419 VSSD.n407 0.00895733
R15587 VSSD.n418 VSSD.n400 0.00895733
R15588 VSSD.n3034 VSSD.n3033 0.00895733
R15589 VSSD.n414 VSSD.n413 0.00895733
R15590 VSSD.n417 VSSD.n416 0.00895733
R15591 VSSD.n414 VSSD.n412 0.00895733
R15592 VSSD.n417 VSSD.n415 0.00895733
R15593 VSSD.n3076 VSSD.n419 0.00895733
R15594 VSSD.n3076 VSSD.n418 0.00895733
R15595 VSSD.n516 VSSD.n508 0.00895733
R15596 VSSD.n520 VSSD.n507 0.00895733
R15597 VSSD.n515 VSSD.n507 0.00895733
R15598 VSSD.n519 VSSD.n506 0.00895733
R15599 VSSD.n514 VSSD.n506 0.00895733
R15600 VSSD.n524 VSSD.n523 0.00895733
R15601 VSSD.n524 VSSD.n518 0.00895733
R15602 VSSD.n512 VSSD.n504 0.00895733
R15603 VSSD.n541 VSSD.n504 0.00895733
R15604 VSSD.n520 VSSD.n509 0.00895733
R15605 VSSD.n519 VSSD.n510 0.00895733
R15606 VSSD.n523 VSSD.n511 0.00895733
R15607 VSSD.n539 VSSD.n512 0.00895733
R15608 VSSD.n516 VSSD.n509 0.00895733
R15609 VSSD.n515 VSSD.n510 0.00895733
R15610 VSSD.n514 VSSD.n511 0.00895733
R15611 VSSD.n539 VSSD.n518 0.00895733
R15612 VSSD.n542 VSSD.n541 0.00895733
R15613 VSSD.n781 VSSD.n769 0.00895733
R15614 VSSD.n783 VSSD.n781 0.00895733
R15615 VSSD.n780 VSSD.n768 0.00895733
R15616 VSSD.n785 VSSD.n780 0.00895733
R15617 VSSD.n779 VSSD.n767 0.00895733
R15618 VSSD.n779 VSSD.n778 0.00895733
R15619 VSSD.n772 VSSD.n771 0.00895733
R15620 VSSD.n776 VSSD.n769 0.00895733
R15621 VSSD.n784 VSSD.n768 0.00895733
R15622 VSSD.n2809 VSSD.n767 0.00895733
R15623 VSSD.n784 VSSD.n783 0.00895733
R15624 VSSD.n2809 VSSD.n785 0.00895733
R15625 VSSD.n778 VSSD.n770 0.00895733
R15626 VSSD.n772 VSSD.n770 0.00895733
R15627 VSSD.n2385 VSSD.n2368 0.00895733
R15628 VSSD.n2392 VSSD.n2370 0.00895733
R15629 VSSD.n2384 VSSD.n2370 0.00895733
R15630 VSSD.n2391 VSSD.n2373 0.00895733
R15631 VSSD.n2383 VSSD.n2373 0.00895733
R15632 VSSD.n2386 VSSD.n2375 0.00895733
R15633 VSSD.n2382 VSSD.n2375 0.00895733
R15634 VSSD.n2398 VSSD.n2378 0.00895733
R15635 VSSD.n2398 VSSD.n2380 0.00895733
R15636 VSSD.n2392 VSSD.n2369 0.00895733
R15637 VSSD.n2391 VSSD.n2390 0.00895733
R15638 VSSD.n2386 VSSD.n2374 0.00895733
R15639 VSSD.n2388 VSSD.n2378 0.00895733
R15640 VSSD.n2385 VSSD.n2369 0.00895733
R15641 VSSD.n2390 VSSD.n2384 0.00895733
R15642 VSSD.n2383 VSSD.n2374 0.00895733
R15643 VSSD.n2388 VSSD.n2382 0.00895733
R15644 VSSD.n2380 VSSD.n2377 0.00895733
R15645 VSSD.n2259 VSSD.n1055 0.00895733
R15646 VSSD.n1058 VSSD.n1055 0.00895733
R15647 VSSD.n1059 VSSD.n1054 0.00895733
R15648 VSSD.n1061 VSSD.n1054 0.00895733
R15649 VSSD.n1062 VSSD.n1053 0.00895733
R15650 VSSD.n1065 VSSD.n1053 0.00895733
R15651 VSSD.n1064 VSSD.n1046 0.00895733
R15652 VSSD.n2260 VSSD.n2259 0.00895733
R15653 VSSD.n1060 VSSD.n1059 0.00895733
R15654 VSSD.n1063 VSSD.n1062 0.00895733
R15655 VSSD.n1060 VSSD.n1058 0.00895733
R15656 VSSD.n1063 VSSD.n1061 0.00895733
R15657 VSSD.n2302 VSSD.n1065 0.00895733
R15658 VSSD.n2302 VSSD.n1064 0.00895733
R15659 VSSD.n2191 VSSD.n2174 0.00895733
R15660 VSSD.n2198 VSSD.n2176 0.00895733
R15661 VSSD.n2190 VSSD.n2176 0.00895733
R15662 VSSD.n2197 VSSD.n2179 0.00895733
R15663 VSSD.n2189 VSSD.n2179 0.00895733
R15664 VSSD.n2192 VSSD.n2181 0.00895733
R15665 VSSD.n2188 VSSD.n2181 0.00895733
R15666 VSSD.n2204 VSSD.n2184 0.00895733
R15667 VSSD.n2204 VSSD.n2186 0.00895733
R15668 VSSD.n2198 VSSD.n2175 0.00895733
R15669 VSSD.n2197 VSSD.n2196 0.00895733
R15670 VSSD.n2192 VSSD.n2180 0.00895733
R15671 VSSD.n2194 VSSD.n2184 0.00895733
R15672 VSSD.n2191 VSSD.n2175 0.00895733
R15673 VSSD.n2196 VSSD.n2190 0.00895733
R15674 VSSD.n2189 VSSD.n2180 0.00895733
R15675 VSSD.n2194 VSSD.n2188 0.00895733
R15676 VSSD.n2186 VSSD.n2183 0.00895733
R15677 VSSD.n1280 VSSD.n1268 0.00895733
R15678 VSSD.n1275 VSSD.n1268 0.00895733
R15679 VSSD.n1279 VSSD.n1267 0.00895733
R15680 VSSD.n1274 VSSD.n1267 0.00895733
R15681 VSSD.n1278 VSSD.n1266 0.00895733
R15682 VSSD.n1285 VSSD.n1266 0.00895733
R15683 VSSD.n1273 VSSD.n1265 0.00895733
R15684 VSSD.n1280 VSSD.n1270 0.00895733
R15685 VSSD.n1279 VSSD.n1271 0.00895733
R15686 VSSD.n1278 VSSD.n1272 0.00895733
R15687 VSSD.n1275 VSSD.n1271 0.00895733
R15688 VSSD.n1274 VSSD.n1272 0.00895733
R15689 VSSD.n1286 VSSD.n1285 0.00895733
R15690 VSSD.n1286 VSSD.n1265 0.00895733
R15691 VSSD.n1976 VSSD.n1968 0.00895733
R15692 VSSD.n1980 VSSD.n1967 0.00895733
R15693 VSSD.n1975 VSSD.n1967 0.00895733
R15694 VSSD.n1979 VSSD.n1966 0.00895733
R15695 VSSD.n1974 VSSD.n1966 0.00895733
R15696 VSSD.n1984 VSSD.n1983 0.00895733
R15697 VSSD.n1984 VSSD.n1978 0.00895733
R15698 VSSD.n1972 VSSD.n1964 0.00895733
R15699 VSSD.n2001 VSSD.n1964 0.00895733
R15700 VSSD.n1980 VSSD.n1969 0.00895733
R15701 VSSD.n1979 VSSD.n1970 0.00895733
R15702 VSSD.n1983 VSSD.n1971 0.00895733
R15703 VSSD.n1999 VSSD.n1972 0.00895733
R15704 VSSD.n1976 VSSD.n1969 0.00895733
R15705 VSSD.n1975 VSSD.n1970 0.00895733
R15706 VSSD.n1974 VSSD.n1971 0.00895733
R15707 VSSD.n1999 VSSD.n1978 0.00895733
R15708 VSSD.n2002 VSSD.n2001 0.00895733
R15709 VSSD.n1535 VSSD.n1522 0.00895733
R15710 VSSD.n1866 VSSD.n1522 0.00895733
R15711 VSSD.n875 VSSD.n862 0.00895733
R15712 VSSD.n2710 VSSD.n862 0.00895733
R15713 VSSD.n120 VSSD.n107 0.00895733
R15714 VSSD.n3540 VSSD.n107 0.00895733
R15715 VSSD.n25 VSSD.n12 0.00895733
R15716 VSSD.n3658 VSSD.n12 0.00895733
R15717 VSSD.n3253 VSSD.n289 0.00895733
R15718 VSSD.n3257 VSSD.n289 0.00895733
R15719 VSSD.n2056 VSSD.n1171 0.00895733
R15720 VSSD.n2052 VSSD.n1171 0.00895733
R15721 VSSD.n2895 VSSD.n594 0.00895733
R15722 VSSD.n2891 VSSD.n594 0.00895733
R15723 VSSD.n3034 VSSD.n411 0.00895733
R15724 VSSD.n3030 VSSD.n411 0.00895733
R15725 VSSD.n776 VSSD.n763 0.00895733
R15726 VSSD.n2814 VSSD.n763 0.00895733
R15727 VSSD.n2260 VSSD.n1057 0.00895733
R15728 VSSD.n2256 VSSD.n1057 0.00895733
R15729 VSSD.n1287 VSSD.n1270 0.00895733
R15730 VSSD.n1935 VSSD.n1287 0.00895733
R15731 VSSD.n1857 VSSD.n1533 0.00884136
R15732 VSSD.n2693 VSSD.n873 0.00884136
R15733 VSSD.n3531 VSSD.n118 0.00884136
R15734 VSSD.n3641 VSSD.n23 0.00884136
R15735 VSSD.n3258 VSSD.n3254 0.00884136
R15736 VSSD.n1141 VSSD.n1122 0.00884136
R15737 VSSD.n713 VSSD.n712 0.00884136
R15738 VSSD.n529 VSSD.n528 0.00884136
R15739 VSSD.n2400 VSSD.n2399 0.00884136
R15740 VSSD.n2206 VSSD.n2205 0.00884136
R15741 VSSD.n1989 VSSD.n1988 0.00884136
R15742 VSSD.n1908 VSSD.n1477 0.00875819
R15743 VSSD.n1906 VSSD.n1494 0.00875819
R15744 VSSD.n1906 VSSD.n1905 0.00875819
R15745 VSSD.n1495 VSSD.n1493 0.00875819
R15746 VSSD.n1492 VSSD.n1483 0.00875819
R15747 VSSD.n1903 VSSD.n1491 0.00875819
R15748 VSSD.n1489 VSSD.n1484 0.00875819
R15749 VSSD.n1487 VSSD.n1484 0.00875819
R15750 VSSD.n1486 VSSD.n1485 0.00875819
R15751 VSSD.n1494 VSSD.n1482 0.00875819
R15752 VSSD.n1496 VSSD.n1495 0.00875819
R15753 VSSD.n1482 VSSD.n1477 0.00875819
R15754 VSSD.n1905 VSSD.n1496 0.00875819
R15755 VSSD.n1903 VSSD.n1483 0.00875819
R15756 VSSD.n1488 VSSD.n1487 0.00875819
R15757 VSSD.n1493 VSSD.n1492 0.00875819
R15758 VSSD.n1488 VSSD.n1486 0.00875819
R15759 VSSD.n1491 VSSD.n1489 0.00875819
R15760 VSSD.n1882 VSSD.n1879 0.00851782
R15761 VSSD.n3556 VSSD.n3553 0.00851782
R15762 VSSD.n2621 VSSD.n975 0.00851782
R15763 VSSD.n3153 VSSD.n337 0.00851782
R15764 VSSD.n2033 VSSD.n2032 0.00851782
R15765 VSSD.n2866 VSSD.n2865 0.00851782
R15766 VSSD.n3005 VSSD.n3004 0.00851782
R15767 VSSD.n2726 VSSD.n2723 0.00851782
R15768 VSSD.n2338 VSSD.n1000 0.00851782
R15769 VSSD.n1674 VSSD.n1671 0.00851782
R15770 VSSD.n3298 VSSD.n3297 0.00851782
R15771 VSSD.n1580 VSSD.n1579 0.00847143
R15772 VSSD.n1581 VSSD.n1580 0.00847143
R15773 VSSD.n1581 VSSD.n1576 0.00847143
R15774 VSSD.n1585 VSSD.n1576 0.00847143
R15775 VSSD.n1586 VSSD.n1585 0.00847143
R15776 VSSD.n1587 VSSD.n1586 0.00847143
R15777 VSSD.n1587 VSSD.n1574 0.00847143
R15778 VSSD.n1591 VSSD.n1574 0.00847143
R15779 VSSD.n2661 VSSD.n2660 0.00847143
R15780 VSSD.n2665 VSSD.n2660 0.00847143
R15781 VSSD.n2666 VSSD.n2665 0.00847143
R15782 VSSD.n2668 VSSD.n2666 0.00847143
R15783 VSSD.n2668 VSSD.n2667 0.00847143
R15784 VSSD.n2667 VSSD.n910 0.00847143
R15785 VSSD.n2676 VSSD.n910 0.00847143
R15786 VSSD.n2677 VSSD.n2676 0.00847143
R15787 VSSD.n3609 VSSD.n3608 0.00847143
R15788 VSSD.n3613 VSSD.n3608 0.00847143
R15789 VSSD.n3614 VSSD.n3613 0.00847143
R15790 VSSD.n3616 VSSD.n3614 0.00847143
R15791 VSSD.n3616 VSSD.n3615 0.00847143
R15792 VSSD.n3615 VSSD.n60 0.00847143
R15793 VSSD.n3624 VSSD.n60 0.00847143
R15794 VSSD.n3625 VSSD.n3624 0.00847143
R15795 VSSD.n81 VSSD.n69 0.00847143
R15796 VSSD.n956 VSSD.n918 0.00847143
R15797 VSSD.n3218 VSSD.n3217 0.00847143
R15798 VSSD.n3222 VSSD.n3217 0.00847143
R15799 VSSD.n3223 VSSD.n3222 0.00847143
R15800 VSSD.n3225 VSSD.n3223 0.00847143
R15801 VSSD.n3225 VSSD.n3224 0.00847143
R15802 VSSD.n3224 VSSD.n321 0.00847143
R15803 VSSD.n3233 VSSD.n321 0.00847143
R15804 VSSD.n3234 VSSD.n3233 0.00847143
R15805 VSSD.n361 VSSD.n357 0.00847143
R15806 VSSD.n1239 VSSD.n1203 0.00847143
R15807 VSSD.n2076 VSSD.n1170 0.00847143
R15808 VSSD.n2080 VSSD.n2076 0.00847143
R15809 VSSD.n2081 VSSD.n2080 0.00847143
R15810 VSSD.n2082 VSSD.n2081 0.00847143
R15811 VSSD.n2082 VSSD.n2074 0.00847143
R15812 VSSD.n2086 VSSD.n2074 0.00847143
R15813 VSSD.n2087 VSSD.n2086 0.00847143
R15814 VSSD.n2089 VSSD.n2087 0.00847143
R15815 VSSD.n658 VSSD.n626 0.00847143
R15816 VSSD.n2915 VSSD.n593 0.00847143
R15817 VSSD.n2919 VSSD.n2915 0.00847143
R15818 VSSD.n2920 VSSD.n2919 0.00847143
R15819 VSSD.n2921 VSSD.n2920 0.00847143
R15820 VSSD.n2921 VSSD.n2913 0.00847143
R15821 VSSD.n2925 VSSD.n2913 0.00847143
R15822 VSSD.n2926 VSSD.n2925 0.00847143
R15823 VSSD.n2928 VSSD.n2926 0.00847143
R15824 VSSD.n475 VSSD.n443 0.00847143
R15825 VSSD.n3054 VSSD.n410 0.00847143
R15826 VSSD.n3058 VSSD.n3054 0.00847143
R15827 VSSD.n3059 VSSD.n3058 0.00847143
R15828 VSSD.n3060 VSSD.n3059 0.00847143
R15829 VSSD.n3060 VSSD.n3052 0.00847143
R15830 VSSD.n3064 VSSD.n3052 0.00847143
R15831 VSSD.n3065 VSSD.n3064 0.00847143
R15832 VSSD.n3067 VSSD.n3065 0.00847143
R15833 VSSD.n836 VSSD.n798 0.00847143
R15834 VSSD.n2797 VSSD.n782 0.00847143
R15835 VSSD.n2797 VSSD.n2796 0.00847143
R15836 VSSD.n2796 VSSD.n2795 0.00847143
R15837 VSSD.n2795 VSSD.n2783 0.00847143
R15838 VSSD.n2791 VSSD.n2783 0.00847143
R15839 VSSD.n2791 VSSD.n2790 0.00847143
R15840 VSSD.n2790 VSSD.n2789 0.00847143
R15841 VSSD.n2789 VSSD.n2785 0.00847143
R15842 VSSD.n2320 VSSD.n1019 0.00847143
R15843 VSSD.n2280 VSSD.n1056 0.00847143
R15844 VSSD.n2284 VSSD.n2280 0.00847143
R15845 VSSD.n2285 VSSD.n2284 0.00847143
R15846 VSSD.n2286 VSSD.n2285 0.00847143
R15847 VSSD.n2286 VSSD.n2278 0.00847143
R15848 VSSD.n2290 VSSD.n2278 0.00847143
R15849 VSSD.n2291 VSSD.n2290 0.00847143
R15850 VSSD.n2293 VSSD.n2291 0.00847143
R15851 VSSD.n1633 VSSD.n1595 0.00847143
R15852 VSSD.n1957 VSSD.n1288 0.00847143
R15853 VSSD.n1322 VSSD.n1288 0.00847143
R15854 VSSD.n1322 VSSD.n1321 0.00847143
R15855 VSSD.n1326 VSSD.n1321 0.00847143
R15856 VSSD.n1327 VSSD.n1326 0.00847143
R15857 VSSD.n1328 VSSD.n1327 0.00847143
R15858 VSSD.n1328 VSSD.n1319 0.00847143
R15859 VSSD.n1332 VSSD.n1319 0.00847143
R15860 VSSD.n251 VSSD.n242 0.00847143
R15861 VSSD.n81 VSSD.n80 0.00796001
R15862 VSSD.n836 VSSD.n835 0.00796001
R15863 VSSD.n1633 VSSD.n1632 0.00796001
R15864 VSSD.n3576 VSSD.n80 0.007947
R15865 VSSD.n2746 VSSD.n835 0.007947
R15866 VSSD.n1694 VSSD.n1632 0.007947
R15867 VSSD.n2436 VSSD.n2435 0.00781849
R15868 VSSD.n2440 VSSD.n2439 0.00781849
R15869 VSSD.n2444 VSSD.n2443 0.00781849
R15870 VSSD.n2448 VSSD.n2447 0.00781849
R15871 VSSD.n2525 VSSD.n2524 0.00781849
R15872 VSSD.n2529 VSSD.n2528 0.00781849
R15873 VSSD.n2517 VSSD.n2516 0.00781849
R15874 VSSD.n2521 VSSD.n2520 0.00781849
R15875 VSSD.n2571 VSSD.n2570 0.00781849
R15876 VSSD.n2575 VSSD.n2574 0.00781849
R15877 VSSD.n2579 VSSD.n2578 0.00781849
R15878 VSSD.n2583 VSSD.n2582 0.00781849
R15879 VSSD.n3185 VSSD.n3184 0.00781849
R15880 VSSD.n3181 VSSD.n3180 0.00781849
R15881 VSSD.n3193 VSSD.n3192 0.00781849
R15882 VSSD.n3189 VSSD.n3188 0.00781849
R15883 VSSD.n3091 VSSD.n3090 0.00781849
R15884 VSSD.n3095 VSSD.n3094 0.00781849
R15885 VSSD.n3083 VSSD.n3082 0.00781849
R15886 VSSD.n3087 VSSD.n3086 0.00781849
R15887 VSSD.n2952 VSSD.n2951 0.00781849
R15888 VSSD.n2956 VSSD.n2955 0.00781849
R15889 VSSD.n2944 VSSD.n2943 0.00781849
R15890 VSSD.n2948 VSSD.n2947 0.00781849
R15891 VSSD.n2144 VSSD.n2143 0.00781849
R15892 VSSD.n2140 VSSD.n2139 0.00781849
R15893 VSSD.n2152 VSSD.n2151 0.00781849
R15894 VSSD.n2148 VSSD.n2147 0.00781849
R15895 VSSD.n1763 VSSD.n1762 0.00781849
R15896 VSSD.n1759 VSSD.n1758 0.00781849
R15897 VSSD.n1755 VSSD.n1754 0.00781849
R15898 VSSD.n1751 VSSD.n1750 0.00781849
R15899 VSSD.n748 VSSD.n747 0.00781849
R15900 VSSD.n752 VSSD.n751 0.00781849
R15901 VSSD.n756 VSSD.n755 0.00781849
R15902 VSSD.n760 VSSD.n759 0.00781849
R15903 VSSD.n2239 VSSD.n2238 0.00781849
R15904 VSSD.n2243 VSSD.n2242 0.00781849
R15905 VSSD.n2247 VSSD.n2246 0.00781849
R15906 VSSD.n2251 VSSD.n2250 0.00781849
R15907 VSSD.n1812 VSSD.n1811 0.00781849
R15908 VSSD.n1816 VSSD.n1815 0.00781849
R15909 VSSD.n1804 VSSD.n1803 0.00781849
R15910 VSSD.n1808 VSSD.n1807 0.00781849
R15911 VSSD.n2630 VSSD.n956 0.0074619
R15912 VSSD.n3146 VSSD.n357 0.0074619
R15913 VSSD.n2040 VSSD.n1239 0.0074619
R15914 VSSD.n2873 VSSD.n658 0.0074619
R15915 VSSD.n3012 VSSD.n475 0.0074619
R15916 VSSD.n2328 VSSD.n1019 0.0074619
R15917 VSSD.n3305 VSSD.n251 0.0074619
R15918 VSSD.n2630 VSSD.n2629 0.00744864
R15919 VSSD.n3147 VSSD.n3146 0.00744864
R15920 VSSD.n2040 VSSD.n2039 0.00744864
R15921 VSSD.n2873 VSSD.n2872 0.00744864
R15922 VSSD.n3012 VSSD.n3011 0.00744864
R15923 VSSD.n2329 VSSD.n2328 0.00744864
R15924 VSSD.n3305 VSSD.n3304 0.00744864
R15925 VSSD.n1900 VSSD.n1894 0.00720524
R15926 VSSD.n1889 VSSD.n1885 0.00720524
R15927 VSSD.n1890 VSSD.n1884 0.00720524
R15928 VSSD.n1887 VSSD.n1499 0.00720524
R15929 VSSD.n1891 VSSD.n1881 0.00720524
R15930 VSSD.n1898 VSSD.n1500 0.00720524
R15931 VSSD.n1891 VSSD.n1500 0.00720524
R15932 VSSD.n1890 VSSD.n1499 0.00720524
R15933 VSSD.n1889 VSSD.n1498 0.00720524
R15934 VSSD.n1895 VSSD.n1894 0.00720524
R15935 VSSD.n1887 VSSD.n1881 0.00720524
R15936 VSSD.n1898 VSSD.n1880 0.00720524
R15937 VSSD.n3574 VSSD.n3568 0.00720524
R15938 VSSD.n3563 VSSD.n3559 0.00720524
R15939 VSSD.n3564 VSSD.n3558 0.00720524
R15940 VSSD.n3561 VSSD.n84 0.00720524
R15941 VSSD.n3565 VSSD.n3555 0.00720524
R15942 VSSD.n3572 VSSD.n85 0.00720524
R15943 VSSD.n3565 VSSD.n85 0.00720524
R15944 VSSD.n3564 VSSD.n84 0.00720524
R15945 VSSD.n3563 VSSD.n83 0.00720524
R15946 VSSD.n3569 VSSD.n3568 0.00720524
R15947 VSSD.n3561 VSSD.n3555 0.00720524
R15948 VSSD.n3572 VSSD.n3554 0.00720524
R15949 VSSD.n2625 VSSD.n964 0.00720524
R15950 VSSD.n2624 VSSD.n958 0.00720524
R15951 VSSD.n966 VSSD.n959 0.00720524
R15952 VSSD.n971 VSSD.n959 0.00720524
R15953 VSSD.n967 VSSD.n960 0.00720524
R15954 VSSD.n972 VSSD.n960 0.00720524
R15955 VSSD.n972 VSSD.n961 0.00720524
R15956 VSSD.n971 VSSD.n962 0.00720524
R15957 VSSD.n2625 VSSD.n2624 0.00720524
R15958 VSSD.n967 VSSD.n962 0.00720524
R15959 VSSD.n966 VSSD.n963 0.00720524
R15960 VSSD.n969 VSSD.n964 0.00720524
R15961 VSSD.n351 VSSD.n341 0.00720524
R15962 VSSD.n353 VSSD.n351 0.00720524
R15963 VSSD.n350 VSSD.n340 0.00720524
R15964 VSSD.n350 VSSD.n349 0.00720524
R15965 VSSD.n348 VSSD.n339 0.00720524
R15966 VSSD.n3151 VSSD.n343 0.00720524
R15967 VSSD.n352 VSSD.n341 0.00720524
R15968 VSSD.n354 VSSD.n340 0.00720524
R15969 VSSD.n3149 VSSD.n339 0.00720524
R15970 VSSD.n354 VSSD.n353 0.00720524
R15971 VSSD.n349 VSSD.n342 0.00720524
R15972 VSSD.n355 VSSD.n343 0.00720524
R15973 VSSD.n2037 VSSD.n1248 0.00720524
R15974 VSSD.n2037 VSSD.n1250 0.00720524
R15975 VSSD.n1258 VSSD.n1247 0.00720524
R15976 VSSD.n1253 VSSD.n1247 0.00720524
R15977 VSSD.n1257 VSSD.n1246 0.00720524
R15978 VSSD.n2035 VSSD.n1245 0.00720524
R15979 VSSD.n1248 VSSD.n1241 0.00720524
R15980 VSSD.n1258 VSSD.n1242 0.00720524
R15981 VSSD.n1257 VSSD.n1244 0.00720524
R15982 VSSD.n1250 VSSD.n1242 0.00720524
R15983 VSSD.n1253 VSSD.n1243 0.00720524
R15984 VSSD.n1255 VSSD.n1245 0.00720524
R15985 VSSD.n2870 VSSD.n667 0.00720524
R15986 VSSD.n2870 VSSD.n669 0.00720524
R15987 VSSD.n677 VSSD.n666 0.00720524
R15988 VSSD.n672 VSSD.n666 0.00720524
R15989 VSSD.n676 VSSD.n665 0.00720524
R15990 VSSD.n2868 VSSD.n664 0.00720524
R15991 VSSD.n667 VSSD.n660 0.00720524
R15992 VSSD.n677 VSSD.n661 0.00720524
R15993 VSSD.n676 VSSD.n663 0.00720524
R15994 VSSD.n669 VSSD.n661 0.00720524
R15995 VSSD.n672 VSSD.n662 0.00720524
R15996 VSSD.n674 VSSD.n664 0.00720524
R15997 VSSD.n3009 VSSD.n484 0.00720524
R15998 VSSD.n3009 VSSD.n486 0.00720524
R15999 VSSD.n494 VSSD.n483 0.00720524
R16000 VSSD.n489 VSSD.n483 0.00720524
R16001 VSSD.n493 VSSD.n482 0.00720524
R16002 VSSD.n3007 VSSD.n481 0.00720524
R16003 VSSD.n484 VSSD.n477 0.00720524
R16004 VSSD.n494 VSSD.n478 0.00720524
R16005 VSSD.n493 VSSD.n480 0.00720524
R16006 VSSD.n486 VSSD.n478 0.00720524
R16007 VSSD.n489 VSSD.n479 0.00720524
R16008 VSSD.n491 VSSD.n481 0.00720524
R16009 VSSD.n2744 VSSD.n2738 0.00720524
R16010 VSSD.n2733 VSSD.n2729 0.00720524
R16011 VSSD.n2734 VSSD.n2728 0.00720524
R16012 VSSD.n2731 VSSD.n839 0.00720524
R16013 VSSD.n2735 VSSD.n2725 0.00720524
R16014 VSSD.n2742 VSSD.n840 0.00720524
R16015 VSSD.n2735 VSSD.n840 0.00720524
R16016 VSSD.n2734 VSSD.n839 0.00720524
R16017 VSSD.n2733 VSSD.n838 0.00720524
R16018 VSSD.n2739 VSSD.n2738 0.00720524
R16019 VSSD.n2731 VSSD.n2725 0.00720524
R16020 VSSD.n2742 VSSD.n2724 0.00720524
R16021 VSSD.n2334 VSSD.n2333 0.00720524
R16022 VSSD.n1014 VSSD.n1004 0.00720524
R16023 VSSD.n1016 VSSD.n1015 0.00720524
R16024 VSSD.n1016 VSSD.n1005 0.00720524
R16025 VSSD.n2331 VSSD.n1017 0.00720524
R16026 VSSD.n1017 VSSD.n1006 0.00720524
R16027 VSSD.n2330 VSSD.n1006 0.00720524
R16028 VSSD.n2332 VSSD.n1005 0.00720524
R16029 VSSD.n2333 VSSD.n1004 0.00720524
R16030 VSSD.n2332 VSSD.n2331 0.00720524
R16031 VSSD.n1015 VSSD.n1007 0.00720524
R16032 VSSD.n2334 VSSD.n1010 0.00720524
R16033 VSSD.n1692 VSSD.n1686 0.00720524
R16034 VSSD.n1681 VSSD.n1677 0.00720524
R16035 VSSD.n1682 VSSD.n1676 0.00720524
R16036 VSSD.n1679 VSSD.n1636 0.00720524
R16037 VSSD.n1683 VSSD.n1673 0.00720524
R16038 VSSD.n1690 VSSD.n1637 0.00720524
R16039 VSSD.n1683 VSSD.n1637 0.00720524
R16040 VSSD.n1682 VSSD.n1636 0.00720524
R16041 VSSD.n1681 VSSD.n1635 0.00720524
R16042 VSSD.n1687 VSSD.n1686 0.00720524
R16043 VSSD.n1679 VSSD.n1673 0.00720524
R16044 VSSD.n1690 VSSD.n1672 0.00720524
R16045 VSSD.n3302 VSSD.n260 0.00720524
R16046 VSSD.n3302 VSSD.n262 0.00720524
R16047 VSSD.n270 VSSD.n259 0.00720524
R16048 VSSD.n265 VSSD.n259 0.00720524
R16049 VSSD.n269 VSSD.n258 0.00720524
R16050 VSSD.n3300 VSSD.n257 0.00720524
R16051 VSSD.n260 VSSD.n253 0.00720524
R16052 VSSD.n270 VSSD.n254 0.00720524
R16053 VSSD.n269 VSSD.n256 0.00720524
R16054 VSSD.n262 VSSD.n254 0.00720524
R16055 VSSD.n265 VSSD.n255 0.00720524
R16056 VSSD.n267 VSSD.n257 0.00720524
R16057 VSSD.n3325 VSSD.n240 0.0067
R16058 VSSD.n3329 VSSD.n240 0.0067
R16059 VSSD.n3330 VSSD.n3329 0.0067
R16060 VSSD.n3331 VSSD.n3330 0.0067
R16061 VSSD.n3331 VSSD.n238 0.0067
R16062 VSSD.n3335 VSSD.n238 0.0067
R16063 VSSD.n3336 VSSD.n3335 0.0067
R16064 VSSD.n3337 VSSD.n3336 0.0067
R16065 VSSD.n3337 VSSD.n236 0.0067
R16066 VSSD.n3341 VSSD.n236 0.0067
R16067 VSSD.n3342 VSSD.n3341 0.0067
R16068 VSSD.n3343 VSSD.n3342 0.0067
R16069 VSSD.n3343 VSSD.n234 0.0067
R16070 VSSD.n3347 VSSD.n234 0.0067
R16071 VSSD.n3348 VSSD.n3347 0.0067
R16072 VSSD.n3349 VSSD.n3348 0.0067
R16073 VSSD.n3349 VSSD.n232 0.0067
R16074 VSSD.n3353 VSSD.n232 0.0067
R16075 VSSD.n3354 VSSD.n3353 0.0067
R16076 VSSD.n3355 VSSD.n3354 0.0067
R16077 VSSD.n3355 VSSD.n230 0.0067
R16078 VSSD.n3359 VSSD.n230 0.0067
R16079 VSSD.n3360 VSSD.n3359 0.0067
R16080 VSSD.n3361 VSSD.n3360 0.0067
R16081 VSSD.n3361 VSSD.n226 0.0067
R16082 VSSD.n3365 VSSD.n226 0.0067
R16083 VSSD.n3366 VSSD.n3365 0.0067
R16084 VSSD.n3494 VSSD.n3493 0.0067
R16085 VSSD.n3493 VSSD.n141 0.0067
R16086 VSSD.n3399 VSSD.n141 0.0067
R16087 VSSD.n3484 VSSD.n3399 0.0067
R16088 VSSD.n3484 VSSD.n3401 0.0067
R16089 VSSD.n3480 VSSD.n3401 0.0067
R16090 VSSD.n3480 VSSD.n3478 0.0067
R16091 VSSD.n3478 VSSD.n3476 0.0067
R16092 VSSD.n3476 VSSD.n3406 0.0067
R16093 VSSD.n3472 VSSD.n3406 0.0067
R16094 VSSD.n3472 VSSD.n3470 0.0067
R16095 VSSD.n3470 VSSD.n3468 0.0067
R16096 VSSD.n3468 VSSD.n3410 0.0067
R16097 VSSD.n3464 VSSD.n3410 0.0067
R16098 VSSD.n3464 VSSD.n3462 0.0067
R16099 VSSD.n3462 VSSD.n3460 0.0067
R16100 VSSD.n3460 VSSD.n3414 0.0067
R16101 VSSD.n3456 VSSD.n3414 0.0067
R16102 VSSD.n3456 VSSD.n3454 0.0067
R16103 VSSD.n3454 VSSD.n3452 0.0067
R16104 VSSD.n3452 VSSD.n3418 0.0067
R16105 VSSD.n3448 VSSD.n3418 0.0067
R16106 VSSD.n3448 VSSD.n3446 0.0067
R16107 VSSD.n3446 VSSD.n3444 0.0067
R16108 VSSD.n3444 VSSD.n3427 0.0067
R16109 VSSD.n3440 VSSD.n3427 0.0067
R16110 VSSD.n3440 VSSD.n3438 0.0067
R16111 VSSD.n3495 VSSD.n139 0.00608
R16112 VSSD.n3402 VSSD.n139 0.00608
R16113 VSSD.n3403 VSSD.n3402 0.00608
R16114 VSSD.n3483 VSSD.n3403 0.00608
R16115 VSSD.n3483 VSSD.n3482 0.00608
R16116 VSSD.n3482 VSSD.n3481 0.00608
R16117 VSSD.n3481 VSSD.n3404 0.00608
R16118 VSSD.n3475 VSSD.n3404 0.00608
R16119 VSSD.n3475 VSSD.n3474 0.00608
R16120 VSSD.n3474 VSSD.n3473 0.00608
R16121 VSSD.n3473 VSSD.n3408 0.00608
R16122 VSSD.n3467 VSSD.n3408 0.00608
R16123 VSSD.n3467 VSSD.n3466 0.00608
R16124 VSSD.n3466 VSSD.n3465 0.00608
R16125 VSSD.n3465 VSSD.n3412 0.00608
R16126 VSSD.n3459 VSSD.n3412 0.00608
R16127 VSSD.n3459 VSSD.n3458 0.00608
R16128 VSSD.n3458 VSSD.n3457 0.00608
R16129 VSSD.n3457 VSSD.n3416 0.00608
R16130 VSSD.n3451 VSSD.n3416 0.00608
R16131 VSSD.n3451 VSSD.n3450 0.00608
R16132 VSSD.n3450 VSSD.n3449 0.00608
R16133 VSSD.n3449 VSSD.n3420 0.00608
R16134 VSSD.n3443 VSSD.n3420 0.00608
R16135 VSSD.n3443 VSSD.n3442 0.00608
R16136 VSSD.n3442 VSSD.n3441 0.00608
R16137 VSSD.n3585 VSSD.n67 0.00608
R16138 VSSD.n3582 VSSD.n3581 0.00608
R16139 VSSD.n1912 VSSD.n1445 0.00608
R16140 VSSD.n1445 VSSD.n1425 0.00608
R16141 VSSD.n3308 VSSD.n3 0.00608
R16142 VSSD.n3314 VSSD.n3313 0.00608
R16143 VSSD.n3327 VSSD.n3326 0.00608
R16144 VSSD.n3328 VSSD.n3327 0.00608
R16145 VSSD.n3328 VSSD.n239 0.00608
R16146 VSSD.n3332 VSSD.n239 0.00608
R16147 VSSD.n3333 VSSD.n3332 0.00608
R16148 VSSD.n3334 VSSD.n3333 0.00608
R16149 VSSD.n3334 VSSD.n237 0.00608
R16150 VSSD.n3338 VSSD.n237 0.00608
R16151 VSSD.n3339 VSSD.n3338 0.00608
R16152 VSSD.n3340 VSSD.n3339 0.00608
R16153 VSSD.n3340 VSSD.n235 0.00608
R16154 VSSD.n3344 VSSD.n235 0.00608
R16155 VSSD.n3345 VSSD.n3344 0.00608
R16156 VSSD.n3346 VSSD.n3345 0.00608
R16157 VSSD.n3346 VSSD.n233 0.00608
R16158 VSSD.n3350 VSSD.n233 0.00608
R16159 VSSD.n3351 VSSD.n3350 0.00608
R16160 VSSD.n3352 VSSD.n3351 0.00608
R16161 VSSD.n3352 VSSD.n231 0.00608
R16162 VSSD.n3356 VSSD.n231 0.00608
R16163 VSSD.n3357 VSSD.n3356 0.00608
R16164 VSSD.n3358 VSSD.n3357 0.00608
R16165 VSSD.n3358 VSSD.n229 0.00608
R16166 VSSD.n3362 VSSD.n229 0.00608
R16167 VSSD.n3363 VSSD.n3362 0.00608
R16168 VSSD.n3364 VSSD.n3363 0.00608
R16169 VSSD.n1303 VSSD.n1290 0.0056452
R16170 VSSD.n1307 VSSD.n1305 0.0056452
R16171 VSSD.n1306 VSSD.n1302 0.0056452
R16172 VSSD.n1310 VSSD.n1308 0.0056452
R16173 VSSD.n1309 VSSD.n1301 0.0056452
R16174 VSSD.n1313 VSSD.n1311 0.0056452
R16175 VSSD.n1312 VSSD.n1300 0.0056452
R16176 VSSD.n1316 VSSD.n1314 0.0056452
R16177 VSSD.n1315 VSSD.n1299 0.0056452
R16178 VSSD.n1953 VSSD.n1317 0.0056452
R16179 VSSD.n1823 VSSD.n1558 0.0056452
R16180 VSSD.n1566 VSSD.n1561 0.0056452
R16181 VSSD.n1822 VSSD.n1557 0.0056452
R16182 VSSD.n1567 VSSD.n1562 0.0056452
R16183 VSSD.n1821 VSSD.n1556 0.0056452
R16184 VSSD.n1568 VSSD.n1563 0.0056452
R16185 VSSD.n1820 VSSD.n1555 0.0056452
R16186 VSSD.n1569 VSSD.n1564 0.0056452
R16187 VSSD.n1819 VSSD.n1554 0.0056452
R16188 VSSD.n1837 VSSD.n1565 0.0056452
R16189 VSSD.n1086 VSSD.n1085 0.0056452
R16190 VSSD.n2269 VSSD.n1070 0.0056452
R16191 VSSD.n2272 VSSD.n1084 0.0056452
R16192 VSSD.n2270 VSSD.n1071 0.0056452
R16193 VSSD.n2271 VSSD.n1083 0.0056452
R16194 VSSD.n2276 VSSD.n1072 0.0056452
R16195 VSSD.n2275 VSSD.n1082 0.0056452
R16196 VSSD.n2295 VSSD.n1073 0.0056452
R16197 VSSD.n2297 VSSD.n1075 0.0056452
R16198 VSSD.n2298 VSSD.n1074 0.0056452
R16199 VSSD.n2781 VSSD.n795 0.0056452
R16200 VSSD.n2780 VSSD.n2756 0.0056452
R16201 VSSD.n2767 VSSD.n794 0.0056452
R16202 VSSD.n2758 VSSD.n2757 0.0056452
R16203 VSSD.n2766 VSSD.n793 0.0056452
R16204 VSSD.n2760 VSSD.n2759 0.0056452
R16205 VSSD.n2765 VSSD.n792 0.0056452
R16206 VSSD.n2762 VSSD.n2761 0.0056452
R16207 VSSD.n2764 VSSD.n791 0.0056452
R16208 VSSD.n2802 VSSD.n2763 0.0056452
R16209 VSSD.n915 VSSD.n897 0.0056452
R16210 VSSD.n2656 VSSD.n2655 0.0056452
R16211 VSSD.n914 VSSD.n896 0.0056452
R16212 VSSD.n2670 VSSD.n2657 0.0056452
R16213 VSSD.n913 VSSD.n895 0.0056452
R16214 VSSD.n2672 VSSD.n2671 0.0056452
R16215 VSSD.n2674 VSSD.n894 0.0056452
R16216 VSSD.n912 VSSD.n899 0.0056452
R16217 VSSD.n2680 VSSD.n901 0.0056452
R16218 VSSD.n2681 VSSD.n900 0.0056452
R16219 VSSD.n2654 VSSD.n897 0.0056452
R16220 VSSD.n2655 VSSD.n915 0.0056452
R16221 VSSD.n2656 VSSD.n896 0.0056452
R16222 VSSD.n2657 VSSD.n914 0.0056452
R16223 VSSD.n2670 VSSD.n895 0.0056452
R16224 VSSD.n2671 VSSD.n913 0.0056452
R16225 VSSD.n2672 VSSD.n894 0.0056452
R16226 VSSD.n2674 VSSD.n912 0.0056452
R16227 VSSD.n901 VSSD.n899 0.0056452
R16228 VSSD.n2681 VSSD.n2680 0.0056452
R16229 VSSD.n65 VSSD.n47 0.0056452
R16230 VSSD.n3604 VSSD.n3603 0.0056452
R16231 VSSD.n64 VSSD.n46 0.0056452
R16232 VSSD.n3618 VSSD.n3605 0.0056452
R16233 VSSD.n63 VSSD.n45 0.0056452
R16234 VSSD.n3620 VSSD.n3619 0.0056452
R16235 VSSD.n3622 VSSD.n44 0.0056452
R16236 VSSD.n62 VSSD.n49 0.0056452
R16237 VSSD.n3628 VSSD.n51 0.0056452
R16238 VSSD.n3629 VSSD.n50 0.0056452
R16239 VSSD.n3602 VSSD.n47 0.0056452
R16240 VSSD.n3603 VSSD.n65 0.0056452
R16241 VSSD.n3604 VSSD.n46 0.0056452
R16242 VSSD.n3605 VSSD.n64 0.0056452
R16243 VSSD.n3618 VSSD.n45 0.0056452
R16244 VSSD.n3619 VSSD.n63 0.0056452
R16245 VSSD.n3620 VSSD.n44 0.0056452
R16246 VSSD.n3622 VSSD.n62 0.0056452
R16247 VSSD.n51 VSSD.n49 0.0056452
R16248 VSSD.n3629 VSSD.n3628 0.0056452
R16249 VSSD.n440 VSSD.n439 0.0056452
R16250 VSSD.n3043 VSSD.n424 0.0056452
R16251 VSSD.n3046 VSSD.n438 0.0056452
R16252 VSSD.n3044 VSSD.n425 0.0056452
R16253 VSSD.n3045 VSSD.n437 0.0056452
R16254 VSSD.n3050 VSSD.n426 0.0056452
R16255 VSSD.n3049 VSSD.n436 0.0056452
R16256 VSSD.n3069 VSSD.n427 0.0056452
R16257 VSSD.n3071 VSSD.n429 0.0056452
R16258 VSSD.n3072 VSSD.n428 0.0056452
R16259 VSSD.n326 VSSD.n308 0.0056452
R16260 VSSD.n3213 VSSD.n3212 0.0056452
R16261 VSSD.n325 VSSD.n307 0.0056452
R16262 VSSD.n3227 VSSD.n3214 0.0056452
R16263 VSSD.n324 VSSD.n306 0.0056452
R16264 VSSD.n3229 VSSD.n3228 0.0056452
R16265 VSSD.n3231 VSSD.n305 0.0056452
R16266 VSSD.n323 VSSD.n310 0.0056452
R16267 VSSD.n3237 VSSD.n312 0.0056452
R16268 VSSD.n3238 VSSD.n311 0.0056452
R16269 VSSD.n3211 VSSD.n308 0.0056452
R16270 VSSD.n3212 VSSD.n326 0.0056452
R16271 VSSD.n3213 VSSD.n307 0.0056452
R16272 VSSD.n3214 VSSD.n325 0.0056452
R16273 VSSD.n3227 VSSD.n306 0.0056452
R16274 VSSD.n3228 VSSD.n324 0.0056452
R16275 VSSD.n3229 VSSD.n305 0.0056452
R16276 VSSD.n3231 VSSD.n323 0.0056452
R16277 VSSD.n312 VSSD.n310 0.0056452
R16278 VSSD.n3238 VSSD.n3237 0.0056452
R16279 VSSD.n623 VSSD.n622 0.0056452
R16280 VSSD.n2904 VSSD.n607 0.0056452
R16281 VSSD.n2907 VSSD.n621 0.0056452
R16282 VSSD.n2905 VSSD.n608 0.0056452
R16283 VSSD.n2906 VSSD.n620 0.0056452
R16284 VSSD.n2911 VSSD.n609 0.0056452
R16285 VSSD.n2910 VSSD.n619 0.0056452
R16286 VSSD.n2930 VSSD.n610 0.0056452
R16287 VSSD.n2932 VSSD.n612 0.0056452
R16288 VSSD.n2933 VSSD.n611 0.0056452
R16289 VSSD.n1200 VSSD.n1199 0.0056452
R16290 VSSD.n2065 VSSD.n1184 0.0056452
R16291 VSSD.n2068 VSSD.n1198 0.0056452
R16292 VSSD.n2066 VSSD.n1185 0.0056452
R16293 VSSD.n2067 VSSD.n1197 0.0056452
R16294 VSSD.n2072 VSSD.n1186 0.0056452
R16295 VSSD.n2071 VSSD.n1196 0.0056452
R16296 VSSD.n2091 VSSD.n1187 0.0056452
R16297 VSSD.n2093 VSSD.n1189 0.0056452
R16298 VSSD.n2094 VSSD.n1188 0.0056452
R16299 VSSD.n1199 VSSD.n1183 0.0056452
R16300 VSSD.n1200 VSSD.n1184 0.0056452
R16301 VSSD.n2068 VSSD.n2065 0.0056452
R16302 VSSD.n1198 VSSD.n1185 0.0056452
R16303 VSSD.n2067 VSSD.n2066 0.0056452
R16304 VSSD.n1197 VSSD.n1186 0.0056452
R16305 VSSD.n2072 VSSD.n2071 0.0056452
R16306 VSSD.n1196 VSSD.n1187 0.0056452
R16307 VSSD.n2091 VSSD.n1189 0.0056452
R16308 VSSD.n2094 VSSD.n2093 0.0056452
R16309 VSSD.n622 VSSD.n606 0.0056452
R16310 VSSD.n623 VSSD.n607 0.0056452
R16311 VSSD.n2907 VSSD.n2904 0.0056452
R16312 VSSD.n621 VSSD.n608 0.0056452
R16313 VSSD.n2906 VSSD.n2905 0.0056452
R16314 VSSD.n620 VSSD.n609 0.0056452
R16315 VSSD.n2911 VSSD.n2910 0.0056452
R16316 VSSD.n619 VSSD.n610 0.0056452
R16317 VSSD.n2930 VSSD.n612 0.0056452
R16318 VSSD.n2933 VSSD.n2932 0.0056452
R16319 VSSD.n439 VSSD.n423 0.0056452
R16320 VSSD.n440 VSSD.n424 0.0056452
R16321 VSSD.n3046 VSSD.n3043 0.0056452
R16322 VSSD.n438 VSSD.n425 0.0056452
R16323 VSSD.n3045 VSSD.n3044 0.0056452
R16324 VSSD.n437 VSSD.n426 0.0056452
R16325 VSSD.n3050 VSSD.n3049 0.0056452
R16326 VSSD.n436 VSSD.n427 0.0056452
R16327 VSSD.n3069 VSSD.n429 0.0056452
R16328 VSSD.n3072 VSSD.n3071 0.0056452
R16329 VSSD.n2800 VSSD.n795 0.0056452
R16330 VSSD.n2781 VSSD.n2780 0.0056452
R16331 VSSD.n2767 VSSD.n2756 0.0056452
R16332 VSSD.n2757 VSSD.n794 0.0056452
R16333 VSSD.n2766 VSSD.n2758 0.0056452
R16334 VSSD.n2759 VSSD.n793 0.0056452
R16335 VSSD.n2765 VSSD.n2760 0.0056452
R16336 VSSD.n2761 VSSD.n792 0.0056452
R16337 VSSD.n2764 VSSD.n2762 0.0056452
R16338 VSSD.n2763 VSSD.n791 0.0056452
R16339 VSSD.n1085 VSSD.n1069 0.0056452
R16340 VSSD.n1086 VSSD.n1070 0.0056452
R16341 VSSD.n2272 VSSD.n2269 0.0056452
R16342 VSSD.n1084 VSSD.n1071 0.0056452
R16343 VSSD.n2271 VSSD.n2270 0.0056452
R16344 VSSD.n1083 VSSD.n1072 0.0056452
R16345 VSSD.n2276 VSSD.n2275 0.0056452
R16346 VSSD.n1082 VSSD.n1073 0.0056452
R16347 VSSD.n2295 VSSD.n1075 0.0056452
R16348 VSSD.n2298 VSSD.n2297 0.0056452
R16349 VSSD.n1823 VSSD.n1560 0.0056452
R16350 VSSD.n1566 VSSD.n1558 0.0056452
R16351 VSSD.n1822 VSSD.n1561 0.0056452
R16352 VSSD.n1567 VSSD.n1557 0.0056452
R16353 VSSD.n1821 VSSD.n1562 0.0056452
R16354 VSSD.n1568 VSSD.n1556 0.0056452
R16355 VSSD.n1820 VSSD.n1563 0.0056452
R16356 VSSD.n1569 VSSD.n1555 0.0056452
R16357 VSSD.n1819 VSSD.n1564 0.0056452
R16358 VSSD.n1565 VSSD.n1554 0.0056452
R16359 VSSD.n1955 VSSD.n1290 0.0056452
R16360 VSSD.n1305 VSSD.n1303 0.0056452
R16361 VSSD.n1307 VSSD.n1306 0.0056452
R16362 VSSD.n1308 VSSD.n1302 0.0056452
R16363 VSSD.n1310 VSSD.n1309 0.0056452
R16364 VSSD.n1311 VSSD.n1301 0.0056452
R16365 VSSD.n1313 VSSD.n1312 0.0056452
R16366 VSSD.n1314 VSSD.n1300 0.0056452
R16367 VSSD.n1316 VSSD.n1315 0.0056452
R16368 VSSD.n1317 VSSD.n1299 0.0056452
R16369 VSSD.n1592 VSSD.n1573 0.00557105
R16370 VSSD.n2679 VSSD.n2678 0.00557105
R16371 VSSD.n3627 VSSD.n3626 0.00557105
R16372 VSSD.n3236 VSSD.n3235 0.00557105
R16373 VSSD.n2088 VSSD.n1192 0.00557105
R16374 VSSD.n2927 VSSD.n615 0.00557105
R16375 VSSD.n3066 VSSD.n432 0.00557105
R16376 VSSD.n2786 VSSD.n2772 0.00557105
R16377 VSSD.n2292 VSSD.n1078 0.00557105
R16378 VSSD.n1333 VSSD.n1318 0.00557105
R16379 VSSD.n2541 VSSD.n2530 0.00554065
R16380 VSSD.n2537 VSSD.n2530 0.00554065
R16381 VSSD.n2537 VSSD.n2536 0.00554065
R16382 VSSD.n2536 VSSD.n2535 0.00554065
R16383 VSSD.n2535 VSSD.n2532 0.00554065
R16384 VSSD.n2532 VSSD.n138 0.00554065
R16385 VSSD.n3513 VSSD.n138 0.00554065
R16386 VSSD.n3513 VSSD.n3512 0.00554065
R16387 VSSD.n3512 VSSD.n3511 0.00554065
R16388 VSSD VSSD.n0 0.00527
R16389 VSSD.n1892 VSSD.n1888 0.00498219
R16390 VSSD.n1899 VSSD.n1896 0.00498219
R16391 VSSD.n1897 VSSD.n1886 0.00498219
R16392 VSSD.n1901 VSSD.n1497 0.00498219
R16393 VSSD.n1902 VSSD.n1478 0.00498219
R16394 VSSD.n1490 VSSD.n1479 0.00498219
R16395 VSSD.n1481 VSSD.n1476 0.00498219
R16396 VSSD.n1907 VSSD.n1480 0.00498219
R16397 VSSD.n1893 VSSD.n1892 0.00498219
R16398 VSSD.n1896 VSSD.n1888 0.00498219
R16399 VSSD.n1899 VSSD.n1897 0.00498219
R16400 VSSD.n1886 VSSD.n1497 0.00498219
R16401 VSSD.n1532 VSSD.n1523 0.00498219
R16402 VSSD.n1534 VSSD.n1524 0.00498219
R16403 VSSD.n1865 VSSD.n1524 0.00498219
R16404 VSSD.n1862 VSSD.n1525 0.00498219
R16405 VSSD.n1548 VSSD.n1540 0.00498219
R16406 VSSD.n1708 VSSD.n1704 0.00498219
R16407 VSSD.n1715 VSSD.n1714 0.00498219
R16408 VSSD.n1714 VSSD.n1713 0.00498219
R16409 VSSD.n1865 VSSD.n1864 0.00498219
R16410 VSSD.n1864 VSSD.n1525 0.00498219
R16411 VSSD.n1536 VSSD.n1523 0.00498219
R16412 VSSD.n1536 VSSD.n1534 0.00498219
R16413 VSSD.n1715 VSSD.n1708 0.00498219
R16414 VSSD.n1704 VSSD.n1548 0.00498219
R16415 VSSD.n1842 VSSD.n1540 0.00498219
R16416 VSSD.n1713 VSSD.n1547 0.00498219
R16417 VSSD.n872 VSSD.n863 0.00498219
R16418 VSSD.n874 VSSD.n864 0.00498219
R16419 VSSD.n2709 VSSD.n864 0.00498219
R16420 VSSD.n2706 VSSD.n865 0.00498219
R16421 VSSD.n888 VSSD.n880 0.00498219
R16422 VSSD.n2643 VSSD.n2639 0.00498219
R16423 VSSD.n2650 VSSD.n2649 0.00498219
R16424 VSSD.n2649 VSSD.n2648 0.00498219
R16425 VSSD.n2709 VSSD.n2708 0.00498219
R16426 VSSD.n2708 VSSD.n865 0.00498219
R16427 VSSD.n876 VSSD.n863 0.00498219
R16428 VSSD.n876 VSSD.n874 0.00498219
R16429 VSSD.n2650 VSSD.n2643 0.00498219
R16430 VSSD.n2639 VSSD.n888 0.00498219
R16431 VSSD.n2686 VSSD.n880 0.00498219
R16432 VSSD.n2648 VSSD.n887 0.00498219
R16433 VSSD.n117 VSSD.n108 0.00498219
R16434 VSSD.n119 VSSD.n109 0.00498219
R16435 VSSD.n3539 VSSD.n109 0.00498219
R16436 VSSD.n3536 VSSD.n110 0.00498219
R16437 VSSD.n133 VSSD.n125 0.00498219
R16438 VSSD.n3501 VSSD.n3497 0.00498219
R16439 VSSD.n3508 VSSD.n3507 0.00498219
R16440 VSSD.n3507 VSSD.n3506 0.00498219
R16441 VSSD.n3539 VSSD.n3538 0.00498219
R16442 VSSD.n3538 VSSD.n110 0.00498219
R16443 VSSD.n121 VSSD.n108 0.00498219
R16444 VSSD.n121 VSSD.n119 0.00498219
R16445 VSSD.n3508 VSSD.n3501 0.00498219
R16446 VSSD.n3497 VSSD.n133 0.00498219
R16447 VSSD.n3516 VSSD.n125 0.00498219
R16448 VSSD.n3506 VSSD.n132 0.00498219
R16449 VSSD.n22 VSSD.n13 0.00498219
R16450 VSSD.n24 VSSD.n14 0.00498219
R16451 VSSD.n3657 VSSD.n14 0.00498219
R16452 VSSD.n3654 VSSD.n15 0.00498219
R16453 VSSD.n38 VSSD.n30 0.00498219
R16454 VSSD.n3591 VSSD.n3587 0.00498219
R16455 VSSD.n3598 VSSD.n3597 0.00498219
R16456 VSSD.n3597 VSSD.n3596 0.00498219
R16457 VSSD.n3657 VSSD.n3656 0.00498219
R16458 VSSD.n3656 VSSD.n15 0.00498219
R16459 VSSD.n26 VSSD.n13 0.00498219
R16460 VSSD.n26 VSSD.n24 0.00498219
R16461 VSSD.n3598 VSSD.n3591 0.00498219
R16462 VSSD.n3587 VSSD.n38 0.00498219
R16463 VSSD.n3634 VSSD.n30 0.00498219
R16464 VSSD.n3596 VSSD.n37 0.00498219
R16465 VSSD.n3566 VSSD.n3562 0.00498219
R16466 VSSD.n3573 VSSD.n3570 0.00498219
R16467 VSSD.n3571 VSSD.n3560 0.00498219
R16468 VSSD.n3575 VSSD.n82 0.00498219
R16469 VSSD.n68 VSSD.n66 0.00498219
R16470 VSSD.n3584 VSSD.n70 0.00498219
R16471 VSSD.n69 VSSD.n68 0.00498219
R16472 VSSD.n70 VSSD.n66 0.00498219
R16473 VSSD.n3567 VSSD.n3566 0.00498219
R16474 VSSD.n3570 VSSD.n3562 0.00498219
R16475 VSSD.n3573 VSSD.n3571 0.00498219
R16476 VSSD.n3560 VSSD.n82 0.00498219
R16477 VSSD.n970 VSSD.n968 0.00498219
R16478 VSSD.n2626 VSSD.n2622 0.00498219
R16479 VSSD.n2623 VSSD.n965 0.00498219
R16480 VSSD.n2628 VSSD.n957 0.00498219
R16481 VSSD.n920 VSSD.n916 0.00498219
R16482 VSSD.n2636 VSSD.n919 0.00498219
R16483 VSSD.n935 VSSD.n934 0.00498219
R16484 VSSD.n945 VSSD.n938 0.00498219
R16485 VSSD.n937 VSSD.n933 0.00498219
R16486 VSSD.n946 VSSD.n940 0.00498219
R16487 VSSD.n939 VSSD.n932 0.00498219
R16488 VSSD.n947 VSSD.n942 0.00498219
R16489 VSSD.n941 VSSD.n931 0.00498219
R16490 VSSD.n948 VSSD.n944 0.00498219
R16491 VSSD.n943 VSSD.n930 0.00498219
R16492 VSSD.n2633 VSSD.n950 0.00498219
R16493 VSSD.n973 VSSD.n970 0.00498219
R16494 VSSD.n2622 VSSD.n968 0.00498219
R16495 VSSD.n2626 VSSD.n2623 0.00498219
R16496 VSSD.n965 VSSD.n957 0.00498219
R16497 VSSD.n920 VSSD.n918 0.00498219
R16498 VSSD.n919 VSSD.n916 0.00498219
R16499 VSSD.n934 VSSD.n925 0.00498219
R16500 VSSD.n945 VSSD.n935 0.00498219
R16501 VSSD.n938 VSSD.n937 0.00498219
R16502 VSSD.n946 VSSD.n933 0.00498219
R16503 VSSD.n940 VSSD.n939 0.00498219
R16504 VSSD.n947 VSSD.n932 0.00498219
R16505 VSSD.n942 VSSD.n941 0.00498219
R16506 VSSD.n948 VSSD.n931 0.00498219
R16507 VSSD.n944 VSSD.n943 0.00498219
R16508 VSSD.n950 VSSD.n930 0.00498219
R16509 VSSD.n3255 VSSD.n279 0.00498219
R16510 VSSD.n282 VSSD.n280 0.00498219
R16511 VSSD.n3256 VSSD.n280 0.00498219
R16512 VSSD.n3271 VSSD.n284 0.00498219
R16513 VSSD.n299 VSSD.n291 0.00498219
R16514 VSSD.n3200 VSSD.n3196 0.00498219
R16515 VSSD.n3207 VSSD.n3206 0.00498219
R16516 VSSD.n3206 VSSD.n3205 0.00498219
R16517 VSSD.n3256 VSSD.n281 0.00498219
R16518 VSSD.n284 VSSD.n281 0.00498219
R16519 VSSD.n3255 VSSD.n283 0.00498219
R16520 VSSD.n283 VSSD.n282 0.00498219
R16521 VSSD.n3207 VSSD.n3200 0.00498219
R16522 VSSD.n3196 VSSD.n299 0.00498219
R16523 VSSD.n3243 VSSD.n291 0.00498219
R16524 VSSD.n3205 VSSD.n298 0.00498219
R16525 VSSD.n345 VSSD.n338 0.00498219
R16526 VSSD.n3150 VSSD.n336 0.00498219
R16527 VSSD.n346 VSSD.n344 0.00498219
R16528 VSSD.n3148 VSSD.n335 0.00498219
R16529 VSSD.n363 VSSD.n359 0.00498219
R16530 VSSD.n3143 VSSD.n362 0.00498219
R16531 VSSD.n3128 VSSD.n3118 0.00498219
R16532 VSSD.n3133 VSSD.n3119 0.00498219
R16533 VSSD.n3127 VSSD.n3117 0.00498219
R16534 VSSD.n3134 VSSD.n3120 0.00498219
R16535 VSSD.n3126 VSSD.n3116 0.00498219
R16536 VSSD.n3135 VSSD.n3121 0.00498219
R16537 VSSD.n3125 VSSD.n3115 0.00498219
R16538 VSSD.n3136 VSSD.n3122 0.00498219
R16539 VSSD.n3124 VSSD.n3114 0.00498219
R16540 VSSD.n3140 VSSD.n3123 0.00498219
R16541 VSSD.n3152 VSSD.n338 0.00498219
R16542 VSSD.n345 VSSD.n336 0.00498219
R16543 VSSD.n3150 VSSD.n346 0.00498219
R16544 VSSD.n344 VSSD.n335 0.00498219
R16545 VSSD.n363 VSSD.n361 0.00498219
R16546 VSSD.n362 VSSD.n359 0.00498219
R16547 VSSD.n3128 VSSD.n379 0.00498219
R16548 VSSD.n3133 VSSD.n3118 0.00498219
R16549 VSSD.n3127 VSSD.n3119 0.00498219
R16550 VSSD.n3134 VSSD.n3117 0.00498219
R16551 VSSD.n3126 VSSD.n3120 0.00498219
R16552 VSSD.n3135 VSSD.n3116 0.00498219
R16553 VSSD.n3125 VSSD.n3121 0.00498219
R16554 VSSD.n3136 VSSD.n3115 0.00498219
R16555 VSSD.n3124 VSSD.n3122 0.00498219
R16556 VSSD.n3123 VSSD.n3114 0.00498219
R16557 VSSD.n1256 VSSD.n1254 0.00498219
R16558 VSSD.n2036 VSSD.n1251 0.00498219
R16559 VSSD.n1252 VSSD.n1249 0.00498219
R16560 VSSD.n2038 VSSD.n1240 0.00498219
R16561 VSSD.n1205 VSSD.n1202 0.00498219
R16562 VSSD.n2047 VSSD.n1204 0.00498219
R16563 VSSD.n1219 VSSD.n1218 0.00498219
R16564 VSSD.n1229 VSSD.n1222 0.00498219
R16565 VSSD.n1221 VSSD.n1217 0.00498219
R16566 VSSD.n1230 VSSD.n1224 0.00498219
R16567 VSSD.n1223 VSSD.n1216 0.00498219
R16568 VSSD.n1231 VSSD.n1226 0.00498219
R16569 VSSD.n1225 VSSD.n1215 0.00498219
R16570 VSSD.n1232 VSSD.n1228 0.00498219
R16571 VSSD.n1227 VSSD.n1214 0.00498219
R16572 VSSD.n2044 VSSD.n1234 0.00498219
R16573 VSSD.n2034 VSSD.n1256 0.00498219
R16574 VSSD.n1254 VSSD.n1251 0.00498219
R16575 VSSD.n2036 VSSD.n1252 0.00498219
R16576 VSSD.n1249 VSSD.n1240 0.00498219
R16577 VSSD.n1205 VSSD.n1203 0.00498219
R16578 VSSD.n1204 VSSD.n1202 0.00498219
R16579 VSSD.n1218 VSSD.n1209 0.00498219
R16580 VSSD.n1229 VSSD.n1219 0.00498219
R16581 VSSD.n1222 VSSD.n1221 0.00498219
R16582 VSSD.n1230 VSSD.n1217 0.00498219
R16583 VSSD.n1224 VSSD.n1223 0.00498219
R16584 VSSD.n1231 VSSD.n1216 0.00498219
R16585 VSSD.n1226 VSSD.n1225 0.00498219
R16586 VSSD.n1232 VSSD.n1215 0.00498219
R16587 VSSD.n1228 VSSD.n1227 0.00498219
R16588 VSSD.n1234 VSSD.n1214 0.00498219
R16589 VSSD.n1146 VSSD.n1145 0.00498219
R16590 VSSD.n1152 VSSD.n1147 0.00498219
R16591 VSSD.n1158 VSSD.n1153 0.00498219
R16592 VSSD.n1159 VSSD.n1158 0.00498219
R16593 VSSD.n2050 VSSD.n1161 0.00498219
R16594 VSSD.n1164 VSSD.n1162 0.00498219
R16595 VSSD.n2051 VSSD.n1162 0.00498219
R16596 VSSD.n2099 VSSD.n1166 0.00498219
R16597 VSSD.n2051 VSSD.n1163 0.00498219
R16598 VSSD.n1166 VSSD.n1163 0.00498219
R16599 VSSD.n2050 VSSD.n1165 0.00498219
R16600 VSSD.n1165 VSSD.n1164 0.00498219
R16601 VSSD.n1153 VSSD.n1152 0.00498219
R16602 VSSD.n1147 VSSD.n1146 0.00498219
R16603 VSSD.n1145 VSSD.n1144 0.00498219
R16604 VSSD.n1160 VSSD.n1159 0.00498219
R16605 VSSD.n675 VSSD.n673 0.00498219
R16606 VSSD.n2869 VSSD.n670 0.00498219
R16607 VSSD.n671 VSSD.n668 0.00498219
R16608 VSSD.n2871 VSSD.n659 0.00498219
R16609 VSSD.n628 VSSD.n625 0.00498219
R16610 VSSD.n2886 VSSD.n627 0.00498219
R16611 VSSD.n652 VSSD.n642 0.00498219
R16612 VSSD.n2876 VSSD.n643 0.00498219
R16613 VSSD.n651 VSSD.n641 0.00498219
R16614 VSSD.n2877 VSSD.n644 0.00498219
R16615 VSSD.n650 VSSD.n640 0.00498219
R16616 VSSD.n2878 VSSD.n645 0.00498219
R16617 VSSD.n649 VSSD.n639 0.00498219
R16618 VSSD.n2879 VSSD.n646 0.00498219
R16619 VSSD.n648 VSSD.n638 0.00498219
R16620 VSSD.n2883 VSSD.n647 0.00498219
R16621 VSSD.n2867 VSSD.n675 0.00498219
R16622 VSSD.n673 VSSD.n670 0.00498219
R16623 VSSD.n2869 VSSD.n671 0.00498219
R16624 VSSD.n668 VSSD.n659 0.00498219
R16625 VSSD.n628 VSSD.n626 0.00498219
R16626 VSSD.n627 VSSD.n625 0.00498219
R16627 VSSD.n652 VSSD.n632 0.00498219
R16628 VSSD.n2876 VSSD.n642 0.00498219
R16629 VSSD.n651 VSSD.n643 0.00498219
R16630 VSSD.n2877 VSSD.n641 0.00498219
R16631 VSSD.n650 VSSD.n644 0.00498219
R16632 VSSD.n2878 VSSD.n640 0.00498219
R16633 VSSD.n649 VSSD.n645 0.00498219
R16634 VSSD.n2879 VSSD.n639 0.00498219
R16635 VSSD.n648 VSSD.n646 0.00498219
R16636 VSSD.n647 VSSD.n638 0.00498219
R16637 VSSD.n689 VSSD.n686 0.00498219
R16638 VSSD.n701 VSSD.n697 0.00498219
R16639 VSSD.n706 VSSD.n687 0.00498219
R16640 VSSD.n706 VSSD.n705 0.00498219
R16641 VSSD.n2889 VSSD.n584 0.00498219
R16642 VSSD.n587 VSSD.n585 0.00498219
R16643 VSSD.n2890 VSSD.n585 0.00498219
R16644 VSSD.n2938 VSSD.n589 0.00498219
R16645 VSSD.n2890 VSSD.n586 0.00498219
R16646 VSSD.n589 VSSD.n586 0.00498219
R16647 VSSD.n2889 VSSD.n588 0.00498219
R16648 VSSD.n588 VSSD.n587 0.00498219
R16649 VSSD.n701 VSSD.n687 0.00498219
R16650 VSSD.n697 VSSD.n686 0.00498219
R16651 VSSD.n724 VSSD.n689 0.00498219
R16652 VSSD.n705 VSSD.n685 0.00498219
R16653 VSSD.n492 VSSD.n490 0.00498219
R16654 VSSD.n3008 VSSD.n487 0.00498219
R16655 VSSD.n488 VSSD.n485 0.00498219
R16656 VSSD.n3010 VSSD.n476 0.00498219
R16657 VSSD.n445 VSSD.n442 0.00498219
R16658 VSSD.n3025 VSSD.n444 0.00498219
R16659 VSSD.n469 VSSD.n459 0.00498219
R16660 VSSD.n3015 VSSD.n460 0.00498219
R16661 VSSD.n468 VSSD.n458 0.00498219
R16662 VSSD.n3016 VSSD.n461 0.00498219
R16663 VSSD.n467 VSSD.n457 0.00498219
R16664 VSSD.n3017 VSSD.n462 0.00498219
R16665 VSSD.n466 VSSD.n456 0.00498219
R16666 VSSD.n3018 VSSD.n463 0.00498219
R16667 VSSD.n465 VSSD.n455 0.00498219
R16668 VSSD.n3022 VSSD.n464 0.00498219
R16669 VSSD.n3006 VSSD.n492 0.00498219
R16670 VSSD.n490 VSSD.n487 0.00498219
R16671 VSSD.n3008 VSSD.n488 0.00498219
R16672 VSSD.n485 VSSD.n476 0.00498219
R16673 VSSD.n445 VSSD.n443 0.00498219
R16674 VSSD.n444 VSSD.n442 0.00498219
R16675 VSSD.n469 VSSD.n449 0.00498219
R16676 VSSD.n3015 VSSD.n459 0.00498219
R16677 VSSD.n468 VSSD.n460 0.00498219
R16678 VSSD.n3016 VSSD.n458 0.00498219
R16679 VSSD.n467 VSSD.n461 0.00498219
R16680 VSSD.n3017 VSSD.n457 0.00498219
R16681 VSSD.n466 VSSD.n462 0.00498219
R16682 VSSD.n3018 VSSD.n456 0.00498219
R16683 VSSD.n465 VSSD.n463 0.00498219
R16684 VSSD.n464 VSSD.n455 0.00498219
R16685 VSSD.n505 VSSD.n502 0.00498219
R16686 VSSD.n517 VSSD.n513 0.00498219
R16687 VSSD.n522 VSSD.n503 0.00498219
R16688 VSSD.n522 VSSD.n521 0.00498219
R16689 VSSD.n3028 VSSD.n401 0.00498219
R16690 VSSD.n404 VSSD.n402 0.00498219
R16691 VSSD.n3029 VSSD.n402 0.00498219
R16692 VSSD.n3077 VSSD.n406 0.00498219
R16693 VSSD.n3029 VSSD.n403 0.00498219
R16694 VSSD.n406 VSSD.n403 0.00498219
R16695 VSSD.n3028 VSSD.n405 0.00498219
R16696 VSSD.n405 VSSD.n404 0.00498219
R16697 VSSD.n517 VSSD.n503 0.00498219
R16698 VSSD.n513 VSSD.n502 0.00498219
R16699 VSSD.n540 VSSD.n505 0.00498219
R16700 VSSD.n521 VSSD.n501 0.00498219
R16701 VSSD.n2736 VSSD.n2732 0.00498219
R16702 VSSD.n2743 VSSD.n2740 0.00498219
R16703 VSSD.n2741 VSSD.n2730 0.00498219
R16704 VSSD.n2745 VSSD.n837 0.00498219
R16705 VSSD.n800 VSSD.n796 0.00498219
R16706 VSSD.n2753 VSSD.n799 0.00498219
R16707 VSSD.n815 VSSD.n814 0.00498219
R16708 VSSD.n825 VSSD.n818 0.00498219
R16709 VSSD.n817 VSSD.n813 0.00498219
R16710 VSSD.n826 VSSD.n820 0.00498219
R16711 VSSD.n819 VSSD.n812 0.00498219
R16712 VSSD.n827 VSSD.n822 0.00498219
R16713 VSSD.n821 VSSD.n811 0.00498219
R16714 VSSD.n828 VSSD.n824 0.00498219
R16715 VSSD.n823 VSSD.n810 0.00498219
R16716 VSSD.n2750 VSSD.n830 0.00498219
R16717 VSSD.n2737 VSSD.n2736 0.00498219
R16718 VSSD.n2740 VSSD.n2732 0.00498219
R16719 VSSD.n2743 VSSD.n2741 0.00498219
R16720 VSSD.n2730 VSSD.n837 0.00498219
R16721 VSSD.n800 VSSD.n798 0.00498219
R16722 VSSD.n799 VSSD.n796 0.00498219
R16723 VSSD.n814 VSSD.n805 0.00498219
R16724 VSSD.n825 VSSD.n815 0.00498219
R16725 VSSD.n818 VSSD.n817 0.00498219
R16726 VSSD.n826 VSSD.n813 0.00498219
R16727 VSSD.n820 VSSD.n819 0.00498219
R16728 VSSD.n827 VSSD.n812 0.00498219
R16729 VSSD.n822 VSSD.n821 0.00498219
R16730 VSSD.n828 VSSD.n811 0.00498219
R16731 VSSD.n824 VSSD.n823 0.00498219
R16732 VSSD.n830 VSSD.n810 0.00498219
R16733 VSSD.n2387 VSSD.n2381 0.00498219
R16734 VSSD.n2397 VSSD.n2396 0.00498219
R16735 VSSD.n2395 VSSD.n2394 0.00498219
R16736 VSSD.n2394 VSSD.n2393 0.00498219
R16737 VSSD.n773 VSSD.n764 0.00498219
R16738 VSSD.n775 VSSD.n765 0.00498219
R16739 VSSD.n2813 VSSD.n765 0.00498219
R16740 VSSD.n2810 VSSD.n766 0.00498219
R16741 VSSD.n2813 VSSD.n2812 0.00498219
R16742 VSSD.n2812 VSSD.n766 0.00498219
R16743 VSSD.n777 VSSD.n764 0.00498219
R16744 VSSD.n777 VSSD.n775 0.00498219
R16745 VSSD.n2396 VSSD.n2395 0.00498219
R16746 VSSD.n2397 VSSD.n2381 0.00498219
R16747 VSSD.n2389 VSSD.n2387 0.00498219
R16748 VSSD.n2393 VSSD.n2379 0.00498219
R16749 VSSD.n1009 VSSD.n1003 0.00498219
R16750 VSSD.n1012 VSSD.n1002 0.00498219
R16751 VSSD.n1011 VSSD.n1008 0.00498219
R16752 VSSD.n2335 VSSD.n1001 0.00498219
R16753 VSSD.n2313 VSSD.n2308 0.00498219
R16754 VSSD.n2322 VSSD.n2309 0.00498219
R16755 VSSD.n1037 VSSD.n1025 0.00498219
R16756 VSSD.n2314 VSSD.n1028 0.00498219
R16757 VSSD.n1036 VSSD.n1024 0.00498219
R16758 VSSD.n2315 VSSD.n1029 0.00498219
R16759 VSSD.n1035 VSSD.n1023 0.00498219
R16760 VSSD.n2316 VSSD.n1030 0.00498219
R16761 VSSD.n1034 VSSD.n1022 0.00498219
R16762 VSSD.n2317 VSSD.n1031 0.00498219
R16763 VSSD.n1033 VSSD.n1021 0.00498219
R16764 VSSD.n2325 VSSD.n1032 0.00498219
R16765 VSSD.n2337 VSSD.n1003 0.00498219
R16766 VSSD.n1009 VSSD.n1002 0.00498219
R16767 VSSD.n1012 VSSD.n1011 0.00498219
R16768 VSSD.n1008 VSSD.n1001 0.00498219
R16769 VSSD.n2320 VSSD.n2308 0.00498219
R16770 VSSD.n2313 VSSD.n2309 0.00498219
R16771 VSSD.n1037 VSSD.n1027 0.00498219
R16772 VSSD.n2314 VSSD.n1025 0.00498219
R16773 VSSD.n1036 VSSD.n1028 0.00498219
R16774 VSSD.n2315 VSSD.n1024 0.00498219
R16775 VSSD.n1035 VSSD.n1029 0.00498219
R16776 VSSD.n2316 VSSD.n1023 0.00498219
R16777 VSSD.n1034 VSSD.n1030 0.00498219
R16778 VSSD.n2317 VSSD.n1022 0.00498219
R16779 VSSD.n1033 VSSD.n1031 0.00498219
R16780 VSSD.n1032 VSSD.n1021 0.00498219
R16781 VSSD.n2193 VSSD.n2187 0.00498219
R16782 VSSD.n2203 VSSD.n2202 0.00498219
R16783 VSSD.n2201 VSSD.n2200 0.00498219
R16784 VSSD.n2200 VSSD.n2199 0.00498219
R16785 VSSD.n2254 VSSD.n1047 0.00498219
R16786 VSSD.n1050 VSSD.n1048 0.00498219
R16787 VSSD.n2255 VSSD.n1048 0.00498219
R16788 VSSD.n2303 VSSD.n1052 0.00498219
R16789 VSSD.n2255 VSSD.n1049 0.00498219
R16790 VSSD.n1052 VSSD.n1049 0.00498219
R16791 VSSD.n2254 VSSD.n1051 0.00498219
R16792 VSSD.n1051 VSSD.n1050 0.00498219
R16793 VSSD.n2202 VSSD.n2201 0.00498219
R16794 VSSD.n2203 VSSD.n2187 0.00498219
R16795 VSSD.n2195 VSSD.n2193 0.00498219
R16796 VSSD.n2199 VSSD.n2185 0.00498219
R16797 VSSD.n1684 VSSD.n1680 0.00498219
R16798 VSSD.n1691 VSSD.n1688 0.00498219
R16799 VSSD.n1689 VSSD.n1678 0.00498219
R16800 VSSD.n1693 VSSD.n1634 0.00498219
R16801 VSSD.n1597 VSSD.n1593 0.00498219
R16802 VSSD.n1701 VSSD.n1596 0.00498219
R16803 VSSD.n1612 VSSD.n1611 0.00498219
R16804 VSSD.n1622 VSSD.n1615 0.00498219
R16805 VSSD.n1614 VSSD.n1610 0.00498219
R16806 VSSD.n1623 VSSD.n1617 0.00498219
R16807 VSSD.n1616 VSSD.n1609 0.00498219
R16808 VSSD.n1624 VSSD.n1619 0.00498219
R16809 VSSD.n1618 VSSD.n1608 0.00498219
R16810 VSSD.n1625 VSSD.n1621 0.00498219
R16811 VSSD.n1620 VSSD.n1607 0.00498219
R16812 VSSD.n1698 VSSD.n1627 0.00498219
R16813 VSSD.n1685 VSSD.n1684 0.00498219
R16814 VSSD.n1688 VSSD.n1680 0.00498219
R16815 VSSD.n1691 VSSD.n1689 0.00498219
R16816 VSSD.n1678 VSSD.n1634 0.00498219
R16817 VSSD.n1597 VSSD.n1595 0.00498219
R16818 VSSD.n1596 VSSD.n1593 0.00498219
R16819 VSSD.n1611 VSSD.n1602 0.00498219
R16820 VSSD.n1622 VSSD.n1612 0.00498219
R16821 VSSD.n1615 VSSD.n1614 0.00498219
R16822 VSSD.n1623 VSSD.n1610 0.00498219
R16823 VSSD.n1617 VSSD.n1616 0.00498219
R16824 VSSD.n1624 VSSD.n1609 0.00498219
R16825 VSSD.n1619 VSSD.n1618 0.00498219
R16826 VSSD.n1625 VSSD.n1608 0.00498219
R16827 VSSD.n1621 VSSD.n1620 0.00498219
R16828 VSSD.n1627 VSSD.n1607 0.00498219
R16829 VSSD.n1490 VSSD.n1478 0.00498219
R16830 VSSD.n1904 VSSD.n1902 0.00498219
R16831 VSSD.n1481 VSSD.n1479 0.00498219
R16832 VSSD.n1480 VSSD.n1476 0.00498219
R16833 VSSD.n1965 VSSD.n1962 0.00498219
R16834 VSSD.n1977 VSSD.n1973 0.00498219
R16835 VSSD.n1982 VSSD.n1963 0.00498219
R16836 VSSD.n1982 VSSD.n1981 0.00498219
R16837 VSSD.n1960 VSSD.n1269 0.00498219
R16838 VSSD.n1282 VSSD.n1276 0.00498219
R16839 VSSD.n1934 VSSD.n1276 0.00498219
R16840 VSSD.n1958 VSSD.n1284 0.00498219
R16841 VSSD.n1934 VSSD.n1281 0.00498219
R16842 VSSD.n1284 VSSD.n1281 0.00498219
R16843 VSSD.n1283 VSSD.n1269 0.00498219
R16844 VSSD.n1283 VSSD.n1282 0.00498219
R16845 VSSD.n1977 VSSD.n1963 0.00498219
R16846 VSSD.n1973 VSSD.n1962 0.00498219
R16847 VSSD.n2000 VSSD.n1965 0.00498219
R16848 VSSD.n1981 VSSD.n1961 0.00498219
R16849 VSSD.n268 VSSD.n266 0.00498219
R16850 VSSD.n3301 VSSD.n263 0.00498219
R16851 VSSD.n264 VSSD.n261 0.00498219
R16852 VSSD.n3303 VSSD.n252 0.00498219
R16853 VSSD.n3311 VSSD.n3309 0.00498219
R16854 VSSD.n3316 VSSD.n243 0.00498219
R16855 VSSD.n3299 VSSD.n268 0.00498219
R16856 VSSD.n266 VSSD.n263 0.00498219
R16857 VSSD.n3301 VSSD.n264 0.00498219
R16858 VSSD.n261 VSSD.n252 0.00498219
R16859 VSSD.n3309 VSSD.n242 0.00498219
R16860 VSSD.n3311 VSSD.n243 0.00498219
R16861 VSSD.n1882 VSSD.n1880 0.0049098
R16862 VSSD.n3556 VSSD.n3554 0.0049098
R16863 VSSD.n975 VSSD.n961 0.0049098
R16864 VSSD.n352 VSSD.n337 0.0049098
R16865 VSSD.n2032 VSSD.n1241 0.0049098
R16866 VSSD.n2865 VSSD.n660 0.0049098
R16867 VSSD.n3004 VSSD.n477 0.0049098
R16868 VSSD.n2726 VSSD.n2724 0.0049098
R16869 VSSD.n2330 VSSD.n1000 0.0049098
R16870 VSSD.n1674 VSSD.n1672 0.0049098
R16871 VSSD.n3297 VSSD.n253 0.0049098
R16872 VSSD.n3141 VSSD.n364 0.00419
R16873 VSSD.n3129 VSSD.n383 0.00419
R16874 VSSD.n3139 VSSD.n3138 0.00419
R16875 VSSD.n3137 VSSD.n382 0.00419
R16876 VSSD.n381 VSSD.n360 0.00419
R16877 VSSD.n3132 VSSD.n365 0.00419
R16878 VSSD.n3130 VSSD.n380 0.00419
R16879 VSSD.n3131 VSSD.n378 0.00419
R16880 VSSD.n2043 VSSD.n1206 0.00419
R16881 VSSD.n2046 VSSD.n1213 0.00419
R16882 VSSD.n2045 VSSD.n1220 0.00419
R16883 VSSD.n1233 VSSD.n1212 0.00419
R16884 VSSD.n1235 VSSD.n1211 0.00419
R16885 VSSD.n1237 VSSD.n1208 0.00419
R16886 VSSD.n1236 VSSD.n1210 0.00419
R16887 VSSD.n2048 VSSD.n1201 0.00419
R16888 VSSD.n2884 VSSD.n629 0.00419
R16889 VSSD.n653 VSSD.n636 0.00419
R16890 VSSD.n2882 VSSD.n2881 0.00419
R16891 VSSD.n2880 VSSD.n635 0.00419
R16892 VSSD.n654 VSSD.n634 0.00419
R16893 VSSD.n656 VSSD.n631 0.00419
R16894 VSSD.n655 VSSD.n633 0.00419
R16895 VSSD.n2887 VSSD.n624 0.00419
R16896 VSSD.n3023 VSSD.n446 0.00419
R16897 VSSD.n470 VSSD.n453 0.00419
R16898 VSSD.n3021 VSSD.n3020 0.00419
R16899 VSSD.n3019 VSSD.n452 0.00419
R16900 VSSD.n471 VSSD.n451 0.00419
R16901 VSSD.n473 VSSD.n448 0.00419
R16902 VSSD.n472 VSSD.n450 0.00419
R16903 VSSD.n3026 VSSD.n441 0.00419
R16904 VSSD.n3318 VSSD.n167 0.00409787
R16905 VSSD.n211 VSSD.n167 0.00409787
R16906 VSSD.n197 VSSD.n166 0.00409787
R16907 VSSD.n210 VSSD.n166 0.00409787
R16908 VSSD.n196 VSSD.n165 0.00409787
R16909 VSSD.n209 VSSD.n165 0.00409787
R16910 VSSD.n195 VSSD.n164 0.00409787
R16911 VSSD.n208 VSSD.n164 0.00409787
R16912 VSSD.n194 VSSD.n163 0.00409787
R16913 VSSD.n207 VSSD.n163 0.00409787
R16914 VSSD.n193 VSSD.n162 0.00409787
R16915 VSSD.n206 VSSD.n162 0.00409787
R16916 VSSD.n192 VSSD.n161 0.00409787
R16917 VSSD.n205 VSSD.n161 0.00409787
R16918 VSSD.n191 VSSD.n160 0.00409787
R16919 VSSD.n204 VSSD.n160 0.00409787
R16920 VSSD.n190 VSSD.n159 0.00409787
R16921 VSSD.n203 VSSD.n159 0.00409787
R16922 VSSD.n189 VSSD.n158 0.00409787
R16923 VSSD.n202 VSSD.n158 0.00409787
R16924 VSSD.n188 VSSD.n157 0.00409787
R16925 VSSD.n201 VSSD.n157 0.00409787
R16926 VSSD.n187 VSSD.n156 0.00409787
R16927 VSSD.n185 VSSD.n156 0.00409787
R16928 VSSD.n200 VSSD.n155 0.00409787
R16929 VSSD.n227 VSSD.n155 0.00409787
R16930 VSSD.n3367 VSSD.n154 0.00409787
R16931 VSSD.n3368 VSSD.n3367 0.00409787
R16932 VSSD.n197 VSSD.n169 0.00409787
R16933 VSSD.n196 VSSD.n170 0.00409787
R16934 VSSD.n195 VSSD.n171 0.00409787
R16935 VSSD.n194 VSSD.n172 0.00409787
R16936 VSSD.n193 VSSD.n173 0.00409787
R16937 VSSD.n192 VSSD.n174 0.00409787
R16938 VSSD.n191 VSSD.n175 0.00409787
R16939 VSSD.n190 VSSD.n176 0.00409787
R16940 VSSD.n189 VSSD.n177 0.00409787
R16941 VSSD.n188 VSSD.n178 0.00409787
R16942 VSSD.n187 VSSD.n179 0.00409787
R16943 VSSD.n211 VSSD.n169 0.00409787
R16944 VSSD.n210 VSSD.n170 0.00409787
R16945 VSSD.n209 VSSD.n171 0.00409787
R16946 VSSD.n208 VSSD.n172 0.00409787
R16947 VSSD.n207 VSSD.n173 0.00409787
R16948 VSSD.n206 VSSD.n174 0.00409787
R16949 VSSD.n205 VSSD.n175 0.00409787
R16950 VSSD.n204 VSSD.n176 0.00409787
R16951 VSSD.n203 VSSD.n177 0.00409787
R16952 VSSD.n202 VSSD.n178 0.00409787
R16953 VSSD.n201 VSSD.n179 0.00409787
R16954 VSSD.n200 VSSD.n180 0.00409787
R16955 VSSD.n185 VSSD.n180 0.00409787
R16956 VSSD.n228 VSSD.n227 0.00409787
R16957 VSSD.n228 VSSD.n154 0.00409787
R16958 VSSD.n3369 VSSD.n3368 0.00409787
R16959 VSSD.n3324 VSSD.n3318 0.00409787
R16960 VSSD.n3492 VSSD.n142 0.00409787
R16961 VSSD.n3492 VSSD.n148 0.00409787
R16962 VSSD.n3489 VSSD.n3385 0.00409787
R16963 VSSD.n3486 VSSD.n3385 0.00409787
R16964 VSSD.n3400 VSSD.n3384 0.00409787
R16965 VSSD.n3400 VSSD.n3397 0.00409787
R16966 VSSD.n3477 VSSD.n3383 0.00409787
R16967 VSSD.n3477 VSSD.n3396 0.00409787
R16968 VSSD.n3405 VSSD.n3382 0.00409787
R16969 VSSD.n3405 VSSD.n3395 0.00409787
R16970 VSSD.n3469 VSSD.n3381 0.00409787
R16971 VSSD.n3469 VSSD.n3394 0.00409787
R16972 VSSD.n3409 VSSD.n3380 0.00409787
R16973 VSSD.n3409 VSSD.n3393 0.00409787
R16974 VSSD.n3461 VSSD.n3379 0.00409787
R16975 VSSD.n3461 VSSD.n3392 0.00409787
R16976 VSSD.n3413 VSSD.n3378 0.00409787
R16977 VSSD.n3413 VSSD.n3391 0.00409787
R16978 VSSD.n3453 VSSD.n3377 0.00409787
R16979 VSSD.n3453 VSSD.n3390 0.00409787
R16980 VSSD.n3417 VSSD.n3376 0.00409787
R16981 VSSD.n3417 VSSD.n3389 0.00409787
R16982 VSSD.n3445 VSSD.n3375 0.00409787
R16983 VSSD.n3445 VSSD.n3388 0.00409787
R16984 VSSD.n3426 VSSD.n3374 0.00409787
R16985 VSSD.n3426 VSSD.n3387 0.00409787
R16986 VSSD.n3437 VSSD.n3373 0.00409787
R16987 VSSD.n3436 VSSD.n3435 0.00409787
R16988 VSSD.n3489 VSSD.n3488 0.00409787
R16989 VSSD.n3485 VSSD.n3384 0.00409787
R16990 VSSD.n3479 VSSD.n3383 0.00409787
R16991 VSSD.n3407 VSSD.n3382 0.00409787
R16992 VSSD.n3471 VSSD.n3381 0.00409787
R16993 VSSD.n3411 VSSD.n3380 0.00409787
R16994 VSSD.n3463 VSSD.n3379 0.00409787
R16995 VSSD.n3415 VSSD.n3378 0.00409787
R16996 VSSD.n3455 VSSD.n3377 0.00409787
R16997 VSSD.n3419 VSSD.n3376 0.00409787
R16998 VSSD.n3447 VSSD.n3375 0.00409787
R16999 VSSD.n3428 VSSD.n3374 0.00409787
R17000 VSSD.n3439 VSSD.n3373 0.00409787
R17001 VSSD.n142 VSSD.n140 0.00409787
R17002 VSSD.n3486 VSSD.n3485 0.00409787
R17003 VSSD.n3479 VSSD.n3397 0.00409787
R17004 VSSD.n3407 VSSD.n3396 0.00409787
R17005 VSSD.n3471 VSSD.n3395 0.00409787
R17006 VSSD.n3411 VSSD.n3394 0.00409787
R17007 VSSD.n3463 VSSD.n3393 0.00409787
R17008 VSSD.n3415 VSSD.n3392 0.00409787
R17009 VSSD.n3455 VSSD.n3391 0.00409787
R17010 VSSD.n3419 VSSD.n3390 0.00409787
R17011 VSSD.n3447 VSSD.n3389 0.00409787
R17012 VSSD.n3428 VSSD.n3388 0.00409787
R17013 VSSD.n3439 VSSD.n3387 0.00409787
R17014 VSSD.n3488 VSSD.n148 0.00409787
R17015 VSSD.n3437 VSSD.n3436 0.00409787
R17016 VSSD.n3366 VSSD.n199 0.00404422
R17017 VSSD.n3438 VSSD.n3429 0.00404422
R17018 VSSD.n2457 VSSD.n908 0.00391463
R17019 VSSD.n2455 VSSD.n907 0.00391463
R17020 VSSD.n2453 VSSD.n906 0.00391463
R17021 VSSD.n2451 VSSD.n905 0.00391463
R17022 VSSD.n2449 VSSD.n904 0.00391463
R17023 VSSD.n903 VSSD.n902 0.00391463
R17024 VSSD.n2683 VSSD.n893 0.00391463
R17025 VSSD.n2682 VSSD.n898 0.00391463
R17026 VSSD.n2673 VSSD.n2653 0.00391463
R17027 VSSD.n2592 VSSD.n58 0.00391463
R17028 VSSD.n2590 VSSD.n57 0.00391463
R17029 VSSD.n2588 VSSD.n56 0.00391463
R17030 VSSD.n2586 VSSD.n55 0.00391463
R17031 VSSD.n2584 VSSD.n54 0.00391463
R17032 VSSD.n53 VSSD.n52 0.00391463
R17033 VSSD.n3631 VSSD.n43 0.00391463
R17034 VSSD.n3630 VSSD.n48 0.00391463
R17035 VSSD.n3621 VSSD.n3601 0.00391463
R17036 VSSD.n2770 VSSD.n761 0.00391463
R17037 VSSD.n2773 VSSD.n2771 0.00391463
R17038 VSSD.n2777 VSSD.n2776 0.00391463
R17039 VSSD.n2778 VSSD.n2769 0.00391463
R17040 VSSD.n2779 VSSD.n787 0.00391463
R17041 VSSD.n2768 VSSD.n788 0.00391463
R17042 VSSD.n2801 VSSD.n789 0.00391463
R17043 VSSD.n2804 VSSD.n790 0.00391463
R17044 VSSD.n2803 VSSD.n2755 0.00391463
R17045 VSSD.n2258 VSSD.n1079 0.00391463
R17046 VSSD.n2262 VSSD.n1077 0.00391463
R17047 VSSD.n2264 VSSD.n1080 0.00391463
R17048 VSSD.n1081 VSSD.n1076 0.00391463
R17049 VSSD.n2296 VSSD.n2268 0.00391463
R17050 VSSD.n2274 VSSD.n2273 0.00391463
R17051 VSSD.n2300 VSSD.n1067 0.00391463
R17052 VSSD.n2299 VSSD.n1068 0.00391463
R17053 VSSD.n2306 VSSD.n1044 0.00391463
R17054 VSSD.n1836 VSSD.n1835 0.00391463
R17055 VSSD.n1832 VSSD.n1824 0.00391463
R17056 VSSD.n1830 VSSD.n1721 0.00391463
R17057 VSSD.n1828 VSSD.n1570 0.00391463
R17058 VSSD.n1826 VSSD.n1720 0.00391463
R17059 VSSD.n1572 VSSD.n1571 0.00391463
R17060 VSSD.n1839 VSSD.n1553 0.00391463
R17061 VSSD.n1838 VSSD.n1559 0.00391463
R17062 VSSD.n1719 VSSD.n1718 0.00391463
R17063 VSSD.n3583 VSSD.n3582 0.00378827
R17064 VSSD.n3581 VSSD.n3580 0.00378827
R17065 VSSD.n78 VSSD.n71 0.00378827
R17066 VSSD.n77 VSSD.n72 0.00378827
R17067 VSSD.n75 VSSD.n72 0.00378827
R17068 VSSD.n74 VSSD.n73 0.00378827
R17069 VSSD.n76 VSSD.n75 0.00378827
R17070 VSSD.n79 VSSD.n78 0.00378827
R17071 VSSD.n3580 VSSD.n3579 0.00378827
R17072 VSSD.n76 VSSD.n74 0.00378827
R17073 VSSD.n79 VSSD.n77 0.00378827
R17074 VSSD.n3583 VSSD.n67 0.00378827
R17075 VSSD.n1447 VSSD.n1400 0.00378827
R17076 VSSD.n1432 VSSD.n1400 0.00378827
R17077 VSSD.n1448 VSSD.n1401 0.00378827
R17078 VSSD.n1433 VSSD.n1401 0.00378827
R17079 VSSD.n1449 VSSD.n1402 0.00378827
R17080 VSSD.n1434 VSSD.n1402 0.00378827
R17081 VSSD.n1450 VSSD.n1403 0.00378827
R17082 VSSD.n1435 VSSD.n1403 0.00378827
R17083 VSSD.n1451 VSSD.n1404 0.00378827
R17084 VSSD.n1436 VSSD.n1404 0.00378827
R17085 VSSD.n1452 VSSD.n1405 0.00378827
R17086 VSSD.n1437 VSSD.n1405 0.00378827
R17087 VSSD.n1453 VSSD.n1406 0.00378827
R17088 VSSD.n1438 VSSD.n1406 0.00378827
R17089 VSSD.n1454 VSSD.n1407 0.00378827
R17090 VSSD.n1439 VSSD.n1407 0.00378827
R17091 VSSD.n1455 VSSD.n1408 0.00378827
R17092 VSSD.n1440 VSSD.n1408 0.00378827
R17093 VSSD.n1456 VSSD.n1409 0.00378827
R17094 VSSD.n1441 VSSD.n1409 0.00378827
R17095 VSSD.n1457 VSSD.n1410 0.00378827
R17096 VSSD.n1442 VSSD.n1410 0.00378827
R17097 VSSD.n1458 VSSD.n1411 0.00378827
R17098 VSSD.n1443 VSSD.n1411 0.00378827
R17099 VSSD.n1470 VSSD.n1469 0.00378827
R17100 VSSD.n1909 VSSD.n1412 0.00378827
R17101 VSSD.n1443 VSSD.n1413 0.00378827
R17102 VSSD.n1442 VSSD.n1414 0.00378827
R17103 VSSD.n1441 VSSD.n1415 0.00378827
R17104 VSSD.n1440 VSSD.n1416 0.00378827
R17105 VSSD.n1439 VSSD.n1417 0.00378827
R17106 VSSD.n1438 VSSD.n1418 0.00378827
R17107 VSSD.n1437 VSSD.n1419 0.00378827
R17108 VSSD.n1436 VSSD.n1420 0.00378827
R17109 VSSD.n1435 VSSD.n1421 0.00378827
R17110 VSSD.n1434 VSSD.n1422 0.00378827
R17111 VSSD.n1433 VSSD.n1423 0.00378827
R17112 VSSD.n1432 VSSD.n1424 0.00378827
R17113 VSSD.n1469 VSSD.n1413 0.00378827
R17114 VSSD.n1458 VSSD.n1414 0.00378827
R17115 VSSD.n1457 VSSD.n1415 0.00378827
R17116 VSSD.n1456 VSSD.n1416 0.00378827
R17117 VSSD.n1455 VSSD.n1417 0.00378827
R17118 VSSD.n1454 VSSD.n1418 0.00378827
R17119 VSSD.n1453 VSSD.n1419 0.00378827
R17120 VSSD.n1452 VSSD.n1420 0.00378827
R17121 VSSD.n1451 VSSD.n1421 0.00378827
R17122 VSSD.n1450 VSSD.n1422 0.00378827
R17123 VSSD.n1449 VSSD.n1423 0.00378827
R17124 VSSD.n1448 VSSD.n1424 0.00378827
R17125 VSSD.n1447 VSSD.n1425 0.00378827
R17126 VSSD.n1470 VSSD.n1412 0.00378827
R17127 VSSD.n1930 VSSD.n1373 0.00378827
R17128 VSSD.n1928 VSSD.n1371 0.00378827
R17129 VSSD.n1928 VSSD.n1927 0.00378827
R17130 VSSD.n1398 VSSD.n1381 0.00378827
R17131 VSSD.n1914 VSSD.n1370 0.00378827
R17132 VSSD.n1382 VSSD.n1347 0.00378827
R17133 VSSD.n1915 VSSD.n1369 0.00378827
R17134 VSSD.n1383 VSSD.n1348 0.00378827
R17135 VSSD.n1916 VSSD.n1368 0.00378827
R17136 VSSD.n1384 VSSD.n1349 0.00378827
R17137 VSSD.n1917 VSSD.n1367 0.00378827
R17138 VSSD.n1385 VSSD.n1350 0.00378827
R17139 VSSD.n1918 VSSD.n1366 0.00378827
R17140 VSSD.n1386 VSSD.n1351 0.00378827
R17141 VSSD.n1919 VSSD.n1365 0.00378827
R17142 VSSD.n1387 VSSD.n1352 0.00378827
R17143 VSSD.n1920 VSSD.n1364 0.00378827
R17144 VSSD.n1388 VSSD.n1353 0.00378827
R17145 VSSD.n1921 VSSD.n1363 0.00378827
R17146 VSSD.n1389 VSSD.n1354 0.00378827
R17147 VSSD.n1922 VSSD.n1362 0.00378827
R17148 VSSD.n1390 VSSD.n1355 0.00378827
R17149 VSSD.n1923 VSSD.n1361 0.00378827
R17150 VSSD.n1391 VSSD.n1356 0.00378827
R17151 VSSD.n1924 VSSD.n1360 0.00378827
R17152 VSSD.n1392 VSSD.n1357 0.00378827
R17153 VSSD.n1925 VSSD.n1359 0.00378827
R17154 VSSD.n1358 VSSD.n1339 0.00378827
R17155 VSSD.n1925 VSSD.n1358 0.00378827
R17156 VSSD.n1924 VSSD.n1357 0.00378827
R17157 VSSD.n1923 VSSD.n1356 0.00378827
R17158 VSSD.n1922 VSSD.n1355 0.00378827
R17159 VSSD.n1921 VSSD.n1354 0.00378827
R17160 VSSD.n1920 VSSD.n1353 0.00378827
R17161 VSSD.n1919 VSSD.n1352 0.00378827
R17162 VSSD.n1918 VSSD.n1351 0.00378827
R17163 VSSD.n1917 VSSD.n1350 0.00378827
R17164 VSSD.n1916 VSSD.n1349 0.00378827
R17165 VSSD.n1915 VSSD.n1348 0.00378827
R17166 VSSD.n1914 VSSD.n1347 0.00378827
R17167 VSSD.n1927 VSSD.n1398 0.00378827
R17168 VSSD.n1379 VSSD.n1373 0.00378827
R17169 VSSD.n1392 VSSD.n1359 0.00378827
R17170 VSSD.n1391 VSSD.n1360 0.00378827
R17171 VSSD.n1390 VSSD.n1361 0.00378827
R17172 VSSD.n1389 VSSD.n1362 0.00378827
R17173 VSSD.n1388 VSSD.n1363 0.00378827
R17174 VSSD.n1387 VSSD.n1364 0.00378827
R17175 VSSD.n1386 VSSD.n1365 0.00378827
R17176 VSSD.n1385 VSSD.n1366 0.00378827
R17177 VSSD.n1384 VSSD.n1367 0.00378827
R17178 VSSD.n1383 VSSD.n1368 0.00378827
R17179 VSSD.n1382 VSSD.n1369 0.00378827
R17180 VSSD.n1381 VSSD.n1370 0.00378827
R17181 VSSD.n1932 VSSD.n1339 0.00378827
R17182 VSSD.n1379 VSSD.n1371 0.00378827
R17183 VSSD.n3315 VSSD.n3314 0.00378827
R17184 VSSD.n3313 VSSD.n3312 0.00378827
R17185 VSSD.n248 VSSD.n244 0.00378827
R17186 VSSD.n3310 VSSD.n245 0.00378827
R17187 VSSD.n246 VSSD.n245 0.00378827
R17188 VSSD.n3317 VSSD.n241 0.00378827
R17189 VSSD.n247 VSSD.n246 0.00378827
R17190 VSSD.n249 VSSD.n248 0.00378827
R17191 VSSD.n3312 VSSD.n3307 0.00378827
R17192 VSSD.n247 VSSD.n241 0.00378827
R17193 VSSD.n3310 VSSD.n249 0.00378827
R17194 VSSD.n3315 VSSD.n3308 0.00378827
R17195 VSSD.n2637 VSSD.n917 0.00365
R17196 VSSD.n929 VSSD.n921 0.00365
R17197 VSSD.n2635 VSSD.n2634 0.00365
R17198 VSSD.n949 VSSD.n936 0.00365
R17199 VSSD.n951 VSSD.n922 0.00365
R17200 VSSD.n954 VSSD.n927 0.00365
R17201 VSSD.n952 VSSD.n923 0.00365
R17202 VSSD.n953 VSSD.n926 0.00365
R17203 VSSD.n2754 VSSD.n797 0.00365
R17204 VSSD.n809 VSSD.n801 0.00365
R17205 VSSD.n2752 VSSD.n2751 0.00365
R17206 VSSD.n829 VSSD.n816 0.00365
R17207 VSSD.n831 VSSD.n802 0.00365
R17208 VSSD.n834 VSSD.n807 0.00365
R17209 VSSD.n832 VSSD.n803 0.00365
R17210 VSSD.n833 VSSD.n806 0.00365
R17211 VSSD.n2324 VSSD.n2307 0.00365
R17212 VSSD.n2323 VSSD.n1038 0.00365
R17213 VSSD.n2321 VSSD.n1043 0.00365
R17214 VSSD.n2319 VSSD.n2318 0.00365
R17215 VSSD.n1039 VSSD.n1026 0.00365
R17216 VSSD.n2312 VSSD.n1042 0.00365
R17217 VSSD.n2310 VSSD.n1040 0.00365
R17218 VSSD.n2311 VSSD.n1041 0.00365
R17219 VSSD.n1702 VSSD.n1594 0.00365
R17220 VSSD.n1606 VSSD.n1598 0.00365
R17221 VSSD.n1700 VSSD.n1699 0.00365
R17222 VSSD.n1626 VSSD.n1613 0.00365
R17223 VSSD.n1628 VSSD.n1599 0.00365
R17224 VSSD.n1631 VSSD.n1604 0.00365
R17225 VSSD.n1629 VSSD.n1600 0.00365
R17226 VSSD.n1630 VSSD.n1603 0.00365
R17227 VSSD.n374 VSSD.n319 0.00342683
R17228 VSSD.n372 VSSD.n318 0.00342683
R17229 VSSD.n370 VSSD.n317 0.00342683
R17230 VSSD.n368 VSSD.n316 0.00342683
R17231 VSSD.n366 VSSD.n315 0.00342683
R17232 VSSD.n314 VSSD.n313 0.00342683
R17233 VSSD.n3240 VSSD.n304 0.00342683
R17234 VSSD.n3239 VSSD.n309 0.00342683
R17235 VSSD.n3230 VSSD.n3210 0.00342683
R17236 VSSD.n2054 VSSD.n1193 0.00342683
R17237 VSSD.n2058 VSSD.n1191 0.00342683
R17238 VSSD.n2060 VSSD.n1194 0.00342683
R17239 VSSD.n1195 VSSD.n1190 0.00342683
R17240 VSSD.n2092 VSSD.n2064 0.00342683
R17241 VSSD.n2070 VSSD.n2069 0.00342683
R17242 VSSD.n2096 VSSD.n1181 0.00342683
R17243 VSSD.n2095 VSSD.n1182 0.00342683
R17244 VSSD.n2102 VSSD.n1110 0.00342683
R17245 VSSD.n2893 VSSD.n616 0.00342683
R17246 VSSD.n2897 VSSD.n614 0.00342683
R17247 VSSD.n2899 VSSD.n617 0.00342683
R17248 VSSD.n618 VSSD.n613 0.00342683
R17249 VSSD.n2931 VSSD.n2903 0.00342683
R17250 VSSD.n2909 VSSD.n2908 0.00342683
R17251 VSSD.n2935 VSSD.n604 0.00342683
R17252 VSSD.n2934 VSSD.n605 0.00342683
R17253 VSSD.n2941 VSSD.n581 0.00342683
R17254 VSSD.n3032 VSSD.n433 0.00342683
R17255 VSSD.n3036 VSSD.n431 0.00342683
R17256 VSSD.n3038 VSSD.n434 0.00342683
R17257 VSSD.n435 VSSD.n430 0.00342683
R17258 VSSD.n3070 VSSD.n3042 0.00342683
R17259 VSSD.n3048 VSSD.n3047 0.00342683
R17260 VSSD.n3074 VSSD.n421 0.00342683
R17261 VSSD.n3073 VSSD.n422 0.00342683
R17262 VSSD.n3080 VSSD.n398 0.00342683
R17263 VSSD.n1952 VSSD.n1951 0.00342683
R17264 VSSD.n1937 VSSD.n1291 0.00342683
R17265 VSSD.n1938 VSSD.n1292 0.00342683
R17266 VSSD.n1939 VSSD.n1293 0.00342683
R17267 VSSD.n1940 VSSD.n1294 0.00342683
R17268 VSSD.n1941 VSSD.n1295 0.00342683
R17269 VSSD.n1942 VSSD.n1296 0.00342683
R17270 VSSD.n1298 VSSD.n1297 0.00342683
R17271 VSSD.n1954 VSSD.n1304 0.00342683
R17272 VSSD.n3579 VSSD.n3578 0.00329
R17273 VSSD.n3578 VSSD.n71 0.00329
R17274 VSSD.n2631 VSSD.n928 0.00329
R17275 VSSD.n3145 VSSD.n3144 0.00329
R17276 VSSD.n2041 VSSD.n1207 0.00329
R17277 VSSD.n2874 VSSD.n630 0.00329
R17278 VSSD.n3013 VSSD.n447 0.00329
R17279 VSSD.n2748 VSSD.n808 0.00329
R17280 VSSD.n2327 VSSD.n1020 0.00329
R17281 VSSD.n1696 VSSD.n1605 0.00329
R17282 VSSD.n3307 VSSD.n3306 0.00329
R17283 VSSD.n3306 VSSD.n244 0.00329
R17284 VSSD.n921 VSSD.n917 0.00293
R17285 VSSD.n2635 VSSD.n929 0.00293
R17286 VSSD.n2634 VSSD.n936 0.00293
R17287 VSSD.n949 VSSD.n928 0.00293
R17288 VSSD.n2632 VSSD.n922 0.00293
R17289 VSSD.n951 VSSD.n927 0.00293
R17290 VSSD.n954 VSSD.n923 0.00293
R17291 VSSD.n952 VSSD.n926 0.00293
R17292 VSSD.n953 VSSD.n924 0.00293
R17293 VSSD.n801 VSSD.n797 0.00293
R17294 VSSD.n2752 VSSD.n809 0.00293
R17295 VSSD.n2751 VSSD.n816 0.00293
R17296 VSSD.n829 VSSD.n808 0.00293
R17297 VSSD.n2749 VSSD.n802 0.00293
R17298 VSSD.n831 VSSD.n807 0.00293
R17299 VSSD.n834 VSSD.n803 0.00293
R17300 VSSD.n832 VSSD.n806 0.00293
R17301 VSSD.n833 VSSD.n804 0.00293
R17302 VSSD.n2324 VSSD.n2323 0.00293
R17303 VSSD.n2321 VSSD.n1038 0.00293
R17304 VSSD.n2319 VSSD.n1043 0.00293
R17305 VSSD.n2318 VSSD.n1020 0.00293
R17306 VSSD.n2326 VSSD.n1026 0.00293
R17307 VSSD.n2312 VSSD.n1039 0.00293
R17308 VSSD.n2310 VSSD.n1042 0.00293
R17309 VSSD.n2311 VSSD.n1040 0.00293
R17310 VSSD.n1041 VSSD.n738 0.00293
R17311 VSSD.n1598 VSSD.n1594 0.00293
R17312 VSSD.n1700 VSSD.n1606 0.00293
R17313 VSSD.n1699 VSSD.n1613 0.00293
R17314 VSSD.n1626 VSSD.n1605 0.00293
R17315 VSSD.n1697 VSSD.n1599 0.00293
R17316 VSSD.n1628 VSSD.n1604 0.00293
R17317 VSSD.n1631 VSSD.n1600 0.00293
R17318 VSSD.n1629 VSSD.n1603 0.00293
R17319 VSSD.n1630 VSSD.n1601 0.00293
R17320 VSSD.n377 VSSD.n319 0.00261382
R17321 VSSD.n374 VSSD.n318 0.00261382
R17322 VSSD.n372 VSSD.n317 0.00261382
R17323 VSSD.n370 VSSD.n316 0.00261382
R17324 VSSD.n368 VSSD.n315 0.00261382
R17325 VSSD.n366 VSSD.n314 0.00261382
R17326 VSSD.n313 VSSD.n304 0.00261382
R17327 VSSD.n3240 VSSD.n3239 0.00261382
R17328 VSSD.n3230 VSSD.n309 0.00261382
R17329 VSSD.n2049 VSSD.n1193 0.00261382
R17330 VSSD.n2054 VSSD.n1191 0.00261382
R17331 VSSD.n2058 VSSD.n1194 0.00261382
R17332 VSSD.n2060 VSSD.n1190 0.00261382
R17333 VSSD.n2092 VSSD.n1195 0.00261382
R17334 VSSD.n2070 VSSD.n2064 0.00261382
R17335 VSSD.n2069 VSSD.n1181 0.00261382
R17336 VSSD.n2096 VSSD.n2095 0.00261382
R17337 VSSD.n1182 VSSD.n1110 0.00261382
R17338 VSSD.n2888 VSSD.n616 0.00261382
R17339 VSSD.n2893 VSSD.n614 0.00261382
R17340 VSSD.n2897 VSSD.n617 0.00261382
R17341 VSSD.n2899 VSSD.n613 0.00261382
R17342 VSSD.n2931 VSSD.n618 0.00261382
R17343 VSSD.n2909 VSSD.n2903 0.00261382
R17344 VSSD.n2908 VSSD.n604 0.00261382
R17345 VSSD.n2935 VSSD.n2934 0.00261382
R17346 VSSD.n605 VSSD.n581 0.00261382
R17347 VSSD.n3027 VSSD.n433 0.00261382
R17348 VSSD.n3032 VSSD.n431 0.00261382
R17349 VSSD.n3036 VSSD.n434 0.00261382
R17350 VSSD.n3038 VSSD.n430 0.00261382
R17351 VSSD.n3070 VSSD.n435 0.00261382
R17352 VSSD.n3048 VSSD.n3042 0.00261382
R17353 VSSD.n3047 VSSD.n421 0.00261382
R17354 VSSD.n3074 VSSD.n3073 0.00261382
R17355 VSSD.n422 VSSD.n398 0.00261382
R17356 VSSD.n1952 VSSD.n1933 0.00261382
R17357 VSSD.n1951 VSSD.n1291 0.00261382
R17358 VSSD.n1937 VSSD.n1292 0.00261382
R17359 VSSD.n1938 VSSD.n1293 0.00261382
R17360 VSSD.n1939 VSSD.n1294 0.00261382
R17361 VSSD.n1940 VSSD.n1295 0.00261382
R17362 VSSD.n1941 VSSD.n1296 0.00261382
R17363 VSSD.n1942 VSSD.n1297 0.00261382
R17364 VSSD.n1954 VSSD.n1298 0.00261382
R17365 VSSD.n3434 VSSD.n153 0.00239457
R17366 VSSD.n3421 VSSD.n144 0.00239457
R17367 VSSD.n3433 VSSD.n152 0.00239457
R17368 VSSD.n3422 VSSD.n145 0.00239457
R17369 VSSD.n3432 VSSD.n151 0.00239457
R17370 VSSD.n3423 VSSD.n146 0.00239457
R17371 VSSD.n3431 VSSD.n150 0.00239457
R17372 VSSD.n3424 VSSD.n147 0.00239457
R17373 VSSD.n3430 VSSD.n149 0.00239457
R17374 VSSD.n3425 VSSD.n3398 0.00239457
R17375 VSSD.n3487 VSSD.n3386 0.00239457
R17376 VSSD.n3490 VSSD.n3372 0.00239457
R17377 VSSD.n3491 VSSD.n3371 0.00239457
R17378 VSSD.n3370 VSSD.n168 0.00239457
R17379 VSSD.n220 VSSD.n181 0.00239457
R17380 VSSD.n3319 VSSD.n181 0.00239457
R17381 VSSD.n221 VSSD.n182 0.00239457
R17382 VSSD.n3320 VSSD.n182 0.00239457
R17383 VSSD.n222 VSSD.n183 0.00239457
R17384 VSSD.n3321 VSSD.n183 0.00239457
R17385 VSSD.n223 VSSD.n184 0.00239457
R17386 VSSD.n3322 VSSD.n184 0.00239457
R17387 VSSD.n224 VSSD.n186 0.00239457
R17388 VSSD.n3323 VSSD.n186 0.00239457
R17389 VSSD.n225 VSSD.n198 0.00239457
R17390 VSSD.n219 VSSD.n218 0.00239457
R17391 VSSD.n218 VSSD.n198 0.00239457
R17392 VSSD.n3323 VSSD.n212 0.00239457
R17393 VSSD.n225 VSSD.n212 0.00239457
R17394 VSSD.n3322 VSSD.n213 0.00239457
R17395 VSSD.n224 VSSD.n213 0.00239457
R17396 VSSD.n3321 VSSD.n214 0.00239457
R17397 VSSD.n223 VSSD.n214 0.00239457
R17398 VSSD.n3320 VSSD.n215 0.00239457
R17399 VSSD.n222 VSSD.n215 0.00239457
R17400 VSSD.n3319 VSSD.n216 0.00239457
R17401 VSSD.n221 VSSD.n216 0.00239457
R17402 VSSD.n217 VSSD.n168 0.00239457
R17403 VSSD.n220 VSSD.n217 0.00239457
R17404 VSSD.n3491 VSSD.n3490 0.00239457
R17405 VSSD.n3487 VSSD.n3372 0.00239457
R17406 VSSD.n3398 VSSD.n3386 0.00239457
R17407 VSSD.n3425 VSSD.n149 0.00239457
R17408 VSSD.n3430 VSSD.n147 0.00239457
R17409 VSSD.n3424 VSSD.n150 0.00239457
R17410 VSSD.n3431 VSSD.n146 0.00239457
R17411 VSSD.n3423 VSSD.n151 0.00239457
R17412 VSSD.n3432 VSSD.n145 0.00239457
R17413 VSSD.n3422 VSSD.n152 0.00239457
R17414 VSSD.n3433 VSSD.n144 0.00239457
R17415 VSSD.n3421 VSSD.n153 0.00239457
R17416 VSSD.n3434 VSSD.n143 0.00239457
R17417 VSSD.n1459 VSSD.n1446 0.00239457
R17418 VSSD.n1475 VSSD.n1431 0.00239457
R17419 VSSD.n1461 VSSD.n1460 0.00239457
R17420 VSSD.n1474 VSSD.n1430 0.00239457
R17421 VSSD.n1463 VSSD.n1462 0.00239457
R17422 VSSD.n1473 VSSD.n1429 0.00239457
R17423 VSSD.n1465 VSSD.n1464 0.00239457
R17424 VSSD.n1472 VSSD.n1428 0.00239457
R17425 VSSD.n1467 VSSD.n1466 0.00239457
R17426 VSSD.n1471 VSSD.n1427 0.00239457
R17427 VSSD.n1911 VSSD.n1468 0.00239457
R17428 VSSD.n1910 VSSD.n1426 0.00239457
R17429 VSSD.n1913 VSSD.n1399 0.00239457
R17430 VSSD.n1926 VSSD.n1340 0.00239457
R17431 VSSD.n1380 VSSD.n1372 0.00239457
R17432 VSSD.n1393 VSSD.n1341 0.00239457
R17433 VSSD.n1378 VSSD.n1338 0.00239457
R17434 VSSD.n1394 VSSD.n1342 0.00239457
R17435 VSSD.n1377 VSSD.n1337 0.00239457
R17436 VSSD.n1395 VSSD.n1343 0.00239457
R17437 VSSD.n1376 VSSD.n1336 0.00239457
R17438 VSSD.n1396 VSSD.n1344 0.00239457
R17439 VSSD.n1375 VSSD.n1335 0.00239457
R17440 VSSD.n1397 VSSD.n1345 0.00239457
R17441 VSSD.n1374 VSSD.n1334 0.00239457
R17442 VSSD.n1931 VSSD.n1346 0.00239457
R17443 VSSD.n1446 VSSD.n1444 0.00239457
R17444 VSSD.n1475 VSSD.n1459 0.00239457
R17445 VSSD.n1460 VSSD.n1431 0.00239457
R17446 VSSD.n1474 VSSD.n1461 0.00239457
R17447 VSSD.n1462 VSSD.n1430 0.00239457
R17448 VSSD.n1473 VSSD.n1463 0.00239457
R17449 VSSD.n1464 VSSD.n1429 0.00239457
R17450 VSSD.n1472 VSSD.n1465 0.00239457
R17451 VSSD.n1466 VSSD.n1428 0.00239457
R17452 VSSD.n1471 VSSD.n1467 0.00239457
R17453 VSSD.n1468 VSSD.n1427 0.00239457
R17454 VSSD.n1911 VSSD.n1910 0.00239457
R17455 VSSD.n1426 VSSD.n1399 0.00239457
R17456 VSSD.n1929 VSSD.n1340 0.00239457
R17457 VSSD.n1929 VSSD.n1380 0.00239457
R17458 VSSD.n1393 VSSD.n1372 0.00239457
R17459 VSSD.n1378 VSSD.n1341 0.00239457
R17460 VSSD.n1394 VSSD.n1338 0.00239457
R17461 VSSD.n1377 VSSD.n1342 0.00239457
R17462 VSSD.n1395 VSSD.n1337 0.00239457
R17463 VSSD.n1376 VSSD.n1343 0.00239457
R17464 VSSD.n1396 VSSD.n1336 0.00239457
R17465 VSSD.n1375 VSSD.n1344 0.00239457
R17466 VSSD.n1397 VSSD.n1335 0.00239457
R17467 VSSD.n1374 VSSD.n1345 0.00239457
R17468 VSSD.n1346 VSSD.n1334 0.00239457
R17469 VSSD.n3142 VSSD.n3141 0.00239
R17470 VSSD.n3129 VSSD.n364 0.00239
R17471 VSSD.n3139 VSSD.n383 0.00239
R17472 VSSD.n3138 VSSD.n3137 0.00239
R17473 VSSD.n382 VSSD.n358 0.00239
R17474 VSSD.n3144 VSSD.n360 0.00239
R17475 VSSD.n3132 VSSD.n381 0.00239
R17476 VSSD.n3130 VSSD.n365 0.00239
R17477 VSSD.n3131 VSSD.n380 0.00239
R17478 VSSD.n2043 VSSD.n1108 0.00239
R17479 VSSD.n1213 VSSD.n1206 0.00239
R17480 VSSD.n2046 VSSD.n2045 0.00239
R17481 VSSD.n1233 VSSD.n1220 0.00239
R17482 VSSD.n2042 VSSD.n1212 0.00239
R17483 VSSD.n1235 VSSD.n1207 0.00239
R17484 VSSD.n1237 VSSD.n1211 0.00239
R17485 VSSD.n1236 VSSD.n1208 0.00239
R17486 VSSD.n1210 VSSD.n1201 0.00239
R17487 VSSD.n2885 VSSD.n2884 0.00239
R17488 VSSD.n653 VSSD.n629 0.00239
R17489 VSSD.n2882 VSSD.n636 0.00239
R17490 VSSD.n2881 VSSD.n2880 0.00239
R17491 VSSD.n2875 VSSD.n635 0.00239
R17492 VSSD.n654 VSSD.n630 0.00239
R17493 VSSD.n656 VSSD.n634 0.00239
R17494 VSSD.n655 VSSD.n631 0.00239
R17495 VSSD.n633 VSSD.n624 0.00239
R17496 VSSD.n3024 VSSD.n3023 0.00239
R17497 VSSD.n470 VSSD.n446 0.00239
R17498 VSSD.n3021 VSSD.n453 0.00239
R17499 VSSD.n3020 VSSD.n3019 0.00239
R17500 VSSD.n3014 VSSD.n452 0.00239
R17501 VSSD.n471 VSSD.n447 0.00239
R17502 VSSD.n473 VSSD.n451 0.00239
R17503 VSSD.n472 VSSD.n448 0.00239
R17504 VSSD.n450 VSSD.n441 0.00239
R17505 VSSD.n1883 VSSD.n1498 0.00230401
R17506 VSSD.n3557 VSSD.n83 0.00230401
R17507 VSSD.n974 VSSD.n958 0.00230401
R17508 VSSD.n348 VSSD.n347 0.00230401
R17509 VSSD.n2031 VSSD.n1246 0.00230401
R17510 VSSD.n2864 VSSD.n665 0.00230401
R17511 VSSD.n3003 VSSD.n482 0.00230401
R17512 VSSD.n2727 VSSD.n838 0.00230401
R17513 VSSD.n1014 VSSD.n1013 0.00230401
R17514 VSSD.n1675 VSSD.n1635 0.00230401
R17515 VSSD.n3296 VSSD.n258 0.00230401
R17516 VSSD.n2460 VSSD.n908 0.00212602
R17517 VSSD.n2457 VSSD.n907 0.00212602
R17518 VSSD.n2455 VSSD.n906 0.00212602
R17519 VSSD.n2453 VSSD.n905 0.00212602
R17520 VSSD.n2451 VSSD.n904 0.00212602
R17521 VSSD.n2449 VSSD.n903 0.00212602
R17522 VSSD.n902 VSSD.n893 0.00212602
R17523 VSSD.n2683 VSSD.n2682 0.00212602
R17524 VSSD.n2673 VSSD.n898 0.00212602
R17525 VSSD.n2595 VSSD.n58 0.00212602
R17526 VSSD.n2592 VSSD.n57 0.00212602
R17527 VSSD.n2590 VSSD.n56 0.00212602
R17528 VSSD.n2588 VSSD.n55 0.00212602
R17529 VSSD.n2586 VSSD.n54 0.00212602
R17530 VSSD.n2584 VSSD.n53 0.00212602
R17531 VSSD.n52 VSSD.n43 0.00212602
R17532 VSSD.n3631 VSSD.n3630 0.00212602
R17533 VSSD.n3621 VSSD.n48 0.00212602
R17534 VSSD.n2816 VSSD.n761 0.00212602
R17535 VSSD.n2771 VSSD.n2770 0.00212602
R17536 VSSD.n2777 VSSD.n2773 0.00212602
R17537 VSSD.n2776 VSSD.n2769 0.00212602
R17538 VSSD.n2779 VSSD.n2778 0.00212602
R17539 VSSD.n2768 VSSD.n787 0.00212602
R17540 VSSD.n2801 VSSD.n788 0.00212602
R17541 VSSD.n790 VSSD.n789 0.00212602
R17542 VSSD.n2804 VSSD.n2803 0.00212602
R17543 VSSD.n2253 VSSD.n1079 0.00212602
R17544 VSSD.n2258 VSSD.n1077 0.00212602
R17545 VSSD.n2262 VSSD.n1080 0.00212602
R17546 VSSD.n2264 VSSD.n1076 0.00212602
R17547 VSSD.n2296 VSSD.n1081 0.00212602
R17548 VSSD.n2274 VSSD.n2268 0.00212602
R17549 VSSD.n2273 VSSD.n1067 0.00212602
R17550 VSSD.n2300 VSSD.n2299 0.00212602
R17551 VSSD.n1068 VSSD.n1044 0.00212602
R17552 VSSD.n1836 VSSD.n1818 0.00212602
R17553 VSSD.n1835 VSSD.n1824 0.00212602
R17554 VSSD.n1832 VSSD.n1721 0.00212602
R17555 VSSD.n1830 VSSD.n1570 0.00212602
R17556 VSSD.n1828 VSSD.n1720 0.00212602
R17557 VSSD.n1826 VSSD.n1572 0.00212602
R17558 VSSD.n1571 VSSD.n1553 0.00212602
R17559 VSSD.n1839 VSSD.n1838 0.00212602
R17560 VSSD.n1719 VSSD.n1559 0.00212602
R17561 VSSD.n3145 VSSD.n358 0.0014
R17562 VSSD.n2042 VSSD.n2041 0.0014
R17563 VSSD.n2875 VSSD.n2874 0.0014
R17564 VSSD.n3014 VSSD.n3013 0.0014
R17565 VSSD.n2632 VSSD.n2631 0.00086
R17566 VSSD.n2749 VSSD.n2748 0.00086
R17567 VSSD.n2327 VSSD.n2326 0.00086
R17568 VSSD.n1697 VSSD.n1696 0.00086
R17569 Set.n4 Set.t57 75.0252
R17570 Set.n0 Set.t73 75.0252
R17571 Set.n13 Set.t80 75.0252
R17572 Set.n9 Set.t65 75.0252
R17573 Set.n23 Set.t7 75.0252
R17574 Set.n19 Set.t23 75.0252
R17575 Set.n33 Set.t9 75.0252
R17576 Set.n29 Set.t11 75.0252
R17577 Set.n43 Set.t18 75.0252
R17578 Set.n39 Set.t50 75.0252
R17579 Set.n53 Set.t27 75.0252
R17580 Set.n49 Set.t55 75.0252
R17581 Set.n63 Set.t44 75.0252
R17582 Set.n59 Set.t38 75.0252
R17583 Set.n73 Set.t60 75.0252
R17584 Set.n69 Set.t40 75.0252
R17585 Set.n83 Set.t41 75.0252
R17586 Set.n79 Set.t36 75.0252
R17587 Set.n93 Set.t87 75.0252
R17588 Set.n89 Set.t6 75.0252
R17589 Set.n103 Set.t75 75.0252
R17590 Set.n99 Set.t70 75.0252
R17591 Set.n6 Set.t10 74.8588
R17592 Set.n2 Set.t85 74.8588
R17593 Set.n15 Set.t76 74.8588
R17594 Set.n11 Set.t32 74.8588
R17595 Set.n25 Set.t22 74.8588
R17596 Set.n21 Set.t12 74.8588
R17597 Set.n35 Set.t56 74.8588
R17598 Set.n31 Set.t86 74.8588
R17599 Set.n45 Set.t49 74.8588
R17600 Set.n41 Set.t20 74.8588
R17601 Set.n55 Set.t21 74.8588
R17602 Set.n51 Set.t42 74.8588
R17603 Set.n65 Set.t37 74.8588
R17604 Set.n61 Set.t47 74.8588
R17605 Set.n75 Set.t29 74.8588
R17606 Set.n71 Set.t31 74.8588
R17607 Set.n85 Set.t35 74.8588
R17608 Set.n81 Set.t46 74.8588
R17609 Set.n95 Set.t48 74.8588
R17610 Set.n91 Set.t83 74.8588
R17611 Set.n105 Set.t69 74.8588
R17612 Set.n101 Set.t79 74.8588
R17613 Set.n6 Set.t17 44.2362
R17614 Set.n2 Set.t14 44.2362
R17615 Set.n15 Set.t82 44.2362
R17616 Set.n11 Set.t53 44.2362
R17617 Set.n25 Set.t43 44.2362
R17618 Set.n21 Set.t30 44.2362
R17619 Set.n35 Set.t51 44.2362
R17620 Set.n31 Set.t16 44.2362
R17621 Set.n45 Set.t77 44.2362
R17622 Set.n41 Set.t39 44.2362
R17623 Set.n55 Set.t19 44.2362
R17624 Set.n51 Set.t67 44.2362
R17625 Set.n65 Set.t61 44.2362
R17626 Set.n61 Set.t72 44.2362
R17627 Set.n75 Set.t15 44.2362
R17628 Set.n71 Set.t52 44.2362
R17629 Set.n85 Set.t58 44.2362
R17630 Set.n81 Set.t71 44.2362
R17631 Set.n95 Set.t84 44.2362
R17632 Set.n91 Set.t13 44.2362
R17633 Set.n105 Set.t1 44.2362
R17634 Set.n101 Set.t8 44.2362
R17635 Set.n4 Set.t63 44.0697
R17636 Set.n0 Set.t3 44.0697
R17637 Set.n13 Set.t26 44.0697
R17638 Set.n9 Set.t0 44.0697
R17639 Set.n23 Set.t25 44.0697
R17640 Set.n19 Set.t45 44.0697
R17641 Set.n33 Set.t5 44.0697
R17642 Set.n29 Set.t28 44.0697
R17643 Set.n43 Set.t34 44.0697
R17644 Set.n39 Set.t78 44.0697
R17645 Set.n53 Set.t74 44.0697
R17646 Set.n49 Set.t81 44.0697
R17647 Set.n63 Set.t68 44.0697
R17648 Set.n59 Set.t62 44.0697
R17649 Set.n73 Set.t54 44.0697
R17650 Set.n69 Set.t64 44.0697
R17651 Set.n83 Set.t66 44.0697
R17652 Set.n79 Set.t59 44.0697
R17653 Set.n93 Set.t33 44.0697
R17654 Set.n89 Set.t24 44.0697
R17655 Set.n103 Set.t4 44.0697
R17656 Set.n99 Set.t2 44.0697
R17657 Set.n18 Set.n8 21.3909
R17658 Set.n28 Set.n27 17.0049
R17659 Set.n48 Set.n47 17.0049
R17660 Set.n68 Set.n67 17.0049
R17661 Set.n88 Set.n87 17.0049
R17662 Set.n108 Set.n107 17.0049
R17663 Set.n18 Set.n17 16.5909
R17664 Set.n38 Set.n37 16.5909
R17665 Set.n58 Set.n57 16.5909
R17666 Set.n78 Set.n77 16.5909
R17667 Set.n98 Set.n97 16.5909
R17668 Set.n3 Set.n1 10.0037
R17669 Set.n12 Set.n10 10.0037
R17670 Set.n22 Set.n20 10.0037
R17671 Set.n32 Set.n30 10.0037
R17672 Set.n42 Set.n40 10.0037
R17673 Set.n52 Set.n50 10.0037
R17674 Set.n62 Set.n60 10.0037
R17675 Set.n72 Set.n70 10.0037
R17676 Set.n82 Set.n80 10.0037
R17677 Set.n92 Set.n90 10.0037
R17678 Set.n102 Set.n100 10.0037
R17679 Set.n5 Set.n4 8.78002
R17680 Set.n14 Set.n13 8.78002
R17681 Set.n20 Set.n19 8.78002
R17682 Set.n34 Set.n33 8.78002
R17683 Set.n40 Set.n39 8.78002
R17684 Set.n54 Set.n53 8.78002
R17685 Set.n60 Set.n59 8.78002
R17686 Set.n74 Set.n73 8.78002
R17687 Set.n80 Set.n79 8.78002
R17688 Set.n94 Set.n93 8.78002
R17689 Set.n100 Set.n99 8.78002
R17690 Set.n1 Set.n0 8.77902
R17691 Set.n10 Set.n9 8.77902
R17692 Set.n24 Set.n23 8.77902
R17693 Set.n30 Set.n29 8.77902
R17694 Set.n44 Set.n43 8.77902
R17695 Set.n50 Set.n49 8.77902
R17696 Set.n64 Set.n63 8.77902
R17697 Set.n70 Set.n69 8.77902
R17698 Set.n84 Set.n83 8.77902
R17699 Set.n90 Set.n89 8.77902
R17700 Set.n104 Set.n103 8.77902
R17701 Set.n7 Set.n6 8.00283
R17702 Set.n16 Set.n15 8.00283
R17703 Set.n36 Set.n35 8.00283
R17704 Set.n56 Set.n55 8.00283
R17705 Set.n76 Set.n75 8.00283
R17706 Set.n96 Set.n95 8.00283
R17707 Set.n26 Set.n25 8.00183
R17708 Set.n46 Set.n45 8.00183
R17709 Set.n66 Set.n65 8.00183
R17710 Set.n86 Set.n85 8.00183
R17711 Set.n106 Set.n105 8.00183
R17712 Set.n8 Set.n1 7.55155
R17713 Set.n17 Set.n10 7.55155
R17714 Set.n27 Set.n20 7.55155
R17715 Set.n37 Set.n30 7.55155
R17716 Set.n47 Set.n40 7.55155
R17717 Set.n57 Set.n50 7.55155
R17718 Set.n67 Set.n60 7.55155
R17719 Set.n77 Set.n70 7.55155
R17720 Set.n87 Set.n80 7.55155
R17721 Set.n97 Set.n90 7.55155
R17722 Set.n107 Set.n100 7.55155
R17723 Set.n8 Set.n7 7.40405
R17724 Set.n17 Set.n16 7.40405
R17725 Set.n27 Set.n26 7.40405
R17726 Set.n37 Set.n36 7.40405
R17727 Set.n47 Set.n46 7.40405
R17728 Set.n57 Set.n56 7.40405
R17729 Set.n67 Set.n66 7.40405
R17730 Set.n77 Set.n76 7.40405
R17731 Set.n87 Set.n86 7.40405
R17732 Set.n97 Set.n96 7.40405
R17733 Set.n107 Set.n106 7.40405
R17734 Set.n7 Set.n5 6.8315
R17735 Set.n16 Set.n14 6.8315
R17736 Set.n26 Set.n24 6.8315
R17737 Set.n36 Set.n34 6.8315
R17738 Set.n46 Set.n44 6.8315
R17739 Set.n56 Set.n54 6.8315
R17740 Set.n66 Set.n64 6.8315
R17741 Set.n76 Set.n74 6.8315
R17742 Set.n86 Set.n84 6.8315
R17743 Set.n96 Set.n94 6.8315
R17744 Set.n106 Set.n104 6.8315
R17745 Set.n5 Set.n3 4.96861
R17746 Set.n14 Set.n12 4.96861
R17747 Set.n24 Set.n22 4.96861
R17748 Set.n34 Set.n32 4.96861
R17749 Set.n44 Set.n42 4.96861
R17750 Set.n54 Set.n52 4.96861
R17751 Set.n64 Set.n62 4.96861
R17752 Set.n74 Set.n72 4.96861
R17753 Set.n84 Set.n82 4.96861
R17754 Set.n94 Set.n92 4.96861
R17755 Set.n104 Set.n102 4.96861
R17756 Set.n22 Set.n21 4.8264
R17757 Set.n42 Set.n41 4.8264
R17758 Set.n62 Set.n61 4.8264
R17759 Set.n82 Set.n81 4.8264
R17760 Set.n102 Set.n101 4.8264
R17761 Set.n3 Set.n2 4.8254
R17762 Set.n12 Set.n11 4.8254
R17763 Set.n32 Set.n31 4.8254
R17764 Set.n52 Set.n51 4.8254
R17765 Set.n72 Set.n71 4.8254
R17766 Set.n92 Set.n91 4.8254
R17767 Set.n108 Set.n98 4.2557
R17768 Set.n88 Set.n78 4.2557
R17769 Set.n68 Set.n58 4.2557
R17770 Set.n48 Set.n38 4.2557
R17771 Set.n28 Set.n18 4.2557
R17772 Set Set.n108 3.63287
R17773 Set.n98 Set.n88 0.5453
R17774 Set.n78 Set.n68 0.5453
R17775 Set.n58 Set.n48 0.5453
R17776 Set.n38 Set.n28 0.5453
R17777 a_4790_n4422.n2 a_4790_n4422.t1 11.0089
R17778 a_4790_n4422.n2 a_4790_n4422.n1 7.28488
R17779 a_4790_n4422.n1 a_4790_n4422.n0 5.39574
R17780 a_4790_n4422.n1 a_4790_n4422.t4 4.91281
R17781 a_4790_n4422.t2 a_4790_n4422.n2 4.12554
R17782 a_4790_n4422.n0 a_4790_n4422.t3 3.7821
R17783 a_4790_n4422.n0 a_4790_n4422.t0 3.77824
R17784 a_105342_n4422.n0 a_105342_n4422.t6 74.8588
R17785 a_105342_n4422.n0 a_105342_n4422.t5 44.2362
R17786 a_105342_n4422.n3 a_105342_n4422.n0 14.5242
R17787 a_105342_n4422.n3 a_105342_n4422.t1 11.0089
R17788 a_105342_n4422.n2 a_105342_n4422.n1 5.39574
R17789 a_105342_n4422.n2 a_105342_n4422.t3 4.91281
R17790 a_105342_n4422.t0 a_105342_n4422.n3 4.12554
R17791 a_105342_n4422.n1 a_105342_n4422.t2 3.7821
R17792 a_105342_n4422.n1 a_105342_n4422.t4 3.77824
R17793 a_105342_n4422.n0 a_105342_n4422.n2 1.83141
R17794 a_106818_n4422.n2 a_106818_n4422.t2 11.0083
R17795 a_106818_n4422.n2 a_106818_n4422.n1 7.51324
R17796 a_106818_n4422.n1 a_106818_n4422.n0 5.39574
R17797 a_106818_n4422.n1 a_106818_n4422.t4 4.91281
R17798 a_106818_n4422.t0 a_106818_n4422.n2 4.12501
R17799 a_106818_n4422.n0 a_106818_n4422.t3 3.7821
R17800 a_106818_n4422.n0 a_106818_n4422.t1 3.77824
R17801 a_4722_n3300.n0 a_4722_n3300.t5 86.4194
R17802 a_4722_n3300.n2 a_4722_n3300.t4 82.415
R17803 a_4722_n3300.n1 a_4722_n3300.t2 51.8534
R17804 a_4722_n3300.n0 a_4722_n3300.t3 51.8062
R17805 a_4722_n3300.n3 a_4722_n3300.t0 6.28457
R17806 a_4722_n3300.n2 a_4722_n3300.n1 4.1171
R17807 a_4722_n3300.n3 a_4722_n3300.n2 2.66254
R17808 a_4722_n3300.t1 a_4722_n3300.n3 2.21138
R17809 a_4722_n3300.n1 a_4722_n3300.n0 1.3775
R17810 a_10632_n3162.n1 a_10632_n3162.t4 75.0252
R17811 a_10632_n3162.n1 a_10632_n3162.t5 44.0697
R17812 a_10632_n3162.n2 a_10632_n3162.t0 10.6055
R17813 a_10632_n3162.n0 a_10632_n3162.t3 10.6055
R17814 a_10632_n3162.n0 a_10632_n3162.n2 8.89791
R17815 a_10632_n3162.n0 a_10632_n3162.n1 5.7951
R17816 a_10632_n3162.t1 a_10632_n3162.n0 4.53176
R17817 a_10632_n3162.n2 a_10632_n3162.t2 4.53041
R17818 a_10818_n4422.n1 a_10818_n4422.t1 11.0083
R17819 a_10818_n4422.n2 a_10818_n4422.n1 7.51324
R17820 a_10818_n4422.n2 a_10818_n4422.n0 5.39574
R17821 a_10818_n4422.t2 a_10818_n4422.n2 4.91281
R17822 a_10818_n4422.n1 a_10818_n4422.t4 4.12408
R17823 a_10818_n4422.n0 a_10818_n4422.t0 3.7821
R17824 a_10818_n4422.n0 a_10818_n4422.t3 3.77824
R17825 a_78134_n18422.n1 a_78134_n18422.t5 75.0252
R17826 a_78134_n18422.n1 a_78134_n18422.t4 44.0697
R17827 a_78134_n18422.n3 a_78134_n18422.t3 11.0112
R17828 a_78134_n18422.n0 a_78134_n18422.t0 10.6055
R17829 a_78134_n18422.n2 a_78134_n18422.n0 9.81776
R17830 a_78134_n18422.n2 a_78134_n18422.n1 5.81441
R17831 a_78134_n18422.n3 a_78134_n18422.n2 4.64798
R17832 a_78134_n18422.n0 a_78134_n18422.t2 4.53024
R17833 a_78134_n18422.t1 a_78134_n18422.n3 4.12554
R17834 SAR_Asynchronous_Logic_7/D_reset_FF_0.Q.n2 SAR_Asynchronous_Logic_7/D_reset_FF_0.Q.t5 74.8588
R17835 SAR_Asynchronous_Logic_7/D_reset_FF_0.Q.n3 SAR_Asynchronous_Logic_7/D_reset_FF_0.Q.t4 70.3153
R17836 SAR_Asynchronous_Logic_7/D_reset_FF_0.Q.n2 SAR_Asynchronous_Logic_7/D_reset_FF_0.Q.t6 44.2362
R17837 SAR_Asynchronous_Logic_7/D_reset_FF_0.Q.n3 SAR_Asynchronous_Logic_7/D_reset_FF_0.Q.t3 39.854
R17838 SAR_Asynchronous_Logic_7/D_reset_FF_0.Q.n4 SAR_Asynchronous_Logic_7/D_reset_FF_0.Q.n0 11.62
R17839 SAR_Asynchronous_Logic_7/D_reset_FF_0.Q.n0 SAR_Asynchronous_Logic_7/D_reset_FF_0.Q.n1 5.39574
R17840 SAR_Asynchronous_Logic_7/D_reset_FF_0.Q.n0 SAR_Asynchronous_Logic_7/D_reset_FF_0.Q.t1 4.91248
R17841 SAR_Asynchronous_Logic_7/D_reset_FF_0.Q.n1 SAR_Asynchronous_Logic_7/D_reset_FF_0.Q.t0 3.7821
R17842 SAR_Asynchronous_Logic_7/D_reset_FF_0.Q.n1 SAR_Asynchronous_Logic_7/D_reset_FF_0.Q.t2 3.77824
R17843 SAR_Asynchronous_Logic_7/D_reset_FF_0.Q.n0 SAR_Asynchronous_Logic_7/D_reset_FF_0.Q.n2 3.04286
R17844 SAR_Asynchronous_Logic_7/D_reset_FF_0.Q SAR_Asynchronous_Logic_7/D_reset_FF_0.Q.n4 2.86313
R17845 SAR_Asynchronous_Logic_7/D_reset_FF_0.Q.n4 SAR_Asynchronous_Logic_7/D_reset_FF_0.Q.n3 2.84345
R17846 Reset.n4 Reset.t48 75.0252
R17847 Reset.n0 Reset.t27 75.0252
R17848 Reset.n11 Reset.t42 75.0252
R17849 Reset.n7 Reset.t4 75.0252
R17850 Reset.n27 Reset.t65 75.0252
R17851 Reset.n23 Reset.t60 75.0252
R17852 Reset.n43 Reset.t81 75.0252
R17853 Reset.n39 Reset.t19 75.0252
R17854 Reset.n19 Reset.t85 75.0252
R17855 Reset.n15 Reset.t28 75.0252
R17856 Reset.n59 Reset.t86 75.0252
R17857 Reset.n55 Reset.t58 75.0252
R17858 Reset.n35 Reset.t22 75.0252
R17859 Reset.n31 Reset.t59 75.0252
R17860 Reset.n75 Reset.t21 75.0252
R17861 Reset.n71 Reset.t57 75.0252
R17862 Reset.n51 Reset.t51 75.0252
R17863 Reset.n47 Reset.t82 75.0252
R17864 Reset.n67 Reset.t8 75.0252
R17865 Reset.n63 Reset.t80 75.0252
R17866 Reset.n83 Reset.t38 75.0252
R17867 Reset.n79 Reset.t20 75.0252
R17868 Reset.n3 Reset.t39 74.8588
R17869 Reset.n1 Reset.t40 74.8588
R17870 Reset.n10 Reset.t12 74.8588
R17871 Reset.n8 Reset.t16 74.8588
R17872 Reset.n26 Reset.t33 74.8588
R17873 Reset.n24 Reset.t84 74.8588
R17874 Reset.n42 Reset.t62 74.8588
R17875 Reset.n40 Reset.t49 74.8588
R17876 Reset.n18 Reset.t71 74.8588
R17877 Reset.n16 Reset.t79 74.8588
R17878 Reset.n58 Reset.t66 74.8588
R17879 Reset.n56 Reset.t83 74.8588
R17880 Reset.n34 Reset.t2 74.8588
R17881 Reset.n32 Reset.t15 74.8588
R17882 Reset.n74 Reset.t23 74.8588
R17883 Reset.n72 Reset.t47 74.8588
R17884 Reset.n50 Reset.t30 74.8588
R17885 Reset.n48 Reset.t43 74.8588
R17886 Reset.n66 Reset.t29 74.8588
R17887 Reset.n64 Reset.t3 74.8588
R17888 Reset.n82 Reset.t61 74.8588
R17889 Reset.n80 Reset.t31 74.8588
R17890 Reset.n3 Reset.t5 44.2362
R17891 Reset.n1 Reset.t64 44.2362
R17892 Reset.n10 Reset.t1 44.2362
R17893 Reset.n8 Reset.t36 44.2362
R17894 Reset.n26 Reset.t73 44.2362
R17895 Reset.n24 Reset.t17 44.2362
R17896 Reset.n42 Reset.t50 44.2362
R17897 Reset.n40 Reset.t70 44.2362
R17898 Reset.n18 Reset.t87 44.2362
R17899 Reset.n16 Reset.t6 44.2362
R17900 Reset.n58 Reset.t45 44.2362
R17901 Reset.n56 Reset.t14 44.2362
R17902 Reset.n34 Reset.t24 44.2362
R17903 Reset.n32 Reset.t34 44.2362
R17904 Reset.n74 Reset.t7 44.2362
R17905 Reset.n72 Reset.t69 44.2362
R17906 Reset.n50 Reset.t55 44.2362
R17907 Reset.n48 Reset.t67 44.2362
R17908 Reset.n66 Reset.t54 44.2362
R17909 Reset.n64 Reset.t25 44.2362
R17910 Reset.n82 Reset.t78 44.2362
R17911 Reset.n80 Reset.t56 44.2362
R17912 Reset.n4 Reset.t0 44.0697
R17913 Reset.n0 Reset.t52 44.0697
R17914 Reset.n11 Reset.t10 44.0697
R17915 Reset.n7 Reset.t26 44.0697
R17916 Reset.n27 Reset.t68 44.0697
R17917 Reset.n23 Reset.t77 44.0697
R17918 Reset.n43 Reset.t44 44.0697
R17919 Reset.n39 Reset.t37 44.0697
R17920 Reset.n19 Reset.t18 44.0697
R17921 Reset.n15 Reset.t53 44.0697
R17922 Reset.n59 Reset.t35 44.0697
R17923 Reset.n55 Reset.t75 44.0697
R17924 Reset.n35 Reset.t46 44.0697
R17925 Reset.n31 Reset.t76 44.0697
R17926 Reset.n75 Reset.t13 44.0697
R17927 Reset.n71 Reset.t74 44.0697
R17928 Reset.n51 Reset.t72 44.0697
R17929 Reset.n47 Reset.t11 44.0697
R17930 Reset.n67 Reset.t32 44.0697
R17931 Reset.n63 Reset.t9 44.0697
R17932 Reset.n83 Reset.t63 44.0697
R17933 Reset.n79 Reset.t41 44.0697
R17934 Reset.n6 Reset.n5 16.4874
R17935 Reset.n13 Reset.n12 16.4874
R17936 Reset.n29 Reset.n28 16.4874
R17937 Reset.n45 Reset.n44 16.4874
R17938 Reset.n21 Reset.n20 16.4874
R17939 Reset.n61 Reset.n60 16.4874
R17940 Reset.n37 Reset.n36 16.4874
R17941 Reset.n77 Reset.n76 16.4874
R17942 Reset.n53 Reset.n52 16.4874
R17943 Reset.n69 Reset.n68 16.4874
R17944 Reset.n85 Reset.n84 16.4874
R17945 Reset.n2 Reset.n0 15.431
R17946 Reset.n9 Reset.n7 15.431
R17947 Reset.n25 Reset.n23 15.431
R17948 Reset.n41 Reset.n39 15.431
R17949 Reset.n57 Reset.n55 15.431
R17950 Reset.n14 Reset.n6 13.0791
R17951 Reset.n17 Reset.n15 13.0646
R17952 Reset.n33 Reset.n31 13.0646
R17953 Reset.n49 Reset.n47 13.0646
R17954 Reset.n65 Reset.n63 13.0646
R17955 Reset.n81 Reset.n79 13.0646
R17956 Reset.n73 Reset.n71 13.0636
R17957 Reset.n5 Reset.n3 12.2256
R17958 Reset.n12 Reset.n10 12.2256
R17959 Reset.n28 Reset.n26 12.2256
R17960 Reset.n44 Reset.n42 12.2256
R17961 Reset.n60 Reset.n58 12.2256
R17962 Reset.n76 Reset.n74 12.2256
R17963 Reset.n20 Reset.n18 12.2246
R17964 Reset.n36 Reset.n34 12.2246
R17965 Reset.n52 Reset.n50 12.2246
R17966 Reset.n68 Reset.n66 12.2246
R17967 Reset.n84 Reset.n82 12.2246
R17968 Reset.n22 Reset.n21 9.86795
R17969 Reset.n38 Reset.n37 9.86795
R17970 Reset.n54 Reset.n53 9.86795
R17971 Reset.n70 Reset.n69 9.86795
R17972 Reset.n86 Reset.n85 9.86795
R17973 Reset.n5 Reset.n4 9.00265
R17974 Reset.n12 Reset.n11 9.00265
R17975 Reset.n28 Reset.n27 9.00265
R17976 Reset.n44 Reset.n43 9.00265
R17977 Reset.n60 Reset.n59 9.00265
R17978 Reset.n76 Reset.n75 9.00265
R17979 Reset.n20 Reset.n19 9.00165
R17980 Reset.n36 Reset.n35 9.00165
R17981 Reset.n52 Reset.n51 9.00165
R17982 Reset.n68 Reset.n67 9.00165
R17983 Reset.n84 Reset.n83 9.00165
R17984 Reset.n14 Reset.n13 8.27992
R17985 Reset.n30 Reset.n29 8.27992
R17986 Reset.n46 Reset.n45 8.27992
R17987 Reset.n62 Reset.n61 8.27992
R17988 Reset.n78 Reset.n77 8.27969
R17989 Reset.n17 Reset.n16 8.11081
R17990 Reset.n33 Reset.n32 8.11081
R17991 Reset.n49 Reset.n48 8.11081
R17992 Reset.n65 Reset.n64 8.11081
R17993 Reset.n81 Reset.n80 8.11081
R17994 Reset.n2 Reset.n1 8.10981
R17995 Reset.n9 Reset.n8 8.10981
R17996 Reset.n25 Reset.n24 8.10981
R17997 Reset.n41 Reset.n40 8.10981
R17998 Reset.n57 Reset.n56 8.10981
R17999 Reset.n73 Reset.n72 8.10981
R18000 Reset.n6 Reset.n2 7.43522
R18001 Reset.n13 Reset.n9 7.43522
R18002 Reset.n29 Reset.n25 7.43522
R18003 Reset.n45 Reset.n41 7.43522
R18004 Reset.n61 Reset.n57 7.43522
R18005 Reset.n21 Reset.n17 4.88651
R18006 Reset.n37 Reset.n33 4.88651
R18007 Reset.n77 Reset.n73 4.88651
R18008 Reset.n53 Reset.n49 4.88651
R18009 Reset.n69 Reset.n65 4.88651
R18010 Reset.n85 Reset.n81 4.88651
R18011 Reset.n70 Reset.n62 4.37435
R18012 Reset.n54 Reset.n46 4.37435
R18013 Reset.n38 Reset.n30 4.37435
R18014 Reset.n22 Reset.n14 4.37435
R18015 Reset.n86 Reset.n78 4.3742
R18016 Reset.n87 Reset.n86 2.6417
R18017 Reset Reset.n87 2.357
R18018 Reset Reset.n87 1.56597
R18019 Reset.n78 Reset.n70 0.4268
R18020 Reset.n62 Reset.n54 0.42665
R18021 Reset.n46 Reset.n38 0.42665
R18022 Reset.n30 Reset.n22 0.42665
R18023 a_n23422_n314.n1 a_n23422_n314.t3 11.0083
R18024 a_n23422_n314.n2 a_n23422_n314.n1 7.51324
R18025 a_n23422_n314.n2 a_n23422_n314.n0 5.39574
R18026 a_n23422_n314.t2 a_n23422_n314.n2 4.91248
R18027 a_n23422_n314.n1 a_n23422_n314.t4 4.12425
R18028 a_n23422_n314.n0 a_n23422_n314.t1 3.7821
R18029 a_n23422_n314.n0 a_n23422_n314.t0 3.77824
R18030 a_133966_n314.n1 a_133966_n314.t5 75.0252
R18031 a_133966_n314.n1 a_133966_n314.t4 44.0697
R18032 a_133966_n314.n2 a_133966_n314.t3 10.6055
R18033 a_133966_n314.n0 a_133966_n314.t1 10.6055
R18034 a_133966_n314.n0 a_133966_n314.n2 8.89791
R18035 a_133966_n314.n0 a_133966_n314.n1 5.7951
R18036 a_133966_n314.t0 a_133966_n314.n0 4.53117
R18037 a_133966_n314.n2 a_133966_n314.t2 4.53024
R18038 a_134950_n314.n0 a_134950_n314.t6 74.8588
R18039 a_134950_n314.n0 a_134950_n314.t5 44.2362
R18040 a_134950_n314.n3 a_134950_n314.n0 14.5242
R18041 a_134950_n314.n3 a_134950_n314.t3 11.0089
R18042 a_134950_n314.n2 a_134950_n314.n1 5.39574
R18043 a_134950_n314.n2 a_134950_n314.t1 4.91248
R18044 a_134950_n314.t0 a_134950_n314.n3 4.12612
R18045 a_134950_n314.n1 a_134950_n314.t2 3.7821
R18046 a_134950_n314.n1 a_134950_n314.t4 3.77824
R18047 a_134950_n314.n0 a_134950_n314.n2 1.83141
R18048 a_n27278_n4054.n2 a_n27278_n4054.t4 82.7757
R18049 a_n27278_n4054.n3 a_n27278_n4054.t2 82.6414
R18050 a_n27278_n4054.n1 a_n27278_n4054.t5 70.3153
R18051 a_n27278_n4054.n2 a_n27278_n4054.t7 55.8254
R18052 a_n27278_n4054.n4 a_n27278_n4054.t6 51.5648
R18053 a_n27278_n4054.n1 a_n27278_n4054.t3 39.8548
R18054 a_n27278_n4054.n0 a_n27278_n4054.t1 6.02308
R18055 a_n27278_n4054.n4 a_n27278_n4054.n3 3.9695
R18056 a_n27278_n4054.n0 a_n27278_n4054.n4 3.3953
R18057 a_n27278_n4054.n0 a_n27278_n4054.n1 2.70724
R18058 a_n27278_n4054.t0 a_n27278_n4054.n0 2.47188
R18059 a_n27278_n4054.n3 a_n27278_n4054.n2 1.3073
R18060 a_n21182_n4422.n1 a_n21182_n4422.t4 11.0083
R18061 a_n21182_n4422.n2 a_n21182_n4422.n1 7.51324
R18062 a_n21182_n4422.n2 a_n21182_n4422.n0 5.39574
R18063 a_n21182_n4422.t0 a_n21182_n4422.n2 4.91281
R18064 a_n21182_n4422.n1 a_n21182_n4422.t2 4.12408
R18065 a_n21182_n4422.n0 a_n21182_n4422.t1 3.7821
R18066 a_n21182_n4422.n0 a_n21182_n4422.t3 3.77824
R18067 a_102002_n18190.n2 a_102002_n18190.t7 82.7757
R18068 a_102002_n18190.n3 a_102002_n18190.t6 82.6424
R18069 a_102002_n18190.n1 a_102002_n18190.t4 70.3153
R18070 a_102002_n18190.n2 a_102002_n18190.t2 55.8264
R18071 a_102002_n18190.n4 a_102002_n18190.t5 51.5658
R18072 a_102002_n18190.n1 a_102002_n18190.t3 39.854
R18073 a_102002_n18190.n0 a_102002_n18190.t0 6.02308
R18074 a_102002_n18190.n4 a_102002_n18190.n3 3.9695
R18075 a_102002_n18190.n0 a_102002_n18190.n4 3.3953
R18076 a_102002_n18190.n0 a_102002_n18190.n1 2.70724
R18077 a_102002_n18190.t1 a_102002_n18190.n0 2.47208
R18078 a_102002_n18190.n3 a_102002_n18190.n2 1.3073
R18079 a_112898_n18422.n2 a_112898_n18422.t0 11.0089
R18080 a_112898_n18422.n2 a_112898_n18422.n1 7.28488
R18081 a_112898_n18422.n1 a_112898_n18422.n0 5.39574
R18082 a_112898_n18422.n1 a_112898_n18422.t2 4.91248
R18083 a_112898_n18422.t1 a_112898_n18422.n2 4.12612
R18084 a_112898_n18422.n0 a_112898_n18422.t3 3.7821
R18085 a_112898_n18422.n0 a_112898_n18422.t4 3.77824
R18086 a_110134_n18422.n1 a_110134_n18422.t4 75.0252
R18087 a_110134_n18422.n1 a_110134_n18422.t5 44.0697
R18088 a_110134_n18422.n3 a_110134_n18422.t3 11.0112
R18089 a_110134_n18422.n0 a_110134_n18422.t0 10.6055
R18090 a_110134_n18422.n2 a_110134_n18422.n0 9.81776
R18091 a_110134_n18422.n2 a_110134_n18422.n1 5.81441
R18092 a_110134_n18422.n3 a_110134_n18422.n2 4.64798
R18093 a_110134_n18422.n0 a_110134_n18422.t2 4.53024
R18094 a_110134_n18422.t1 a_110134_n18422.n3 4.12554
R18095 a_96736_n13096.n0 a_96736_n13096.t5 85.7547
R18096 a_96736_n13096.n2 a_96736_n13096.t4 70.3153
R18097 a_96736_n13096.n3 a_96736_n13096.t7 51.5027
R18098 a_96736_n13096.n3 a_96736_n13096.t3 51.1583
R18099 a_96736_n13096.n2 a_96736_n13096.t2 39.8548
R18100 a_96736_n13096.n0 a_96736_n13096.t6 24.4279
R18101 a_96736_n13096.n1 a_96736_n13096.n0 7.82327
R18102 a_96736_n13096.n1 a_96736_n13096.t0 5.96645
R18103 a_96736_n13096.n1 a_96736_n13096.n2 2.73467
R18104 a_96736_n13096.t1 a_96736_n13096.n1 2.52922
R18105 a_96736_n13096.n0 a_96736_n13096.n3 1.30714
R18106 a_102822_n13946.n2 a_102822_n13946.t5 82.7757
R18107 a_102822_n13946.n3 a_102822_n13946.t7 82.6414
R18108 a_102822_n13946.n1 a_102822_n13946.t4 70.3153
R18109 a_102822_n13946.n2 a_102822_n13946.t6 55.8254
R18110 a_102822_n13946.n4 a_102822_n13946.t3 51.5648
R18111 a_102822_n13946.n1 a_102822_n13946.t2 39.8548
R18112 a_102822_n13946.n0 a_102822_n13946.t1 6.02308
R18113 a_102822_n13946.n4 a_102822_n13946.n3 3.9695
R18114 a_102822_n13946.n0 a_102822_n13946.n4 3.3953
R18115 a_102822_n13946.n0 a_102822_n13946.n1 2.70724
R18116 a_102822_n13946.t0 a_102822_n13946.n0 2.47188
R18117 a_102822_n13946.n3 a_102822_n13946.n2 1.3073
R18118 a_107442_n14314.n0 a_107442_n14314.t6 74.8588
R18119 a_107442_n14314.n0 a_107442_n14314.t5 44.2362
R18120 a_107442_n14314.n3 a_107442_n14314.n0 14.5242
R18121 a_107442_n14314.n3 a_107442_n14314.t1 11.0089
R18122 a_107442_n14314.n2 a_107442_n14314.n1 5.39574
R18123 a_107442_n14314.n2 a_107442_n14314.t3 4.91281
R18124 a_107442_n14314.t0 a_107442_n14314.n3 4.12554
R18125 a_107442_n14314.n1 a_107442_n14314.t4 3.7821
R18126 a_107442_n14314.n1 a_107442_n14314.t2 3.77824
R18127 a_107442_n14314.n0 a_107442_n14314.n2 1.83141
R18128 a_108918_n14314.n2 a_108918_n14314.t1 11.0083
R18129 a_108918_n14314.n2 a_108918_n14314.n1 7.51324
R18130 a_108918_n14314.n1 a_108918_n14314.n0 5.39574
R18131 a_108918_n14314.n1 a_108918_n14314.t2 4.91281
R18132 a_108918_n14314.t0 a_108918_n14314.n2 4.12501
R18133 a_108918_n14314.n0 a_108918_n14314.t3 3.7821
R18134 a_108918_n14314.n0 a_108918_n14314.t4 3.77824
R18135 a_6822_n13192.n0 a_6822_n13192.t3 86.4194
R18136 a_6822_n13192.n2 a_6822_n13192.t4 82.415
R18137 a_6822_n13192.n1 a_6822_n13192.t2 51.8534
R18138 a_6822_n13192.n0 a_6822_n13192.t5 51.8062
R18139 a_6822_n13192.n3 a_6822_n13192.t1 6.28457
R18140 a_6822_n13192.n2 a_6822_n13192.n1 4.1171
R18141 a_6822_n13192.n3 a_6822_n13192.n2 2.66254
R18142 a_6822_n13192.t0 a_6822_n13192.n3 2.21138
R18143 a_6822_n13192.n1 a_6822_n13192.n0 1.3775
R18144 a_41342_n4422.n0 a_41342_n4422.t6 74.8588
R18145 a_41342_n4422.n0 a_41342_n4422.t5 44.2362
R18146 a_41342_n4422.n3 a_41342_n4422.n0 14.5242
R18147 a_41342_n4422.n3 a_41342_n4422.t1 11.0089
R18148 a_41342_n4422.n2 a_41342_n4422.n1 5.39574
R18149 a_41342_n4422.n2 a_41342_n4422.t4 4.91281
R18150 a_41342_n4422.t0 a_41342_n4422.n3 4.12554
R18151 a_41342_n4422.n1 a_41342_n4422.t3 3.7821
R18152 a_41342_n4422.n1 a_41342_n4422.t2 3.77824
R18153 a_41342_n4422.n0 a_41342_n4422.n2 1.83141
R18154 a_42818_n4422.n1 a_42818_n4422.t2 11.0083
R18155 a_42818_n4422.n2 a_42818_n4422.n1 7.51324
R18156 a_42818_n4422.n2 a_42818_n4422.n0 5.39574
R18157 a_42818_n4422.t0 a_42818_n4422.n2 4.91281
R18158 a_42818_n4422.n1 a_42818_n4422.t3 4.12408
R18159 a_42818_n4422.n0 a_42818_n4422.t1 3.7821
R18160 a_42818_n4422.n0 a_42818_n4422.t4 3.77824
R18161 a_6822_n18190.n0 a_6822_n18190.t4 86.4194
R18162 a_6822_n18190.n2 a_6822_n18190.t2 82.416
R18163 a_6822_n18190.n1 a_6822_n18190.t3 51.8544
R18164 a_6822_n18190.n0 a_6822_n18190.t5 51.8072
R18165 a_6822_n18190.n3 a_6822_n18190.t0 6.28457
R18166 a_6822_n18190.n2 a_6822_n18190.n1 4.1171
R18167 a_6822_n18190.n3 a_6822_n18190.n2 2.66253
R18168 a_6822_n18190.t1 a_6822_n18190.n3 2.21122
R18169 a_6822_n18190.n1 a_6822_n18190.n0 1.3775
R18170 SAR_Asynchronous_Logic_4/D_reset_FF_1.Q.n1 SAR_Asynchronous_Logic_4/D_reset_FF_1.Q.t11 74.8588
R18171 SAR_Asynchronous_Logic_4/D_reset_FF_1.Q.n3 SAR_Asynchronous_Logic_4/D_reset_FF_1.Q.t10 70.3153
R18172 SAR_Asynchronous_Logic_4/D_reset_FF_1.Q.n1 SAR_Asynchronous_Logic_4/D_reset_FF_1.Q.t12 44.2362
R18173 SAR_Asynchronous_Logic_4/D_reset_FF_1.Q.n3 SAR_Asynchronous_Logic_4/D_reset_FF_1.Q.t9 39.8548
R18174 SAR_Asynchronous_Logic_4/D_reset_FF_1.Q.n4 SAR_Asynchronous_Logic_4/D_reset_FF_1.Q.n0 11.62
R18175 SAR_Asynchronous_Logic_4/D_reset_FF_1.Q.n6 SAR_Asynchronous_Logic_4/D_reset_FF_1.Q.t6 11.0112
R18176 SAR_Asynchronous_Logic_4/D_reset_FF_1.Q.n7 SAR_Asynchronous_Logic_4/D_reset_FF_1.Q.t7 11.0112
R18177 SAR_Asynchronous_Logic_4/D_reset_FF_1.Q.n5 SAR_Asynchronous_Logic_4/D_reset_FF_1.Q.t5 11.0083
R18178 SAR_Asynchronous_Logic_4/D_reset_FF_1.Q.n9 SAR_Asynchronous_Logic_4/D_reset_FF_1.Q.n5 9.49928
R18179 SAR_Asynchronous_Logic_4/D_reset_FF_1.Q.n8 SAR_Asynchronous_Logic_4/D_reset_FF_1.Q.n6 7.28497
R18180 SAR_Asynchronous_Logic_4/D_reset_FF_1.Q.n8 SAR_Asynchronous_Logic_4/D_reset_FF_1.Q.n7 6.65722
R18181 SAR_Asynchronous_Logic_4/D_reset_FF_1.Q.n9 SAR_Asynchronous_Logic_4/D_reset_FF_1.Q.n8 5.53329
R18182 SAR_Asynchronous_Logic_4/D_reset_FF_1.Q.n0 SAR_Asynchronous_Logic_4/D_reset_FF_1.Q.n2 5.39574
R18183 SAR_Asynchronous_Logic_4/D_reset_FF_1.Q.n0 SAR_Asynchronous_Logic_4/D_reset_FF_1.Q.t1 4.91281
R18184 SAR_Asynchronous_Logic_4/D_reset_FF_1.Q SAR_Asynchronous_Logic_4/D_reset_FF_1.Q.n9 4.59604
R18185 SAR_Asynchronous_Logic_4/D_reset_FF_1.Q.n6 SAR_Asynchronous_Logic_4/D_reset_FF_1.Q.t3 4.12478
R18186 SAR_Asynchronous_Logic_4/D_reset_FF_1.Q.n7 SAR_Asynchronous_Logic_4/D_reset_FF_1.Q.t4 4.12478
R18187 SAR_Asynchronous_Logic_4/D_reset_FF_1.Q.n5 SAR_Asynchronous_Logic_4/D_reset_FF_1.Q.t8 4.12425
R18188 SAR_Asynchronous_Logic_4/D_reset_FF_1.Q.n2 SAR_Asynchronous_Logic_4/D_reset_FF_1.Q.t0 3.7821
R18189 SAR_Asynchronous_Logic_4/D_reset_FF_1.Q.n2 SAR_Asynchronous_Logic_4/D_reset_FF_1.Q.t2 3.77824
R18190 SAR_Asynchronous_Logic_4/D_reset_FF_1.Q.n0 SAR_Asynchronous_Logic_4/D_reset_FF_1.Q.n1 3.04186
R18191 SAR_Asynchronous_Logic_4/D_reset_FF_1.Q SAR_Asynchronous_Logic_4/D_reset_FF_1.Q.n4 2.86313
R18192 SAR_Asynchronous_Logic_4/D_reset_FF_1.Q.n4 SAR_Asynchronous_Logic_4/D_reset_FF_1.Q.n3 2.84345
R18193 a_8066_n18422.n1 a_8066_n18422.t4 75.0252
R18194 a_8066_n18422.n1 a_8066_n18422.t5 44.0697
R18195 a_8066_n18422.n2 a_8066_n18422.t3 10.6055
R18196 a_8066_n18422.n0 a_8066_n18422.t1 10.6055
R18197 a_8066_n18422.n2 a_8066_n18422.n0 8.89791
R18198 a_8066_n18422.n0 a_8066_n18422.n1 5.7951
R18199 a_8066_n18422.t0 a_8066_n18422.n2 4.53117
R18200 a_8066_n18422.n0 a_8066_n18422.t2 4.53024
R18201 a_38822_n13192.n0 a_38822_n13192.t3 86.4194
R18202 a_38822_n13192.n2 a_38822_n13192.t2 82.415
R18203 a_38822_n13192.n1 a_38822_n13192.t5 51.8534
R18204 a_38822_n13192.n0 a_38822_n13192.t4 51.8062
R18205 a_38822_n13192.n3 a_38822_n13192.t0 6.28457
R18206 a_38822_n13192.n2 a_38822_n13192.n1 4.1171
R18207 a_38822_n13192.n3 a_38822_n13192.n2 2.66254
R18208 a_38822_n13192.t1 a_38822_n13192.n3 2.21138
R18209 a_38822_n13192.n1 a_38822_n13192.n0 1.3775
R18210 a_44732_n13054.n1 a_44732_n13054.t4 75.0252
R18211 a_44732_n13054.n1 a_44732_n13054.t5 44.0697
R18212 a_44732_n13054.n2 a_44732_n13054.t2 10.6055
R18213 a_44732_n13054.n0 a_44732_n13054.t0 10.6055
R18214 a_44732_n13054.n2 a_44732_n13054.n0 8.89791
R18215 a_44732_n13054.n0 a_44732_n13054.n1 5.7951
R18216 a_44732_n13054.t1 a_44732_n13054.n2 4.53176
R18217 a_44732_n13054.n0 a_44732_n13054.t3 4.53041
R18218 D_C_2 D_C_2.n0 17.04
R18219 D_C_2.n0 D_C_2.t0 11.0083
R18220 D_C_2.n0 D_C_2.t1 4.12408
R18221 SAR_Asynchronous_Logic_5/D_reset_FF_1.Q.n7 SAR_Asynchronous_Logic_5/D_reset_FF_1.Q.t11 74.8588
R18222 SAR_Asynchronous_Logic_5/D_reset_FF_1.Q.n8 SAR_Asynchronous_Logic_5/D_reset_FF_1.Q.t9 70.3153
R18223 SAR_Asynchronous_Logic_5/D_reset_FF_1.Q.n7 SAR_Asynchronous_Logic_5/D_reset_FF_1.Q.t12 44.2362
R18224 SAR_Asynchronous_Logic_5/D_reset_FF_1.Q.n8 SAR_Asynchronous_Logic_5/D_reset_FF_1.Q.t10 39.854
R18225 SAR_Asynchronous_Logic_5/D_reset_FF_1.Q.n9 SAR_Asynchronous_Logic_5/D_reset_FF_1.Q.n0 11.62
R18226 SAR_Asynchronous_Logic_5/D_reset_FF_1.Q.n2 SAR_Asynchronous_Logic_5/D_reset_FF_1.Q.t6 11.0112
R18227 SAR_Asynchronous_Logic_5/D_reset_FF_1.Q.n3 SAR_Asynchronous_Logic_5/D_reset_FF_1.Q.t7 11.0112
R18228 SAR_Asynchronous_Logic_5/D_reset_FF_1.Q.n1 SAR_Asynchronous_Logic_5/D_reset_FF_1.Q.t8 11.0083
R18229 SAR_Asynchronous_Logic_5/D_reset_FF_1.Q.n5 SAR_Asynchronous_Logic_5/D_reset_FF_1.Q.n1 9.49928
R18230 SAR_Asynchronous_Logic_5/D_reset_FF_1.Q.n4 SAR_Asynchronous_Logic_5/D_reset_FF_1.Q.n2 7.28497
R18231 SAR_Asynchronous_Logic_5/D_reset_FF_1.Q.n4 SAR_Asynchronous_Logic_5/D_reset_FF_1.Q.n3 6.65722
R18232 SAR_Asynchronous_Logic_5/D_reset_FF_1.Q.n5 SAR_Asynchronous_Logic_5/D_reset_FF_1.Q.n4 5.53329
R18233 SAR_Asynchronous_Logic_5/D_reset_FF_1.Q.n0 SAR_Asynchronous_Logic_5/D_reset_FF_1.Q.n6 5.39574
R18234 SAR_Asynchronous_Logic_5/D_reset_FF_1.Q.n0 SAR_Asynchronous_Logic_5/D_reset_FF_1.Q.t3 4.91248
R18235 SAR_Asynchronous_Logic_5/D_reset_FF_1.Q SAR_Asynchronous_Logic_5/D_reset_FF_1.Q.n5 4.59604
R18236 SAR_Asynchronous_Logic_5/D_reset_FF_1.Q.n1 SAR_Asynchronous_Logic_5/D_reset_FF_1.Q.t0 4.12501
R18237 SAR_Asynchronous_Logic_5/D_reset_FF_1.Q.n2 SAR_Asynchronous_Logic_5/D_reset_FF_1.Q.t1 4.12461
R18238 SAR_Asynchronous_Logic_5/D_reset_FF_1.Q.n3 SAR_Asynchronous_Logic_5/D_reset_FF_1.Q.t5 4.12461
R18239 SAR_Asynchronous_Logic_5/D_reset_FF_1.Q.n6 SAR_Asynchronous_Logic_5/D_reset_FF_1.Q.t2 3.7821
R18240 SAR_Asynchronous_Logic_5/D_reset_FF_1.Q.n6 SAR_Asynchronous_Logic_5/D_reset_FF_1.Q.t4 3.77824
R18241 SAR_Asynchronous_Logic_5/D_reset_FF_1.Q.n0 SAR_Asynchronous_Logic_5/D_reset_FF_1.Q.n7 3.04286
R18242 SAR_Asynchronous_Logic_5/D_reset_FF_1.Q SAR_Asynchronous_Logic_5/D_reset_FF_1.Q.n9 2.86313
R18243 SAR_Asynchronous_Logic_5/D_reset_FF_1.Q.n9 SAR_Asynchronous_Logic_5/D_reset_FF_1.Q.n8 2.84345
R18244 a_132722_n4054.n2 a_132722_n4054.t5 82.7757
R18245 a_132722_n4054.n3 a_132722_n4054.t7 82.6414
R18246 a_132722_n4054.n1 a_132722_n4054.t2 70.3153
R18247 a_132722_n4054.n2 a_132722_n4054.t3 55.8254
R18248 a_132722_n4054.n4 a_132722_n4054.t4 51.5648
R18249 a_132722_n4054.n1 a_132722_n4054.t6 39.8548
R18250 a_132722_n4054.n0 a_132722_n4054.t0 6.02308
R18251 a_132722_n4054.n4 a_132722_n4054.n3 3.9695
R18252 a_132722_n4054.n0 a_132722_n4054.n4 3.3953
R18253 a_132722_n4054.n0 a_132722_n4054.n1 2.70724
R18254 a_132722_n4054.t1 a_132722_n4054.n0 2.47188
R18255 a_132722_n4054.n3 a_132722_n4054.n2 1.3073
R18256 a_132722_n3300.n0 a_132722_n3300.t3 86.4194
R18257 a_132722_n3300.n2 a_132722_n3300.t4 82.415
R18258 a_132722_n3300.n1 a_132722_n3300.t2 51.8534
R18259 a_132722_n3300.n0 a_132722_n3300.t5 51.8062
R18260 a_132722_n3300.n3 a_132722_n3300.t1 6.28457
R18261 a_132722_n3300.n2 a_132722_n3300.n1 4.1171
R18262 a_132722_n3300.n3 a_132722_n3300.n2 2.66254
R18263 a_132722_n3300.t0 a_132722_n3300.n3 2.21138
R18264 a_132722_n3300.n1 a_132722_n3300.n0 1.3775
R18265 a_131002_n80.n0 a_131002_n80.t3 85.7557
R18266 a_131002_n80.n3 a_131002_n80.t4 70.3153
R18267 a_131002_n80.n2 a_131002_n80.t7 51.5037
R18268 a_131002_n80.n2 a_131002_n80.t5 51.1583
R18269 a_131002_n80.n3 a_131002_n80.t6 39.854
R18270 a_131002_n80.n0 a_131002_n80.t2 24.4279
R18271 a_131002_n80.n1 a_131002_n80.n0 7.82327
R18272 a_131002_n80.n1 a_131002_n80.t1 5.96645
R18273 a_131002_n80.n1 a_131002_n80.n3 2.73367
R18274 a_131002_n80.t0 a_131002_n80.n1 2.52942
R18275 a_131002_n80.n0 a_131002_n80.n2 1.30714
R18276 a_146854_1076.n0 a_146854_1076.t3 28.6634
R18277 a_146854_1076.n0 a_146854_1076.t1 11.2157
R18278 a_146854_1076.n1 a_146854_1076.t0 3.00172
R18279 a_146854_1076.t2 a_146854_1076.n1 2.9434
R18280 a_146854_1076.n1 a_146854_1076.n0 0.976737
R18281 a_102822_n18190.n0 a_102822_n18190.t4 86.4194
R18282 a_102822_n18190.n2 a_102822_n18190.t3 82.416
R18283 a_102822_n18190.n1 a_102822_n18190.t5 51.8544
R18284 a_102822_n18190.n0 a_102822_n18190.t2 51.8072
R18285 a_102822_n18190.n3 a_102822_n18190.t1 6.28457
R18286 a_102822_n18190.n2 a_102822_n18190.n1 4.1171
R18287 a_102822_n18190.n3 a_102822_n18190.n2 2.66253
R18288 a_102822_n18190.t0 a_102822_n18190.n3 2.21122
R18289 a_102822_n18190.n1 a_102822_n18190.n0 1.3775
R18290 a_139442_n14314.n0 a_139442_n14314.t5 74.8588
R18291 a_139442_n14314.n0 a_139442_n14314.t6 44.2362
R18292 a_139442_n14314.n0 a_139442_n14314.n2 14.5242
R18293 a_139442_n14314.n2 a_139442_n14314.t4 11.0089
R18294 a_139442_n14314.n3 a_139442_n14314.n1 5.39574
R18295 a_139442_n14314.t0 a_139442_n14314.n3 4.91281
R18296 a_139442_n14314.n2 a_139442_n14314.t2 4.12461
R18297 a_139442_n14314.n1 a_139442_n14314.t1 3.7821
R18298 a_139442_n14314.n1 a_139442_n14314.t3 3.77824
R18299 a_139442_n14314.n3 a_139442_n14314.n0 1.83141
R18300 a_64736_n13096.n0 a_64736_n13096.t7 85.7547
R18301 a_64736_n13096.n2 a_64736_n13096.t3 70.3153
R18302 a_64736_n13096.n3 a_64736_n13096.t4 51.5027
R18303 a_64736_n13096.n3 a_64736_n13096.t6 51.1583
R18304 a_64736_n13096.n2 a_64736_n13096.t2 39.8548
R18305 a_64736_n13096.n0 a_64736_n13096.t5 24.4279
R18306 a_64736_n13096.n1 a_64736_n13096.n0 7.82327
R18307 a_64736_n13096.n1 a_64736_n13096.t0 5.96645
R18308 a_64736_n13096.n1 a_64736_n13096.n2 2.73467
R18309 a_64736_n13096.t1 a_64736_n13096.n1 2.52922
R18310 a_64736_n13096.n0 a_64736_n13096.n3 1.30714
R18311 a_70822_n13946.n2 a_70822_n13946.t5 82.7757
R18312 a_70822_n13946.n3 a_70822_n13946.t7 82.6414
R18313 a_70822_n13946.n1 a_70822_n13946.t4 70.3153
R18314 a_70822_n13946.n2 a_70822_n13946.t6 55.8254
R18315 a_70822_n13946.n4 a_70822_n13946.t3 51.5648
R18316 a_70822_n13946.n1 a_70822_n13946.t2 39.8548
R18317 a_70822_n13946.n0 a_70822_n13946.t1 6.02308
R18318 a_70822_n13946.n4 a_70822_n13946.n3 3.9695
R18319 a_70822_n13946.n0 a_70822_n13946.n4 3.3953
R18320 a_70822_n13946.n0 a_70822_n13946.n1 2.70724
R18321 a_70822_n13946.t0 a_70822_n13946.n0 2.47188
R18322 a_70822_n13946.n3 a_70822_n13946.n2 1.3073
R18323 a_70002_n18190.n2 a_70002_n18190.t5 82.7757
R18324 a_70002_n18190.n3 a_70002_n18190.t7 82.6424
R18325 a_70002_n18190.n1 a_70002_n18190.t4 70.3153
R18326 a_70002_n18190.n2 a_70002_n18190.t2 55.8264
R18327 a_70002_n18190.n4 a_70002_n18190.t6 51.5658
R18328 a_70002_n18190.n1 a_70002_n18190.t3 39.854
R18329 a_70002_n18190.n0 a_70002_n18190.t1 6.02308
R18330 a_70002_n18190.n4 a_70002_n18190.n3 3.9695
R18331 a_70002_n18190.n0 a_70002_n18190.n4 3.3953
R18332 a_70002_n18190.n0 a_70002_n18190.n1 2.70724
R18333 a_70002_n18190.t0 a_70002_n18190.n0 2.47208
R18334 a_70002_n18190.n3 a_70002_n18190.n2 1.3073
R18335 a_80898_n18422.n2 a_80898_n18422.t2 11.0089
R18336 a_80898_n18422.n2 a_80898_n18422.n1 7.28488
R18337 a_80898_n18422.n1 a_80898_n18422.n0 5.39574
R18338 a_80898_n18422.n1 a_80898_n18422.t4 4.91248
R18339 a_80898_n18422.t1 a_80898_n18422.n2 4.12612
R18340 a_80898_n18422.n0 a_80898_n18422.t3 3.7821
R18341 a_80898_n18422.n0 a_80898_n18422.t0 3.77824
R18342 a_105050_n18422.n0 a_105050_n18422.t5 74.8588
R18343 a_105050_n18422.n0 a_105050_n18422.t6 44.2362
R18344 a_105050_n18422.n3 a_105050_n18422.n0 14.5242
R18345 a_105050_n18422.n3 a_105050_n18422.t0 11.0089
R18346 a_105050_n18422.n2 a_105050_n18422.n1 5.39574
R18347 a_105050_n18422.n2 a_105050_n18422.t2 4.91248
R18348 a_105050_n18422.t1 a_105050_n18422.n3 4.12612
R18349 a_105050_n18422.n1 a_105050_n18422.t3 3.7821
R18350 a_105050_n18422.n1 a_105050_n18422.t4 3.77824
R18351 a_105050_n18422.n0 a_105050_n18422.n2 1.83141
R18352 a_34110_n80.n3 a_34110_n80.t2 81.0083
R18353 a_34110_n80.n3 a_34110_n80.t6 80.9469
R18354 a_34110_n80.n2 a_34110_n80.t4 70.3153
R18355 a_34110_n80.n0 a_34110_n80.t7 54.8886
R18356 a_34110_n80.n2 a_34110_n80.t5 39.854
R18357 a_34110_n80.n0 a_34110_n80.t3 16.7884
R18358 a_34110_n80.n1 a_34110_n80.n0 9.8148
R18359 a_34110_n80.n1 a_34110_n80.t1 5.96645
R18360 a_34110_n80.n1 a_34110_n80.n2 2.69789
R18361 a_34110_n80.t0 a_34110_n80.n1 2.52942
R18362 a_34110_n80.n0 a_34110_n80.n3 1.30877
R18363 a_50854_1076.n0 a_50854_1076.t3 28.6634
R18364 a_50854_1076.n0 a_50854_1076.t2 11.2157
R18365 a_50854_1076.n1 a_50854_1076.t1 3.00172
R18366 a_50854_1076.t0 a_50854_1076.n1 2.9434
R18367 a_50854_1076.n1 a_50854_1076.n0 0.976737
R18368 SAR_Asynchronous_Logic_1/D_reset_FF_1.Q.n7 SAR_Asynchronous_Logic_1/D_reset_FF_1.Q.t10 74.8588
R18369 SAR_Asynchronous_Logic_1/D_reset_FF_1.Q.n8 SAR_Asynchronous_Logic_1/D_reset_FF_1.Q.t11 70.3153
R18370 SAR_Asynchronous_Logic_1/D_reset_FF_1.Q.n7 SAR_Asynchronous_Logic_1/D_reset_FF_1.Q.t9 44.2362
R18371 SAR_Asynchronous_Logic_1/D_reset_FF_1.Q.n8 SAR_Asynchronous_Logic_1/D_reset_FF_1.Q.t12 39.854
R18372 SAR_Asynchronous_Logic_1/D_reset_FF_1.Q.n9 SAR_Asynchronous_Logic_1/D_reset_FF_1.Q.n0 11.62
R18373 SAR_Asynchronous_Logic_1/D_reset_FF_1.Q.n2 SAR_Asynchronous_Logic_1/D_reset_FF_1.Q.t8 11.0112
R18374 SAR_Asynchronous_Logic_1/D_reset_FF_1.Q.n3 SAR_Asynchronous_Logic_1/D_reset_FF_1.Q.t7 11.0112
R18375 SAR_Asynchronous_Logic_1/D_reset_FF_1.Q.n1 SAR_Asynchronous_Logic_1/D_reset_FF_1.Q.t3 11.0083
R18376 SAR_Asynchronous_Logic_1/D_reset_FF_1.Q.n5 SAR_Asynchronous_Logic_1/D_reset_FF_1.Q.n1 9.49928
R18377 SAR_Asynchronous_Logic_1/D_reset_FF_1.Q.n4 SAR_Asynchronous_Logic_1/D_reset_FF_1.Q.n2 7.28497
R18378 SAR_Asynchronous_Logic_1/D_reset_FF_1.Q.n4 SAR_Asynchronous_Logic_1/D_reset_FF_1.Q.n3 6.65722
R18379 SAR_Asynchronous_Logic_1/D_reset_FF_1.Q.n5 SAR_Asynchronous_Logic_1/D_reset_FF_1.Q.n4 5.53329
R18380 SAR_Asynchronous_Logic_1/D_reset_FF_1.Q.n0 SAR_Asynchronous_Logic_1/D_reset_FF_1.Q.n6 5.39574
R18381 SAR_Asynchronous_Logic_1/D_reset_FF_1.Q.n0 SAR_Asynchronous_Logic_1/D_reset_FF_1.Q.t6 4.91248
R18382 SAR_Asynchronous_Logic_1/D_reset_FF_1.Q SAR_Asynchronous_Logic_1/D_reset_FF_1.Q.n5 4.59604
R18383 SAR_Asynchronous_Logic_1/D_reset_FF_1.Q.n3 SAR_Asynchronous_Logic_1/D_reset_FF_1.Q.t1 4.12554
R18384 SAR_Asynchronous_Logic_1/D_reset_FF_1.Q.n2 SAR_Asynchronous_Logic_1/D_reset_FF_1.Q.t2 4.12461
R18385 SAR_Asynchronous_Logic_1/D_reset_FF_1.Q.n1 SAR_Asynchronous_Logic_1/D_reset_FF_1.Q.t4 4.12408
R18386 SAR_Asynchronous_Logic_1/D_reset_FF_1.Q.n6 SAR_Asynchronous_Logic_1/D_reset_FF_1.Q.t5 3.7821
R18387 SAR_Asynchronous_Logic_1/D_reset_FF_1.Q.n6 SAR_Asynchronous_Logic_1/D_reset_FF_1.Q.t0 3.77824
R18388 SAR_Asynchronous_Logic_1/D_reset_FF_1.Q.n0 SAR_Asynchronous_Logic_1/D_reset_FF_1.Q.n7 3.04286
R18389 SAR_Asynchronous_Logic_1/D_reset_FF_1.Q SAR_Asynchronous_Logic_1/D_reset_FF_1.Q.n9 2.86313
R18390 SAR_Asynchronous_Logic_1/D_reset_FF_1.Q.n9 SAR_Asynchronous_Logic_1/D_reset_FF_1.Q.n8 2.84345
R18391 SAR_Asynchronous_Logic_3/D_reset_FF_1.Q.n7 SAR_Asynchronous_Logic_3/D_reset_FF_1.Q.t9 74.8588
R18392 SAR_Asynchronous_Logic_3/D_reset_FF_1.Q.n8 SAR_Asynchronous_Logic_3/D_reset_FF_1.Q.t10 70.3153
R18393 SAR_Asynchronous_Logic_3/D_reset_FF_1.Q.n7 SAR_Asynchronous_Logic_3/D_reset_FF_1.Q.t11 44.2362
R18394 SAR_Asynchronous_Logic_3/D_reset_FF_1.Q.n8 SAR_Asynchronous_Logic_3/D_reset_FF_1.Q.t12 39.854
R18395 SAR_Asynchronous_Logic_3/D_reset_FF_1.Q.n9 SAR_Asynchronous_Logic_3/D_reset_FF_1.Q.n0 11.62
R18396 SAR_Asynchronous_Logic_3/D_reset_FF_1.Q.n2 SAR_Asynchronous_Logic_3/D_reset_FF_1.Q.t4 11.0112
R18397 SAR_Asynchronous_Logic_3/D_reset_FF_1.Q.n3 SAR_Asynchronous_Logic_3/D_reset_FF_1.Q.t3 11.0112
R18398 SAR_Asynchronous_Logic_3/D_reset_FF_1.Q.n1 SAR_Asynchronous_Logic_3/D_reset_FF_1.Q.t8 11.0083
R18399 SAR_Asynchronous_Logic_3/D_reset_FF_1.Q.n5 SAR_Asynchronous_Logic_3/D_reset_FF_1.Q.n1 9.49928
R18400 SAR_Asynchronous_Logic_3/D_reset_FF_1.Q.n4 SAR_Asynchronous_Logic_3/D_reset_FF_1.Q.n2 7.28497
R18401 SAR_Asynchronous_Logic_3/D_reset_FF_1.Q.n4 SAR_Asynchronous_Logic_3/D_reset_FF_1.Q.n3 6.65722
R18402 SAR_Asynchronous_Logic_3/D_reset_FF_1.Q.n5 SAR_Asynchronous_Logic_3/D_reset_FF_1.Q.n4 5.53329
R18403 SAR_Asynchronous_Logic_3/D_reset_FF_1.Q.n0 SAR_Asynchronous_Logic_3/D_reset_FF_1.Q.n6 5.39574
R18404 SAR_Asynchronous_Logic_3/D_reset_FF_1.Q.n0 SAR_Asynchronous_Logic_3/D_reset_FF_1.Q.t1 4.91248
R18405 SAR_Asynchronous_Logic_3/D_reset_FF_1.Q SAR_Asynchronous_Logic_3/D_reset_FF_1.Q.n5 4.59604
R18406 SAR_Asynchronous_Logic_3/D_reset_FF_1.Q.n2 SAR_Asynchronous_Logic_3/D_reset_FF_1.Q.t7 4.12461
R18407 SAR_Asynchronous_Logic_3/D_reset_FF_1.Q.n3 SAR_Asynchronous_Logic_3/D_reset_FF_1.Q.t6 4.12461
R18408 SAR_Asynchronous_Logic_3/D_reset_FF_1.Q.n1 SAR_Asynchronous_Logic_3/D_reset_FF_1.Q.t5 4.12408
R18409 SAR_Asynchronous_Logic_3/D_reset_FF_1.Q.n6 SAR_Asynchronous_Logic_3/D_reset_FF_1.Q.t0 3.7821
R18410 SAR_Asynchronous_Logic_3/D_reset_FF_1.Q.n6 SAR_Asynchronous_Logic_3/D_reset_FF_1.Q.t2 3.77824
R18411 SAR_Asynchronous_Logic_3/D_reset_FF_1.Q.n0 SAR_Asynchronous_Logic_3/D_reset_FF_1.Q.n7 3.04286
R18412 SAR_Asynchronous_Logic_3/D_reset_FF_1.Q SAR_Asynchronous_Logic_3/D_reset_FF_1.Q.n9 2.86313
R18413 SAR_Asynchronous_Logic_3/D_reset_FF_1.Q.n9 SAR_Asynchronous_Logic_3/D_reset_FF_1.Q.n8 2.84345
R18414 a_144898_n18422.n2 a_144898_n18422.t1 11.0089
R18415 a_144898_n18422.n2 a_144898_n18422.n1 7.28488
R18416 a_144898_n18422.n1 a_144898_n18422.n0 5.39574
R18417 a_144898_n18422.n1 a_144898_n18422.t3 4.91248
R18418 a_144898_n18422.t2 a_144898_n18422.n2 4.12612
R18419 a_144898_n18422.n0 a_144898_n18422.t4 3.7821
R18420 a_144898_n18422.n0 a_144898_n18422.t0 3.77824
R18421 a_46798_n314.n1 a_46798_n314.t0 11.0089
R18422 a_46798_n314.n2 a_46798_n314.n1 7.28488
R18423 a_46798_n314.n2 a_46798_n314.n0 5.39574
R18424 a_46798_n314.t2 a_46798_n314.n2 4.91248
R18425 a_46798_n314.n1 a_46798_n314.t4 4.12478
R18426 a_46798_n314.n0 a_46798_n314.t3 3.7821
R18427 a_46798_n314.n0 a_46798_n314.t1 3.77824
R18428 a_68722_n4054.n2 a_68722_n4054.t4 82.7757
R18429 a_68722_n4054.n3 a_68722_n4054.t6 82.6414
R18430 a_68722_n4054.n1 a_68722_n4054.t2 70.3153
R18431 a_68722_n4054.n2 a_68722_n4054.t7 55.8254
R18432 a_68722_n4054.n4 a_68722_n4054.t3 51.5648
R18433 a_68722_n4054.n1 a_68722_n4054.t5 39.8548
R18434 a_68722_n4054.n0 a_68722_n4054.t0 6.02308
R18435 a_68722_n4054.n4 a_68722_n4054.n3 3.9695
R18436 a_68722_n4054.n0 a_68722_n4054.n4 3.3953
R18437 a_68722_n4054.n0 a_68722_n4054.n1 2.70724
R18438 a_68722_n4054.t1 a_68722_n4054.n0 2.47188
R18439 a_68722_n4054.n3 a_68722_n4054.n2 1.3073
R18440 a_68722_n3300.n0 a_68722_n3300.t3 86.4194
R18441 a_68722_n3300.n2 a_68722_n3300.t4 82.415
R18442 a_68722_n3300.n1 a_68722_n3300.t2 51.8534
R18443 a_68722_n3300.n0 a_68722_n3300.t5 51.8062
R18444 a_68722_n3300.n3 a_68722_n3300.t1 6.28457
R18445 a_68722_n3300.n2 a_68722_n3300.n1 4.1171
R18446 a_68722_n3300.n3 a_68722_n3300.n2 2.66254
R18447 a_68722_n3300.t0 a_68722_n3300.n3 2.21138
R18448 a_68722_n3300.n1 a_68722_n3300.n0 1.3775
R18449 clks.n6 clks.t13 70.3153
R18450 clks.n7 clks.t7 70.3153
R18451 clks.n9 clks.t1 70.3153
R18452 clks.n8 clks.t15 70.3153
R18453 clks.n12 clks.t5 70.3153
R18454 clks.n3 clks.t0 70.3153
R18455 clks.n23 clks.t17 70.3153
R18456 clks.n21 clks.t14 70.3153
R18457 clks.n19 clks.t6 70.3153
R18458 clks.n17 clks.t2 70.3153
R18459 clks.n4 clks.t12 70.3153
R18460 clks.n22 clks.n21 42.2864
R18461 clks.n6 clks.t9 39.8548
R18462 clks.n7 clks.t4 39.8548
R18463 clks.n9 clks.t19 39.8548
R18464 clks.n3 clks.t18 39.8548
R18465 clks.n21 clks.t10 39.8548
R18466 clks.n17 clks.t20 39.8548
R18467 clks.n8 clks.t11 39.854
R18468 clks.n12 clks.t21 39.854
R18469 clks.n23 clks.t16 39.854
R18470 clks.n19 clks.t3 39.854
R18471 clks.n4 clks.t8 39.854
R18472 clks.n18 clks.n17 39.2703
R18473 clks.n11 clks.n7 36.4155
R18474 clks.n10 clks.n9 35.1419
R18475 clks.n5 clks.n3 32.3505
R18476 clks.n13 clks.n12 31.0794
R18477 clks.n24 clks.n23 28.4107
R18478 clks.n15 clks.n6 27.6093
R18479 clks.n20 clks.n19 26.8873
R18480 clks.n10 clks.n8 24.3542
R18481 clks.n5 clks.n4 21.6589
R18482 clks.n15 clks.n14 17.2511
R18483 clks.n18 clks.n16 3.8117
R18484 clks.n22 clks.n20 1.5833
R18485 clks.n25 clks.n24 1.45403
R18486 clks.n14 clks.n13 1.4531
R18487 clks.n13 clks.n11 1.21167
R18488 clks.n16 clks.n5 0.9593
R18489 clks.n26 clks.n25 0.908971
R18490 clks.n32 clks.n1 0.908971
R18491 clks.n16 clks.n15 0.9005
R18492 clks.n28 clks.n27 0.9005
R18493 clks.n29 clks.n2 0.9005
R18494 clks.n31 clks.n30 0.9005
R18495 clks.n2 clks.n0 0.9005
R18496 clks.n11 clks.n10 0.781039
R18497 clks.n24 clks.n22 0.6677
R18498 clks.n20 clks.n18 0.5405
R18499 clks.n14 clks.n1 0.487236
R18500 clks.n26 clks.n0 0.466943
R18501 clks clks.n32 0.464371
R18502 clks.n27 clks.n2 0.0164429
R18503 clks.n31 clks.n2 0.0164429
R18504 clks.n28 clks.n25 0.0148814
R18505 clks.n29 clks.n28 0.0148814
R18506 clks.n30 clks.n29 0.0148814
R18507 clks.n30 clks.n1 0.0148814
R18508 clks.n32 clks.n31 0.00883268
R18509 clks.n27 clks.n26 0.00883268
R18510 clks clks.n0 0.00307143
R18511 a_70822_n18190.n0 a_70822_n18190.t4 86.4194
R18512 a_70822_n18190.n2 a_70822_n18190.t3 82.416
R18513 a_70822_n18190.n1 a_70822_n18190.t5 51.8544
R18514 a_70822_n18190.n0 a_70822_n18190.t2 51.8072
R18515 a_70822_n18190.n3 a_70822_n18190.t1 6.28457
R18516 a_70822_n18190.n2 a_70822_n18190.n1 4.1171
R18517 a_70822_n18190.n3 a_70822_n18190.n2 2.66253
R18518 a_70822_n18190.t0 a_70822_n18190.n3 2.21122
R18519 a_70822_n18190.n1 a_70822_n18190.n0 1.3775
R18520 a_66110_n80.n3 a_66110_n80.t6 81.0083
R18521 a_66110_n80.n3 a_66110_n80.t3 80.9469
R18522 a_66110_n80.n2 a_66110_n80.t5 70.3153
R18523 a_66110_n80.n0 a_66110_n80.t4 54.8886
R18524 a_66110_n80.n2 a_66110_n80.t2 39.854
R18525 a_66110_n80.n0 a_66110_n80.t7 16.7884
R18526 a_66110_n80.n1 a_66110_n80.n0 9.8148
R18527 a_66110_n80.n1 a_66110_n80.t1 5.96645
R18528 a_66110_n80.n1 a_66110_n80.n2 2.69789
R18529 a_66110_n80.t0 a_66110_n80.n1 2.52942
R18530 a_66110_n80.n0 a_66110_n80.n3 1.30877
R18531 a_67002_n80.n0 a_67002_n80.t4 85.7557
R18532 a_67002_n80.n3 a_67002_n80.t6 70.3153
R18533 a_67002_n80.n2 a_67002_n80.t5 51.5037
R18534 a_67002_n80.n2 a_67002_n80.t7 51.1583
R18535 a_67002_n80.n3 a_67002_n80.t2 39.854
R18536 a_67002_n80.n0 a_67002_n80.t3 24.4279
R18537 a_67002_n80.n1 a_67002_n80.n0 7.82327
R18538 a_67002_n80.n1 a_67002_n80.t1 5.96645
R18539 a_67002_n80.n1 a_67002_n80.n3 2.73367
R18540 a_67002_n80.t0 a_67002_n80.n1 2.52942
R18541 a_67002_n80.n0 a_67002_n80.n2 1.30714
R18542 SAR_Asynchronous_Logic_8/D_reset_FF_1.Q.n1 SAR_Asynchronous_Logic_8/D_reset_FF_1.Q.t9 74.8588
R18543 SAR_Asynchronous_Logic_8/D_reset_FF_1.Q.n3 SAR_Asynchronous_Logic_8/D_reset_FF_1.Q.t12 70.3153
R18544 SAR_Asynchronous_Logic_8/D_reset_FF_1.Q.n1 SAR_Asynchronous_Logic_8/D_reset_FF_1.Q.t10 44.2362
R18545 SAR_Asynchronous_Logic_8/D_reset_FF_1.Q.n3 SAR_Asynchronous_Logic_8/D_reset_FF_1.Q.t11 39.8548
R18546 SAR_Asynchronous_Logic_8/D_reset_FF_1.Q.n4 SAR_Asynchronous_Logic_8/D_reset_FF_1.Q.n0 11.62
R18547 SAR_Asynchronous_Logic_8/D_reset_FF_1.Q.n7 SAR_Asynchronous_Logic_8/D_reset_FF_1.Q.t6 11.0112
R18548 SAR_Asynchronous_Logic_8/D_reset_FF_1.Q.n6 SAR_Asynchronous_Logic_8/D_reset_FF_1.Q.t7 11.0112
R18549 SAR_Asynchronous_Logic_8/D_reset_FF_1.Q.n5 SAR_Asynchronous_Logic_8/D_reset_FF_1.Q.t8 11.0083
R18550 SAR_Asynchronous_Logic_8/D_reset_FF_1.Q.n9 SAR_Asynchronous_Logic_8/D_reset_FF_1.Q.n5 9.49928
R18551 SAR_Asynchronous_Logic_8/D_reset_FF_1.Q.n8 SAR_Asynchronous_Logic_8/D_reset_FF_1.Q.n6 7.28497
R18552 SAR_Asynchronous_Logic_8/D_reset_FF_1.Q.n8 SAR_Asynchronous_Logic_8/D_reset_FF_1.Q.n7 6.65722
R18553 SAR_Asynchronous_Logic_8/D_reset_FF_1.Q.n9 SAR_Asynchronous_Logic_8/D_reset_FF_1.Q.n8 5.53329
R18554 SAR_Asynchronous_Logic_8/D_reset_FF_1.Q.n0 SAR_Asynchronous_Logic_8/D_reset_FF_1.Q.n2 5.39574
R18555 SAR_Asynchronous_Logic_8/D_reset_FF_1.Q.n0 SAR_Asynchronous_Logic_8/D_reset_FF_1.Q.t4 4.91281
R18556 SAR_Asynchronous_Logic_8/D_reset_FF_1.Q SAR_Asynchronous_Logic_8/D_reset_FF_1.Q.n9 4.59604
R18557 SAR_Asynchronous_Logic_8/D_reset_FF_1.Q.n6 SAR_Asynchronous_Logic_8/D_reset_FF_1.Q.t0 4.12612
R18558 SAR_Asynchronous_Logic_8/D_reset_FF_1.Q.n7 SAR_Asynchronous_Logic_8/D_reset_FF_1.Q.t1 4.12478
R18559 SAR_Asynchronous_Logic_8/D_reset_FF_1.Q.n5 SAR_Asynchronous_Logic_8/D_reset_FF_1.Q.t2 4.12425
R18560 SAR_Asynchronous_Logic_8/D_reset_FF_1.Q.n2 SAR_Asynchronous_Logic_8/D_reset_FF_1.Q.t3 3.7821
R18561 SAR_Asynchronous_Logic_8/D_reset_FF_1.Q.n2 SAR_Asynchronous_Logic_8/D_reset_FF_1.Q.t5 3.77824
R18562 SAR_Asynchronous_Logic_8/D_reset_FF_1.Q.n0 SAR_Asynchronous_Logic_8/D_reset_FF_1.Q.n1 3.04186
R18563 SAR_Asynchronous_Logic_8/D_reset_FF_1.Q SAR_Asynchronous_Logic_8/D_reset_FF_1.Q.n4 2.86313
R18564 SAR_Asynchronous_Logic_8/D_reset_FF_1.Q.n4 SAR_Asynchronous_Logic_8/D_reset_FF_1.Q.n3 2.84345
R18565 a_98012_n13060.n0 a_98012_n13060.t3 28.6634
R18566 a_98012_n13060.n0 a_98012_n13060.t1 11.2157
R18567 a_98012_n13060.n1 a_98012_n13060.t2 3.00189
R18568 a_98012_n13060.t0 a_98012_n13060.n1 2.94281
R18569 a_98012_n13060.n1 a_98012_n13060.n0 0.976737
R18570 a_36722_n4054.n2 a_36722_n4054.t3 82.7757
R18571 a_36722_n4054.n3 a_36722_n4054.t4 82.6414
R18572 a_36722_n4054.n1 a_36722_n4054.t2 70.3153
R18573 a_36722_n4054.n2 a_36722_n4054.t5 55.8254
R18574 a_36722_n4054.n4 a_36722_n4054.t6 51.5648
R18575 a_36722_n4054.n1 a_36722_n4054.t7 39.8548
R18576 a_36722_n4054.n0 a_36722_n4054.t1 6.02308
R18577 a_36722_n4054.n4 a_36722_n4054.n3 3.9695
R18578 a_36722_n4054.n0 a_36722_n4054.n4 3.3953
R18579 a_36722_n4054.n0 a_36722_n4054.n1 2.70724
R18580 a_36722_n4054.t0 a_36722_n4054.n0 2.47188
R18581 a_36722_n4054.n3 a_36722_n4054.n2 1.3073
R18582 a_36722_n3300.n0 a_36722_n3300.t2 86.4194
R18583 a_36722_n3300.n2 a_36722_n3300.t3 82.415
R18584 a_36722_n3300.n1 a_36722_n3300.t5 51.8534
R18585 a_36722_n3300.n0 a_36722_n3300.t4 51.8062
R18586 a_36722_n3300.n3 a_36722_n3300.t1 6.28457
R18587 a_36722_n3300.n2 a_36722_n3300.n1 4.1171
R18588 a_36722_n3300.n3 a_36722_n3300.n2 2.66254
R18589 a_36722_n3300.t0 a_36722_n3300.n3 2.21138
R18590 a_36722_n3300.n1 a_36722_n3300.n0 1.3775
R18591 a_74632_n3162.n1 a_74632_n3162.t4 75.0252
R18592 a_74632_n3162.n1 a_74632_n3162.t5 44.0697
R18593 a_74632_n3162.n2 a_74632_n3162.t2 10.6055
R18594 a_74632_n3162.n0 a_74632_n3162.t1 10.6055
R18595 a_74632_n3162.n2 a_74632_n3162.n0 8.89791
R18596 a_74632_n3162.n0 a_74632_n3162.n1 5.7951
R18597 a_74632_n3162.t0 a_74632_n3162.n2 4.53176
R18598 a_74632_n3162.n0 a_74632_n3162.t3 4.53041
R18599 SAR_Asynchronous_Logic_10/D_reset_FF_0.Q.n2 SAR_Asynchronous_Logic_10/D_reset_FF_0.Q.t3 74.8588
R18600 SAR_Asynchronous_Logic_10/D_reset_FF_0.Q.n3 SAR_Asynchronous_Logic_10/D_reset_FF_0.Q.t6 70.3153
R18601 SAR_Asynchronous_Logic_10/D_reset_FF_0.Q.n2 SAR_Asynchronous_Logic_10/D_reset_FF_0.Q.t4 44.2362
R18602 SAR_Asynchronous_Logic_10/D_reset_FF_0.Q.n3 SAR_Asynchronous_Logic_10/D_reset_FF_0.Q.t5 39.854
R18603 SAR_Asynchronous_Logic_10/D_reset_FF_0.Q.n4 SAR_Asynchronous_Logic_10/D_reset_FF_0.Q.n0 11.62
R18604 SAR_Asynchronous_Logic_10/D_reset_FF_0.Q.n0 SAR_Asynchronous_Logic_10/D_reset_FF_0.Q.n1 5.39574
R18605 SAR_Asynchronous_Logic_10/D_reset_FF_0.Q.n0 SAR_Asynchronous_Logic_10/D_reset_FF_0.Q.t1 4.91248
R18606 SAR_Asynchronous_Logic_10/D_reset_FF_0.Q.n1 SAR_Asynchronous_Logic_10/D_reset_FF_0.Q.t2 3.7821
R18607 SAR_Asynchronous_Logic_10/D_reset_FF_0.Q.n1 SAR_Asynchronous_Logic_10/D_reset_FF_0.Q.t0 3.77824
R18608 SAR_Asynchronous_Logic_10/D_reset_FF_0.Q.n0 SAR_Asynchronous_Logic_10/D_reset_FF_0.Q.n2 3.04286
R18609 SAR_Asynchronous_Logic_10/D_reset_FF_0.Q SAR_Asynchronous_Logic_10/D_reset_FF_0.Q.n4 2.86313
R18610 SAR_Asynchronous_Logic_10/D_reset_FF_0.Q.n4 SAR_Asynchronous_Logic_10/D_reset_FF_0.Q.n3 2.84345
R18611 Bit_4 Bit_4.n2 14.6284
R18612 Bit_4.n2 Bit_4.t2 12.5331
R18613 Bit_4.n1 Bit_4.t3 10.8182
R18614 Bit_4.n0 Bit_4.t1 3.00189
R18615 Bit_4.n0 Bit_4.t0 2.94188
R18616 Bit_4.n2 Bit_4.n1 2.2505
R18617 Bit_4.n1 Bit_4.n0 1.37321
R18618 SAR_Asynchronous_Logic_7/D_reset_FF_1.Q.n1 SAR_Asynchronous_Logic_7/D_reset_FF_1.Q.t10 74.8588
R18619 SAR_Asynchronous_Logic_7/D_reset_FF_1.Q.n3 SAR_Asynchronous_Logic_7/D_reset_FF_1.Q.t9 70.3153
R18620 SAR_Asynchronous_Logic_7/D_reset_FF_1.Q.n1 SAR_Asynchronous_Logic_7/D_reset_FF_1.Q.t11 44.2362
R18621 SAR_Asynchronous_Logic_7/D_reset_FF_1.Q.n3 SAR_Asynchronous_Logic_7/D_reset_FF_1.Q.t12 39.8548
R18622 SAR_Asynchronous_Logic_7/D_reset_FF_1.Q.n4 SAR_Asynchronous_Logic_7/D_reset_FF_1.Q.n0 11.62
R18623 SAR_Asynchronous_Logic_7/D_reset_FF_1.Q.n6 SAR_Asynchronous_Logic_7/D_reset_FF_1.Q.t0 11.0112
R18624 SAR_Asynchronous_Logic_7/D_reset_FF_1.Q.n7 SAR_Asynchronous_Logic_7/D_reset_FF_1.Q.t1 11.0112
R18625 SAR_Asynchronous_Logic_7/D_reset_FF_1.Q.n5 SAR_Asynchronous_Logic_7/D_reset_FF_1.Q.t4 11.0083
R18626 SAR_Asynchronous_Logic_7/D_reset_FF_1.Q.n9 SAR_Asynchronous_Logic_7/D_reset_FF_1.Q.n5 9.49928
R18627 SAR_Asynchronous_Logic_7/D_reset_FF_1.Q.n8 SAR_Asynchronous_Logic_7/D_reset_FF_1.Q.n6 7.28497
R18628 SAR_Asynchronous_Logic_7/D_reset_FF_1.Q.n8 SAR_Asynchronous_Logic_7/D_reset_FF_1.Q.n7 6.65722
R18629 SAR_Asynchronous_Logic_7/D_reset_FF_1.Q.n9 SAR_Asynchronous_Logic_7/D_reset_FF_1.Q.n8 5.53329
R18630 SAR_Asynchronous_Logic_7/D_reset_FF_1.Q.n0 SAR_Asynchronous_Logic_7/D_reset_FF_1.Q.n2 5.39574
R18631 SAR_Asynchronous_Logic_7/D_reset_FF_1.Q.n0 SAR_Asynchronous_Logic_7/D_reset_FF_1.Q.t6 4.91281
R18632 SAR_Asynchronous_Logic_7/D_reset_FF_1.Q SAR_Asynchronous_Logic_7/D_reset_FF_1.Q.n9 4.59604
R18633 SAR_Asynchronous_Logic_7/D_reset_FF_1.Q.n7 SAR_Asynchronous_Logic_7/D_reset_FF_1.Q.t3 4.12612
R18634 SAR_Asynchronous_Logic_7/D_reset_FF_1.Q.n6 SAR_Asynchronous_Logic_7/D_reset_FF_1.Q.t5 4.12478
R18635 SAR_Asynchronous_Logic_7/D_reset_FF_1.Q.n5 SAR_Asynchronous_Logic_7/D_reset_FF_1.Q.t8 4.12425
R18636 SAR_Asynchronous_Logic_7/D_reset_FF_1.Q.n2 SAR_Asynchronous_Logic_7/D_reset_FF_1.Q.t7 3.7821
R18637 SAR_Asynchronous_Logic_7/D_reset_FF_1.Q.n2 SAR_Asynchronous_Logic_7/D_reset_FF_1.Q.t2 3.77824
R18638 SAR_Asynchronous_Logic_7/D_reset_FF_1.Q.n0 SAR_Asynchronous_Logic_7/D_reset_FF_1.Q.n1 3.04186
R18639 SAR_Asynchronous_Logic_7/D_reset_FF_1.Q SAR_Asynchronous_Logic_7/D_reset_FF_1.Q.n4 2.86313
R18640 SAR_Asynchronous_Logic_7/D_reset_FF_1.Q.n4 SAR_Asynchronous_Logic_7/D_reset_FF_1.Q.n3 2.84345
R18641 SAR_Asynchronous_Logic_0/D_reset_FF_1.Q.n7 SAR_Asynchronous_Logic_0/D_reset_FF_1.Q.t10 74.8588
R18642 SAR_Asynchronous_Logic_0/D_reset_FF_1.Q.n8 SAR_Asynchronous_Logic_0/D_reset_FF_1.Q.t9 70.3153
R18643 SAR_Asynchronous_Logic_0/D_reset_FF_1.Q.n7 SAR_Asynchronous_Logic_0/D_reset_FF_1.Q.t12 44.2362
R18644 SAR_Asynchronous_Logic_0/D_reset_FF_1.Q.n8 SAR_Asynchronous_Logic_0/D_reset_FF_1.Q.t11 39.854
R18645 SAR_Asynchronous_Logic_0/D_reset_FF_1.Q.n9 SAR_Asynchronous_Logic_0/D_reset_FF_1.Q.n0 11.62
R18646 SAR_Asynchronous_Logic_0/D_reset_FF_1.Q.n2 SAR_Asynchronous_Logic_0/D_reset_FF_1.Q.t2 11.0112
R18647 SAR_Asynchronous_Logic_0/D_reset_FF_1.Q.n3 SAR_Asynchronous_Logic_0/D_reset_FF_1.Q.t3 11.0112
R18648 SAR_Asynchronous_Logic_0/D_reset_FF_1.Q.n1 SAR_Asynchronous_Logic_0/D_reset_FF_1.Q.t1 11.0083
R18649 SAR_Asynchronous_Logic_0/D_reset_FF_1.Q.n5 SAR_Asynchronous_Logic_0/D_reset_FF_1.Q.n1 9.49928
R18650 SAR_Asynchronous_Logic_0/D_reset_FF_1.Q.n4 SAR_Asynchronous_Logic_0/D_reset_FF_1.Q.n2 7.28497
R18651 SAR_Asynchronous_Logic_0/D_reset_FF_1.Q.n4 SAR_Asynchronous_Logic_0/D_reset_FF_1.Q.n3 6.65722
R18652 SAR_Asynchronous_Logic_0/D_reset_FF_1.Q.n5 SAR_Asynchronous_Logic_0/D_reset_FF_1.Q.n4 5.53329
R18653 SAR_Asynchronous_Logic_0/D_reset_FF_1.Q.n0 SAR_Asynchronous_Logic_0/D_reset_FF_1.Q.n6 5.39574
R18654 SAR_Asynchronous_Logic_0/D_reset_FF_1.Q.n0 SAR_Asynchronous_Logic_0/D_reset_FF_1.Q.t7 4.91248
R18655 SAR_Asynchronous_Logic_0/D_reset_FF_1.Q SAR_Asynchronous_Logic_0/D_reset_FF_1.Q.n5 4.59604
R18656 SAR_Asynchronous_Logic_0/D_reset_FF_1.Q.n1 SAR_Asynchronous_Logic_0/D_reset_FF_1.Q.t4 4.12501
R18657 SAR_Asynchronous_Logic_0/D_reset_FF_1.Q.n2 SAR_Asynchronous_Logic_0/D_reset_FF_1.Q.t5 4.12461
R18658 SAR_Asynchronous_Logic_0/D_reset_FF_1.Q.n3 SAR_Asynchronous_Logic_0/D_reset_FF_1.Q.t8 4.12461
R18659 SAR_Asynchronous_Logic_0/D_reset_FF_1.Q.n6 SAR_Asynchronous_Logic_0/D_reset_FF_1.Q.t6 3.7821
R18660 SAR_Asynchronous_Logic_0/D_reset_FF_1.Q.n6 SAR_Asynchronous_Logic_0/D_reset_FF_1.Q.t0 3.77824
R18661 SAR_Asynchronous_Logic_0/D_reset_FF_1.Q.n0 SAR_Asynchronous_Logic_0/D_reset_FF_1.Q.n7 3.04286
R18662 SAR_Asynchronous_Logic_0/D_reset_FF_1.Q SAR_Asynchronous_Logic_0/D_reset_FF_1.Q.n9 2.86313
R18663 SAR_Asynchronous_Logic_0/D_reset_FF_1.Q.n9 SAR_Asynchronous_Logic_0/D_reset_FF_1.Q.n8 2.84345
R18664 Bit_3 Bit_3.n2 14.6329
R18665 Bit_3.n2 Bit_3.t1 12.5331
R18666 Bit_3.n1 Bit_3.t0 10.8182
R18667 Bit_3.n0 Bit_3.t2 3.00189
R18668 Bit_3.n0 Bit_3.t3 2.94188
R18669 Bit_3.n2 Bit_3.n1 2.2505
R18670 Bit_3.n1 Bit_3.n0 1.37321
R18671 a_76732_n13054.n1 a_76732_n13054.t5 75.0252
R18672 a_76732_n13054.n1 a_76732_n13054.t4 44.0697
R18673 a_76732_n13054.n2 a_76732_n13054.t1 10.6055
R18674 a_76732_n13054.n0 a_76732_n13054.t3 10.6055
R18675 a_76732_n13054.n0 a_76732_n13054.n2 8.89791
R18676 a_76732_n13054.n0 a_76732_n13054.n1 5.7951
R18677 a_76732_n13054.t0 a_76732_n13054.n0 4.53176
R18678 a_76732_n13054.n2 a_76732_n13054.t2 4.53041
R18679 a_75442_n14314.n0 a_75442_n14314.t5 74.8588
R18680 a_75442_n14314.n0 a_75442_n14314.t6 44.2362
R18681 a_75442_n14314.n0 a_75442_n14314.n2 14.5242
R18682 a_75442_n14314.n2 a_75442_n14314.t0 11.0089
R18683 a_75442_n14314.n3 a_75442_n14314.n1 5.39574
R18684 a_75442_n14314.t1 a_75442_n14314.n3 4.91281
R18685 a_75442_n14314.n2 a_75442_n14314.t3 4.12461
R18686 a_75442_n14314.n1 a_75442_n14314.t2 3.7821
R18687 a_75442_n14314.n1 a_75442_n14314.t4 3.77824
R18688 a_75442_n14314.n3 a_75442_n14314.n0 1.83141
R18689 a_99902_n82.n2 a_99902_n82.t2 82.7757
R18690 a_99902_n82.n3 a_99902_n82.t4 82.6424
R18691 a_99902_n82.n1 a_99902_n82.t3 70.3153
R18692 a_99902_n82.n2 a_99902_n82.t7 55.8264
R18693 a_99902_n82.n4 a_99902_n82.t6 51.5658
R18694 a_99902_n82.n1 a_99902_n82.t5 39.854
R18695 a_99902_n82.n0 a_99902_n82.t1 6.02308
R18696 a_99902_n82.n4 a_99902_n82.n3 3.9695
R18697 a_99902_n82.n0 a_99902_n82.n4 3.3953
R18698 a_99902_n82.n0 a_99902_n82.n1 2.70724
R18699 a_99902_n82.t0 a_99902_n82.n0 2.47208
R18700 a_99902_n82.n3 a_99902_n82.n2 1.3073
R18701 a_102950_n314.n0 a_102950_n314.t5 74.8588
R18702 a_102950_n314.n0 a_102950_n314.t6 44.2362
R18703 a_102950_n314.n3 a_102950_n314.n0 14.5242
R18704 a_102950_n314.n3 a_102950_n314.t2 11.0089
R18705 a_102950_n314.n2 a_102950_n314.n1 5.39574
R18706 a_102950_n314.n2 a_102950_n314.t3 4.91248
R18707 a_102950_n314.t0 a_102950_n314.n3 4.12612
R18708 a_102950_n314.n1 a_102950_n314.t1 3.7821
R18709 a_102950_n314.n1 a_102950_n314.t4 3.77824
R18710 a_102950_n314.n0 a_102950_n314.n2 1.83141
R18711 SAR_Asynchronous_Logic_3/D_reset_FF_0.Q.n1 SAR_Asynchronous_Logic_3/D_reset_FF_0.Q.t6 74.8588
R18712 SAR_Asynchronous_Logic_3/D_reset_FF_0.Q.n3 SAR_Asynchronous_Logic_3/D_reset_FF_0.Q.t5 70.3153
R18713 SAR_Asynchronous_Logic_3/D_reset_FF_0.Q.n1 SAR_Asynchronous_Logic_3/D_reset_FF_0.Q.t3 44.2362
R18714 SAR_Asynchronous_Logic_3/D_reset_FF_0.Q.n3 SAR_Asynchronous_Logic_3/D_reset_FF_0.Q.t4 39.8548
R18715 SAR_Asynchronous_Logic_3/D_reset_FF_0.Q.n4 SAR_Asynchronous_Logic_3/D_reset_FF_0.Q.n0 11.62
R18716 SAR_Asynchronous_Logic_3/D_reset_FF_0.Q.n0 SAR_Asynchronous_Logic_3/D_reset_FF_0.Q.n2 5.39574
R18717 SAR_Asynchronous_Logic_3/D_reset_FF_0.Q.n0 SAR_Asynchronous_Logic_3/D_reset_FF_0.Q.t1 4.91281
R18718 SAR_Asynchronous_Logic_3/D_reset_FF_0.Q.n2 SAR_Asynchronous_Logic_3/D_reset_FF_0.Q.t2 3.7821
R18719 SAR_Asynchronous_Logic_3/D_reset_FF_0.Q.n2 SAR_Asynchronous_Logic_3/D_reset_FF_0.Q.t0 3.77824
R18720 SAR_Asynchronous_Logic_3/D_reset_FF_0.Q.n0 SAR_Asynchronous_Logic_3/D_reset_FF_0.Q.n1 3.04186
R18721 SAR_Asynchronous_Logic_3/D_reset_FF_0.Q SAR_Asynchronous_Logic_3/D_reset_FF_0.Q.n4 2.86313
R18722 SAR_Asynchronous_Logic_3/D_reset_FF_0.Q.n4 SAR_Asynchronous_Logic_3/D_reset_FF_0.Q.n3 2.84345
R18723 a_102822_n13192.n0 a_102822_n13192.t2 86.4194
R18724 a_102822_n13192.n2 a_102822_n13192.t5 82.415
R18725 a_102822_n13192.n1 a_102822_n13192.t4 51.8534
R18726 a_102822_n13192.n0 a_102822_n13192.t3 51.8062
R18727 a_102822_n13192.n3 a_102822_n13192.t1 6.28457
R18728 a_102822_n13192.n2 a_102822_n13192.n1 4.1171
R18729 a_102822_n13192.n3 a_102822_n13192.n2 2.66254
R18730 a_102822_n13192.t0 a_102822_n13192.n3 2.21138
R18731 a_102822_n13192.n1 a_102822_n13192.n0 1.3775
R18732 a_38822_n13946.n2 a_38822_n13946.t2 82.7757
R18733 a_38822_n13946.n3 a_38822_n13946.t4 82.6414
R18734 a_38822_n13946.n1 a_38822_n13946.t7 70.3153
R18735 a_38822_n13946.n2 a_38822_n13946.t5 55.8254
R18736 a_38822_n13946.n4 a_38822_n13946.t3 51.5648
R18737 a_38822_n13946.n1 a_38822_n13946.t6 39.8548
R18738 a_38822_n13946.n0 a_38822_n13946.t0 6.02308
R18739 a_38822_n13946.n4 a_38822_n13946.n3 3.9695
R18740 a_38822_n13946.n0 a_38822_n13946.n4 3.3953
R18741 a_38822_n13946.n0 a_38822_n13946.n1 2.70724
R18742 a_38822_n13946.t1 a_38822_n13946.n0 2.47188
R18743 a_38822_n13946.n3 a_38822_n13946.n2 1.3073
R18744 a_43442_n14314.n0 a_43442_n14314.t6 74.8588
R18745 a_43442_n14314.n0 a_43442_n14314.t5 44.2362
R18746 a_43442_n14314.n3 a_43442_n14314.n0 14.5242
R18747 a_43442_n14314.n3 a_43442_n14314.t3 11.0089
R18748 a_43442_n14314.n2 a_43442_n14314.n1 5.39574
R18749 a_43442_n14314.n2 a_43442_n14314.t2 4.91281
R18750 a_43442_n14314.t0 a_43442_n14314.n3 4.12554
R18751 a_43442_n14314.n1 a_43442_n14314.t1 3.7821
R18752 a_43442_n14314.n1 a_43442_n14314.t4 3.77824
R18753 a_43442_n14314.n0 a_43442_n14314.n2 1.83141
R18754 a_n25050_n314.n0 a_n25050_n314.t6 74.8588
R18755 a_n25050_n314.n0 a_n25050_n314.t5 44.2362
R18756 a_n25050_n314.n0 a_n25050_n314.n2 14.5242
R18757 a_n25050_n314.n2 a_n25050_n314.t2 11.0089
R18758 a_n25050_n314.n3 a_n25050_n314.n1 5.39574
R18759 a_n25050_n314.t0 a_n25050_n314.n3 4.91248
R18760 a_n25050_n314.n2 a_n25050_n314.t3 4.12478
R18761 a_n25050_n314.n1 a_n25050_n314.t1 3.7821
R18762 a_n25050_n314.n1 a_n25050_n314.t4 3.77824
R18763 a_n25050_n314.n3 a_n25050_n314.n0 1.83141
R18764 a_136066_n18422.n1 a_136066_n18422.t5 75.0252
R18765 a_136066_n18422.n1 a_136066_n18422.t4 44.0697
R18766 a_136066_n18422.n2 a_136066_n18422.t0 10.6055
R18767 a_136066_n18422.n0 a_136066_n18422.t2 10.6055
R18768 a_136066_n18422.n2 a_136066_n18422.n0 8.89791
R18769 a_136066_n18422.n0 a_136066_n18422.n1 5.7951
R18770 a_136066_n18422.t1 a_136066_n18422.n2 4.53117
R18771 a_136066_n18422.n0 a_136066_n18422.t3 4.53024
R18772 a_137050_n18422.n0 a_137050_n18422.t5 74.8588
R18773 a_137050_n18422.n0 a_137050_n18422.t6 44.2362
R18774 a_137050_n18422.n0 a_137050_n18422.n2 14.5242
R18775 a_137050_n18422.n2 a_137050_n18422.t3 11.0089
R18776 a_137050_n18422.n3 a_137050_n18422.n1 5.39574
R18777 a_137050_n18422.t1 a_137050_n18422.n3 4.91248
R18778 a_137050_n18422.n2 a_137050_n18422.t2 4.12478
R18779 a_137050_n18422.n1 a_137050_n18422.t0 3.7821
R18780 a_137050_n18422.n1 a_137050_n18422.t4 3.77824
R18781 a_137050_n18422.n3 a_137050_n18422.n0 1.83141
R18782 a_134890_n14314.n1 a_134890_n14314.t1 11.0089
R18783 a_134890_n14314.n2 a_134890_n14314.n1 7.28488
R18784 a_134890_n14314.n2 a_134890_n14314.n0 5.39574
R18785 a_134890_n14314.t2 a_134890_n14314.n2 4.91281
R18786 a_134890_n14314.n1 a_134890_n14314.t4 4.12461
R18787 a_134890_n14314.n0 a_134890_n14314.t3 3.7821
R18788 a_134890_n14314.n0 a_134890_n14314.t0 3.77824
R18789 a_70822_n13192.n0 a_70822_n13192.t2 86.4194
R18790 a_70822_n13192.n2 a_70822_n13192.t5 82.415
R18791 a_70822_n13192.n1 a_70822_n13192.t4 51.8534
R18792 a_70822_n13192.n0 a_70822_n13192.t3 51.8062
R18793 a_70822_n13192.n3 a_70822_n13192.t1 6.28457
R18794 a_70822_n13192.n2 a_70822_n13192.n1 4.1171
R18795 a_70822_n13192.n3 a_70822_n13192.n2 2.66254
R18796 a_70822_n13192.t0 a_70822_n13192.n3 2.21138
R18797 a_70822_n13192.n1 a_70822_n13192.n0 1.3775
R18798 SAR_Asynchronous_Logic_9/D_reset_FF_1.Q.n7 SAR_Asynchronous_Logic_9/D_reset_FF_1.Q.t12 74.8588
R18799 SAR_Asynchronous_Logic_9/D_reset_FF_1.Q.n8 SAR_Asynchronous_Logic_9/D_reset_FF_1.Q.t9 70.3153
R18800 SAR_Asynchronous_Logic_9/D_reset_FF_1.Q.n7 SAR_Asynchronous_Logic_9/D_reset_FF_1.Q.t11 44.2362
R18801 SAR_Asynchronous_Logic_9/D_reset_FF_1.Q.n8 SAR_Asynchronous_Logic_9/D_reset_FF_1.Q.t10 39.854
R18802 SAR_Asynchronous_Logic_9/D_reset_FF_1.Q.n9 SAR_Asynchronous_Logic_9/D_reset_FF_1.Q.n0 11.62
R18803 SAR_Asynchronous_Logic_9/D_reset_FF_1.Q.n2 SAR_Asynchronous_Logic_9/D_reset_FF_1.Q.t7 11.0112
R18804 SAR_Asynchronous_Logic_9/D_reset_FF_1.Q.n3 SAR_Asynchronous_Logic_9/D_reset_FF_1.Q.t8 11.0112
R18805 SAR_Asynchronous_Logic_9/D_reset_FF_1.Q.n1 SAR_Asynchronous_Logic_9/D_reset_FF_1.Q.t2 11.0083
R18806 SAR_Asynchronous_Logic_9/D_reset_FF_1.Q.n5 SAR_Asynchronous_Logic_9/D_reset_FF_1.Q.n1 9.49928
R18807 SAR_Asynchronous_Logic_9/D_reset_FF_1.Q.n4 SAR_Asynchronous_Logic_9/D_reset_FF_1.Q.n2 7.28497
R18808 SAR_Asynchronous_Logic_9/D_reset_FF_1.Q.n4 SAR_Asynchronous_Logic_9/D_reset_FF_1.Q.n3 6.65722
R18809 SAR_Asynchronous_Logic_9/D_reset_FF_1.Q.n5 SAR_Asynchronous_Logic_9/D_reset_FF_1.Q.n4 5.53329
R18810 SAR_Asynchronous_Logic_9/D_reset_FF_1.Q.n0 SAR_Asynchronous_Logic_9/D_reset_FF_1.Q.n6 5.39574
R18811 SAR_Asynchronous_Logic_9/D_reset_FF_1.Q.n0 SAR_Asynchronous_Logic_9/D_reset_FF_1.Q.t1 4.91248
R18812 SAR_Asynchronous_Logic_9/D_reset_FF_1.Q SAR_Asynchronous_Logic_9/D_reset_FF_1.Q.n5 4.59604
R18813 SAR_Asynchronous_Logic_9/D_reset_FF_1.Q.n2 SAR_Asynchronous_Logic_9/D_reset_FF_1.Q.t3 4.12461
R18814 SAR_Asynchronous_Logic_9/D_reset_FF_1.Q.n3 SAR_Asynchronous_Logic_9/D_reset_FF_1.Q.t4 4.12461
R18815 SAR_Asynchronous_Logic_9/D_reset_FF_1.Q.n1 SAR_Asynchronous_Logic_9/D_reset_FF_1.Q.t6 4.12408
R18816 SAR_Asynchronous_Logic_9/D_reset_FF_1.Q.n6 SAR_Asynchronous_Logic_9/D_reset_FF_1.Q.t0 3.7821
R18817 SAR_Asynchronous_Logic_9/D_reset_FF_1.Q.n6 SAR_Asynchronous_Logic_9/D_reset_FF_1.Q.t5 3.77824
R18818 SAR_Asynchronous_Logic_9/D_reset_FF_1.Q.n0 SAR_Asynchronous_Logic_9/D_reset_FF_1.Q.n7 3.04286
R18819 SAR_Asynchronous_Logic_9/D_reset_FF_1.Q SAR_Asynchronous_Logic_9/D_reset_FF_1.Q.n9 2.86313
R18820 SAR_Asynchronous_Logic_9/D_reset_FF_1.Q.n9 SAR_Asynchronous_Logic_9/D_reset_FF_1.Q.n8 2.84345
R18821 a_134822_n18190.n0 a_134822_n18190.t2 86.4194
R18822 a_134822_n18190.n2 a_134822_n18190.t4 82.416
R18823 a_134822_n18190.n1 a_134822_n18190.t5 51.8544
R18824 a_134822_n18190.n0 a_134822_n18190.t3 51.8072
R18825 a_134822_n18190.n3 a_134822_n18190.t0 6.28457
R18826 a_134822_n18190.n2 a_134822_n18190.n1 4.1171
R18827 a_134822_n18190.n3 a_134822_n18190.n2 2.66253
R18828 a_134822_n18190.t1 a_134822_n18190.n3 2.21122
R18829 a_134822_n18190.n1 a_134822_n18190.n0 1.3775
R18830 a_142134_n18422.n1 a_142134_n18422.t4 75.0252
R18831 a_142134_n18422.n1 a_142134_n18422.t5 44.0697
R18832 a_142134_n18422.n0 a_142134_n18422.t1 11.0112
R18833 a_142134_n18422.n3 a_142134_n18422.t3 10.6055
R18834 a_142134_n18422.n3 a_142134_n18422.n2 9.81776
R18835 a_142134_n18422.n2 a_142134_n18422.n1 5.81441
R18836 a_142134_n18422.n2 a_142134_n18422.n0 4.64798
R18837 a_142134_n18422.t0 a_142134_n18422.n3 4.53117
R18838 a_142134_n18422.n0 a_142134_n18422.t2 4.12461
R18839 a_38002_n18190.n2 a_38002_n18190.t7 82.7757
R18840 a_38002_n18190.n3 a_38002_n18190.t5 82.6424
R18841 a_38002_n18190.n1 a_38002_n18190.t3 70.3153
R18842 a_38002_n18190.n2 a_38002_n18190.t6 55.8264
R18843 a_38002_n18190.n4 a_38002_n18190.t4 51.5658
R18844 a_38002_n18190.n1 a_38002_n18190.t2 39.854
R18845 a_38002_n18190.n0 a_38002_n18190.t1 6.02308
R18846 a_38002_n18190.n4 a_38002_n18190.n3 3.9695
R18847 a_38002_n18190.n0 a_38002_n18190.n4 3.3953
R18848 a_38002_n18190.n0 a_38002_n18190.n1 2.70724
R18849 a_38002_n18190.t0 a_38002_n18190.n0 2.47208
R18850 a_38002_n18190.n3 a_38002_n18190.n2 1.3073
R18851 a_128736_n13850.n3 a_128736_n13850.t3 81.0083
R18852 a_128736_n13850.n3 a_128736_n13850.t2 80.9469
R18853 a_128736_n13850.n2 a_128736_n13850.t7 70.3153
R18854 a_128736_n13850.n0 a_128736_n13850.t4 54.8876
R18855 a_128736_n13850.n2 a_128736_n13850.t6 39.8548
R18856 a_128736_n13850.n0 a_128736_n13850.t5 16.7884
R18857 a_128736_n13850.n1 a_128736_n13850.n0 9.8148
R18858 a_128736_n13850.n1 a_128736_n13850.t0 5.96645
R18859 a_128736_n13850.n1 a_128736_n13850.n2 2.6989
R18860 a_128736_n13850.t1 a_128736_n13850.n1 2.52922
R18861 a_128736_n13850.n0 a_128736_n13850.n3 1.30877
R18862 SAR_Asynchronous_Logic_10/D_reset_FF_1.Q.n1 SAR_Asynchronous_Logic_10/D_reset_FF_1.Q.t9 74.8588
R18863 SAR_Asynchronous_Logic_10/D_reset_FF_1.Q.n3 SAR_Asynchronous_Logic_10/D_reset_FF_1.Q.t12 70.3153
R18864 SAR_Asynchronous_Logic_10/D_reset_FF_1.Q.n1 SAR_Asynchronous_Logic_10/D_reset_FF_1.Q.t10 44.2362
R18865 SAR_Asynchronous_Logic_10/D_reset_FF_1.Q.n3 SAR_Asynchronous_Logic_10/D_reset_FF_1.Q.t11 39.8548
R18866 SAR_Asynchronous_Logic_10/D_reset_FF_1.Q.n4 SAR_Asynchronous_Logic_10/D_reset_FF_1.Q.n0 11.62
R18867 SAR_Asynchronous_Logic_10/D_reset_FF_1.Q.n7 SAR_Asynchronous_Logic_10/D_reset_FF_1.Q.t8 11.0112
R18868 SAR_Asynchronous_Logic_10/D_reset_FF_1.Q.n6 SAR_Asynchronous_Logic_10/D_reset_FF_1.Q.t0 11.0112
R18869 SAR_Asynchronous_Logic_10/D_reset_FF_1.Q.n5 SAR_Asynchronous_Logic_10/D_reset_FF_1.Q.t7 11.0083
R18870 SAR_Asynchronous_Logic_10/D_reset_FF_1.Q.n9 SAR_Asynchronous_Logic_10/D_reset_FF_1.Q.n5 9.49928
R18871 SAR_Asynchronous_Logic_10/D_reset_FF_1.Q.n8 SAR_Asynchronous_Logic_10/D_reset_FF_1.Q.n6 7.28497
R18872 SAR_Asynchronous_Logic_10/D_reset_FF_1.Q.n8 SAR_Asynchronous_Logic_10/D_reset_FF_1.Q.n7 6.65722
R18873 SAR_Asynchronous_Logic_10/D_reset_FF_1.Q.n9 SAR_Asynchronous_Logic_10/D_reset_FF_1.Q.n8 5.53329
R18874 SAR_Asynchronous_Logic_10/D_reset_FF_1.Q.n0 SAR_Asynchronous_Logic_10/D_reset_FF_1.Q.n2 5.39574
R18875 SAR_Asynchronous_Logic_10/D_reset_FF_1.Q.n0 SAR_Asynchronous_Logic_10/D_reset_FF_1.Q.t4 4.91281
R18876 SAR_Asynchronous_Logic_10/D_reset_FF_1.Q SAR_Asynchronous_Logic_10/D_reset_FF_1.Q.n9 4.59604
R18877 SAR_Asynchronous_Logic_10/D_reset_FF_1.Q.n6 SAR_Asynchronous_Logic_10/D_reset_FF_1.Q.t1 4.12612
R18878 SAR_Asynchronous_Logic_10/D_reset_FF_1.Q.n7 SAR_Asynchronous_Logic_10/D_reset_FF_1.Q.t2 4.12478
R18879 SAR_Asynchronous_Logic_10/D_reset_FF_1.Q.n5 SAR_Asynchronous_Logic_10/D_reset_FF_1.Q.t6 4.12425
R18880 SAR_Asynchronous_Logic_10/D_reset_FF_1.Q.n2 SAR_Asynchronous_Logic_10/D_reset_FF_1.Q.t3 3.7821
R18881 SAR_Asynchronous_Logic_10/D_reset_FF_1.Q.n2 SAR_Asynchronous_Logic_10/D_reset_FF_1.Q.t5 3.77824
R18882 SAR_Asynchronous_Logic_10/D_reset_FF_1.Q.n0 SAR_Asynchronous_Logic_10/D_reset_FF_1.Q.n1 3.04186
R18883 SAR_Asynchronous_Logic_10/D_reset_FF_1.Q SAR_Asynchronous_Logic_10/D_reset_FF_1.Q.n4 2.86313
R18884 SAR_Asynchronous_Logic_10/D_reset_FF_1.Q.n4 SAR_Asynchronous_Logic_10/D_reset_FF_1.Q.n3 2.84345
R18885 a_100722_n82.n0 a_100722_n82.t5 86.4194
R18886 a_100722_n82.n2 a_100722_n82.t3 82.416
R18887 a_100722_n82.n1 a_100722_n82.t4 51.8544
R18888 a_100722_n82.n0 a_100722_n82.t2 51.8072
R18889 a_100722_n82.n3 a_100722_n82.t1 6.28457
R18890 a_100722_n82.n2 a_100722_n82.n1 4.1171
R18891 a_100722_n82.n3 a_100722_n82.n2 2.66253
R18892 a_100722_n82.t0 a_100722_n82.n3 2.21122
R18893 a_100722_n82.n1 a_100722_n82.n0 1.3775
R18894 a_36722_n82.n0 a_36722_n82.t3 86.4194
R18895 a_36722_n82.n2 a_36722_n82.t5 82.416
R18896 a_36722_n82.n1 a_36722_n82.t2 51.8544
R18897 a_36722_n82.n0 a_36722_n82.t4 51.8072
R18898 a_36722_n82.n3 a_36722_n82.t1 6.28457
R18899 a_36722_n82.n2 a_36722_n82.n1 4.1171
R18900 a_36722_n82.n3 a_36722_n82.n2 2.66253
R18901 a_36722_n82.t0 a_36722_n82.n3 2.21122
R18902 a_36722_n82.n1 a_36722_n82.n0 1.3775
R18903 a_40578_n314.n1 a_40578_n314.t4 11.0083
R18904 a_40578_n314.n2 a_40578_n314.n1 7.51324
R18905 a_40578_n314.n2 a_40578_n314.n0 5.39574
R18906 a_40578_n314.t1 a_40578_n314.n2 4.91248
R18907 a_40578_n314.n1 a_40578_n314.t2 4.12425
R18908 a_40578_n314.n0 a_40578_n314.t0 3.7821
R18909 a_40578_n314.n0 a_40578_n314.t3 3.77824
R18910 a_37966_n314.n1 a_37966_n314.t5 75.0252
R18911 a_37966_n314.n1 a_37966_n314.t4 44.0697
R18912 a_37966_n314.n2 a_37966_n314.t2 10.6055
R18913 a_37966_n314.n0 a_37966_n314.t0 10.6055
R18914 a_37966_n314.n2 a_37966_n314.n0 8.89791
R18915 a_37966_n314.n0 a_37966_n314.n1 5.7951
R18916 a_37966_n314.t1 a_37966_n314.n2 4.53117
R18917 a_37966_n314.n0 a_37966_n314.t3 4.53024
R18918 a_4722_n4054.n2 a_4722_n4054.t4 82.7757
R18919 a_4722_n4054.n3 a_4722_n4054.t6 82.6414
R18920 a_4722_n4054.n1 a_4722_n4054.t5 70.3153
R18921 a_4722_n4054.n2 a_4722_n4054.t2 55.8254
R18922 a_4722_n4054.n4 a_4722_n4054.t7 51.5648
R18923 a_4722_n4054.n1 a_4722_n4054.t3 39.8548
R18924 a_4722_n4054.n0 a_4722_n4054.t1 6.02308
R18925 a_4722_n4054.n4 a_4722_n4054.n3 3.9695
R18926 a_4722_n4054.n0 a_4722_n4054.n4 3.3953
R18927 a_4722_n4054.n0 a_4722_n4054.n1 2.70724
R18928 a_4722_n4054.t0 a_4722_n4054.n0 2.47188
R18929 a_4722_n4054.n3 a_4722_n4054.n2 1.3073
R18930 a_4604_n3162.n1 a_4604_n3162.t4 75.0252
R18931 a_4604_n3162.n1 a_4604_n3162.t5 44.0697
R18932 a_4604_n3162.n3 a_4604_n3162.t3 11.0112
R18933 a_4604_n3162.n0 a_4604_n3162.t0 10.6055
R18934 a_4604_n3162.n2 a_4604_n3162.n0 9.81776
R18935 a_4604_n3162.n2 a_4604_n3162.n1 5.81341
R18936 a_4604_n3162.n3 a_4604_n3162.n2 4.64798
R18937 a_4604_n3162.n0 a_4604_n3162.t2 4.53041
R18938 a_4604_n3162.t1 a_4604_n3162.n3 4.12612
R18939 Bit_5 Bit_5.n2 21.8158
R18940 Bit_5.n2 Bit_5.t0 12.5331
R18941 Bit_5.n1 Bit_5.t2 10.8182
R18942 Bit_5.n0 Bit_5.t3 3.00172
R18943 Bit_5.n0 Bit_5.t1 2.94206
R18944 Bit_5.n2 Bit_5.n1 2.2505
R18945 Bit_5.n1 Bit_5.n0 1.37321
R18946 a_132790_n4422.n2 a_132790_n4422.t1 11.0089
R18947 a_132790_n4422.n2 a_132790_n4422.n1 7.28488
R18948 a_132790_n4422.n1 a_132790_n4422.n0 5.39574
R18949 a_132790_n4422.n1 a_132790_n4422.t3 4.91281
R18950 a_132790_n4422.t2 a_132790_n4422.n2 4.12554
R18951 a_132790_n4422.n0 a_132790_n4422.t4 3.7821
R18952 a_132790_n4422.n0 a_132790_n4422.t0 3.77824
R18953 a_134002_n18190.n2 a_134002_n18190.t2 82.7757
R18954 a_134002_n18190.n3 a_134002_n18190.t6 82.6424
R18955 a_134002_n18190.n1 a_134002_n18190.t5 70.3153
R18956 a_134002_n18190.n2 a_134002_n18190.t3 55.8264
R18957 a_134002_n18190.n4 a_134002_n18190.t7 51.5658
R18958 a_134002_n18190.n1 a_134002_n18190.t4 39.854
R18959 a_134002_n18190.n0 a_134002_n18190.t1 6.02308
R18960 a_134002_n18190.n4 a_134002_n18190.n3 3.9695
R18961 a_134002_n18190.n0 a_134002_n18190.n4 3.3953
R18962 a_134002_n18190.n0 a_134002_n18190.n1 2.70724
R18963 a_134002_n18190.t0 a_134002_n18190.n0 2.47208
R18964 a_134002_n18190.n3 a_134002_n18190.n2 1.3073
R18965 a_9050_n18422.n0 a_9050_n18422.t5 74.8588
R18966 a_9050_n18422.n0 a_9050_n18422.t6 44.2362
R18967 a_9050_n18422.n3 a_9050_n18422.n0 14.5242
R18968 a_9050_n18422.n3 a_9050_n18422.t3 11.0089
R18969 a_9050_n18422.n2 a_9050_n18422.n1 5.39574
R18970 a_9050_n18422.n2 a_9050_n18422.t1 4.91248
R18971 a_9050_n18422.t0 a_9050_n18422.n3 4.12612
R18972 a_9050_n18422.n1 a_9050_n18422.t2 3.7821
R18973 a_9050_n18422.n1 a_9050_n18422.t4 3.77824
R18974 a_9050_n18422.n0 a_9050_n18422.n2 1.83141
R18975 CK_7.n0 CK_7.t0 70.3153
R18976 CK_7.n0 CK_7.t1 39.854
R18977 CK_7 CK_7.n0 18.4679
R18978 a_6890_n14314.n2 a_6890_n14314.t1 11.0089
R18979 a_6890_n14314.n2 a_6890_n14314.n1 7.28488
R18980 a_6890_n14314.n1 a_6890_n14314.n0 5.39574
R18981 a_6890_n14314.n1 a_6890_n14314.t3 4.91281
R18982 a_6890_n14314.t2 a_6890_n14314.n2 4.12554
R18983 a_6890_n14314.n0 a_6890_n14314.t4 3.7821
R18984 a_6890_n14314.n0 a_6890_n14314.t0 3.77824
R18985 Bit_7 Bit_7.n2 21.8158
R18986 Bit_7.n2 Bit_7.t1 12.5331
R18987 Bit_7.n1 Bit_7.t0 10.8182
R18988 Bit_7.n0 Bit_7.t3 3.00172
R18989 Bit_7.n0 Bit_7.t2 2.94206
R18990 Bit_7.n2 Bit_7.n1 2.2505
R18991 Bit_7.n1 Bit_7.n0 1.37321
R18992 SAR_Asynchronous_Logic_5/D_reset_FF_0.Q.n1 SAR_Asynchronous_Logic_5/D_reset_FF_0.Q.t4 74.8588
R18993 SAR_Asynchronous_Logic_5/D_reset_FF_0.Q.n3 SAR_Asynchronous_Logic_5/D_reset_FF_0.Q.t5 70.3153
R18994 SAR_Asynchronous_Logic_5/D_reset_FF_0.Q.n1 SAR_Asynchronous_Logic_5/D_reset_FF_0.Q.t6 44.2362
R18995 SAR_Asynchronous_Logic_5/D_reset_FF_0.Q.n3 SAR_Asynchronous_Logic_5/D_reset_FF_0.Q.t3 39.8548
R18996 SAR_Asynchronous_Logic_5/D_reset_FF_0.Q.n4 SAR_Asynchronous_Logic_5/D_reset_FF_0.Q.n0 11.62
R18997 SAR_Asynchronous_Logic_5/D_reset_FF_0.Q.n0 SAR_Asynchronous_Logic_5/D_reset_FF_0.Q.n2 5.39574
R18998 SAR_Asynchronous_Logic_5/D_reset_FF_0.Q.n0 SAR_Asynchronous_Logic_5/D_reset_FF_0.Q.t1 4.91281
R18999 SAR_Asynchronous_Logic_5/D_reset_FF_0.Q.n2 SAR_Asynchronous_Logic_5/D_reset_FF_0.Q.t2 3.7821
R19000 SAR_Asynchronous_Logic_5/D_reset_FF_0.Q.n2 SAR_Asynchronous_Logic_5/D_reset_FF_0.Q.t0 3.77824
R19001 SAR_Asynchronous_Logic_5/D_reset_FF_0.Q.n0 SAR_Asynchronous_Logic_5/D_reset_FF_0.Q.n1 3.04186
R19002 SAR_Asynchronous_Logic_5/D_reset_FF_0.Q SAR_Asynchronous_Logic_5/D_reset_FF_0.Q.n4 2.86313
R19003 SAR_Asynchronous_Logic_5/D_reset_FF_0.Q.n4 SAR_Asynchronous_Logic_5/D_reset_FF_0.Q.n3 2.84345
R19004 SAR_Asynchronous_Logic_4/D_reset_FF_0.Q.n2 SAR_Asynchronous_Logic_4/D_reset_FF_0.Q.t5 74.8588
R19005 SAR_Asynchronous_Logic_4/D_reset_FF_0.Q.n3 SAR_Asynchronous_Logic_4/D_reset_FF_0.Q.t4 70.3153
R19006 SAR_Asynchronous_Logic_4/D_reset_FF_0.Q.n2 SAR_Asynchronous_Logic_4/D_reset_FF_0.Q.t6 44.2362
R19007 SAR_Asynchronous_Logic_4/D_reset_FF_0.Q.n3 SAR_Asynchronous_Logic_4/D_reset_FF_0.Q.t3 39.854
R19008 SAR_Asynchronous_Logic_4/D_reset_FF_0.Q.n4 SAR_Asynchronous_Logic_4/D_reset_FF_0.Q.n0 11.62
R19009 SAR_Asynchronous_Logic_4/D_reset_FF_0.Q.n0 SAR_Asynchronous_Logic_4/D_reset_FF_0.Q.n1 5.39574
R19010 SAR_Asynchronous_Logic_4/D_reset_FF_0.Q.n0 SAR_Asynchronous_Logic_4/D_reset_FF_0.Q.t1 4.91248
R19011 SAR_Asynchronous_Logic_4/D_reset_FF_0.Q.n1 SAR_Asynchronous_Logic_4/D_reset_FF_0.Q.t2 3.7821
R19012 SAR_Asynchronous_Logic_4/D_reset_FF_0.Q.n1 SAR_Asynchronous_Logic_4/D_reset_FF_0.Q.t0 3.77824
R19013 SAR_Asynchronous_Logic_4/D_reset_FF_0.Q.n0 SAR_Asynchronous_Logic_4/D_reset_FF_0.Q.n2 3.04286
R19014 SAR_Asynchronous_Logic_4/D_reset_FF_0.Q SAR_Asynchronous_Logic_4/D_reset_FF_0.Q.n4 2.86313
R19015 SAR_Asynchronous_Logic_4/D_reset_FF_0.Q.n4 SAR_Asynchronous_Logic_4/D_reset_FF_0.Q.n3 2.84345
R19016 a_4722_n82.n0 a_4722_n82.t2 86.4194
R19017 a_4722_n82.n2 a_4722_n82.t3 82.416
R19018 a_4722_n82.n1 a_4722_n82.t4 51.8544
R19019 a_4722_n82.n0 a_4722_n82.t5 51.8072
R19020 a_4722_n82.n3 a_4722_n82.t0 6.28457
R19021 a_4722_n82.n2 a_4722_n82.n1 4.1171
R19022 a_4722_n82.n3 a_4722_n82.n2 2.66253
R19023 a_4722_n82.t1 a_4722_n82.n3 2.21122
R19024 a_4722_n82.n1 a_4722_n82.n0 1.3775
R19025 a_14798_n314.n2 a_14798_n314.t2 11.0089
R19026 a_14798_n314.n2 a_14798_n314.n1 7.28488
R19027 a_14798_n314.n1 a_14798_n314.n0 5.39574
R19028 a_14798_n314.n1 a_14798_n314.t3 4.91248
R19029 a_14798_n314.t0 a_14798_n314.n2 4.12612
R19030 a_14798_n314.n0 a_14798_n314.t4 3.7821
R19031 a_14798_n314.n0 a_14798_n314.t1 3.77824
R19032 a_6950_n314.n0 a_6950_n314.t6 74.8588
R19033 a_6950_n314.n0 a_6950_n314.t5 44.2362
R19034 a_6950_n314.n0 a_6950_n314.n2 14.5242
R19035 a_6950_n314.n2 a_6950_n314.t0 11.0089
R19036 a_6950_n314.n3 a_6950_n314.n1 5.39574
R19037 a_6950_n314.t1 a_6950_n314.n3 4.91248
R19038 a_6950_n314.n2 a_6950_n314.t3 4.12478
R19039 a_6950_n314.n1 a_6950_n314.t2 3.7821
R19040 a_6950_n314.n1 a_6950_n314.t4 3.77824
R19041 a_6950_n314.n3 a_6950_n314.n0 1.83141
R19042 a_8578_n314.n2 a_8578_n314.t1 11.0083
R19043 a_8578_n314.n2 a_8578_n314.n1 7.51324
R19044 a_8578_n314.n1 a_8578_n314.n0 5.39574
R19045 a_8578_n314.n1 a_8578_n314.t3 4.91248
R19046 a_8578_n314.t0 a_8578_n314.n2 4.12559
R19047 a_8578_n314.n0 a_8578_n314.t4 3.7821
R19048 a_8578_n314.n0 a_8578_n314.t2 3.77824
R19049 a_n27278_n3300.n0 a_n27278_n3300.t5 86.4194
R19050 a_n27278_n3300.n2 a_n27278_n3300.t4 82.415
R19051 a_n27278_n3300.n1 a_n27278_n3300.t2 51.8534
R19052 a_n27278_n3300.n0 a_n27278_n3300.t3 51.8062
R19053 a_n27278_n3300.n3 a_n27278_n3300.t1 6.28457
R19054 a_n27278_n3300.n2 a_n27278_n3300.n1 4.1171
R19055 a_n27278_n3300.n3 a_n27278_n3300.n2 2.66254
R19056 a_n27278_n3300.t0 a_n27278_n3300.n3 2.21138
R19057 a_n27278_n3300.n1 a_n27278_n3300.n0 1.3775
R19058 SAR_Asynchronous_Logic_2/D_reset_FF_0.Q.n2 SAR_Asynchronous_Logic_2/D_reset_FF_0.Q.t6 74.8588
R19059 SAR_Asynchronous_Logic_2/D_reset_FF_0.Q.n3 SAR_Asynchronous_Logic_2/D_reset_FF_0.Q.t5 70.3153
R19060 SAR_Asynchronous_Logic_2/D_reset_FF_0.Q.n2 SAR_Asynchronous_Logic_2/D_reset_FF_0.Q.t3 44.2362
R19061 SAR_Asynchronous_Logic_2/D_reset_FF_0.Q.n3 SAR_Asynchronous_Logic_2/D_reset_FF_0.Q.t4 39.854
R19062 SAR_Asynchronous_Logic_2/D_reset_FF_0.Q.n4 SAR_Asynchronous_Logic_2/D_reset_FF_0.Q.n0 11.62
R19063 SAR_Asynchronous_Logic_2/D_reset_FF_0.Q.n0 SAR_Asynchronous_Logic_2/D_reset_FF_0.Q.n1 5.39574
R19064 SAR_Asynchronous_Logic_2/D_reset_FF_0.Q.n0 SAR_Asynchronous_Logic_2/D_reset_FF_0.Q.t1 4.91248
R19065 SAR_Asynchronous_Logic_2/D_reset_FF_0.Q.n1 SAR_Asynchronous_Logic_2/D_reset_FF_0.Q.t2 3.7821
R19066 SAR_Asynchronous_Logic_2/D_reset_FF_0.Q.n1 SAR_Asynchronous_Logic_2/D_reset_FF_0.Q.t0 3.77824
R19067 SAR_Asynchronous_Logic_2/D_reset_FF_0.Q.n0 SAR_Asynchronous_Logic_2/D_reset_FF_0.Q.n2 3.04286
R19068 SAR_Asynchronous_Logic_2/D_reset_FF_0.Q SAR_Asynchronous_Logic_2/D_reset_FF_0.Q.n4 2.86313
R19069 SAR_Asynchronous_Logic_2/D_reset_FF_0.Q.n4 SAR_Asynchronous_Logic_2/D_reset_FF_0.Q.n3 2.84345
R19070 a_48898_n18422.n1 a_48898_n18422.t1 11.0089
R19071 a_48898_n18422.n2 a_48898_n18422.n1 7.28488
R19072 a_48898_n18422.n2 a_48898_n18422.n0 5.39574
R19073 a_48898_n18422.t2 a_48898_n18422.n2 4.91248
R19074 a_48898_n18422.n1 a_48898_n18422.t4 4.12478
R19075 a_48898_n18422.n0 a_48898_n18422.t3 3.7821
R19076 a_48898_n18422.n0 a_48898_n18422.t0 3.77824
R19077 a_n29890_n80.n3 a_n29890_n80.t6 81.0083
R19078 a_n29890_n80.n3 a_n29890_n80.t7 80.9469
R19079 a_n29890_n80.n2 a_n29890_n80.t4 70.3153
R19080 a_n29890_n80.n0 a_n29890_n80.t2 54.8886
R19081 a_n29890_n80.n2 a_n29890_n80.t5 39.854
R19082 a_n29890_n80.n0 a_n29890_n80.t3 16.7884
R19083 a_n29890_n80.n1 a_n29890_n80.n0 9.8148
R19084 a_n29890_n80.n1 a_n29890_n80.t1 5.96645
R19085 a_n29890_n80.n1 a_n29890_n80.n2 2.69789
R19086 a_n29890_n80.t0 a_n29890_n80.n1 2.52942
R19087 a_n29890_n80.n0 a_n29890_n80.n3 1.30877
R19088 Bit_10 Bit_10.n2 21.8179
R19089 Bit_10.n2 Bit_10.t1 12.5331
R19090 Bit_10.n1 Bit_10.t2 10.8182
R19091 Bit_10.n0 Bit_10.t3 3.00172
R19092 Bit_10.n0 Bit_10.t0 2.94206
R19093 Bit_10.n2 Bit_10.n1 2.2505
R19094 Bit_10.n1 Bit_10.n0 1.37321
R19095 VCM.n2 VCM.n0 11.246
R19096 VCM.n19 VCM.t18 11.0112
R19097 VCM.n17 VCM.t2 11.0112
R19098 VCM.n15 VCM.t6 11.0112
R19099 VCM.n13 VCM.t0 11.0112
R19100 VCM.n11 VCM.t4 11.0112
R19101 VCM.n9 VCM.t20 11.0112
R19102 VCM.n7 VCM.t8 11.0112
R19103 VCM.n5 VCM.t10 11.0112
R19104 VCM.n3 VCM.t15 11.0112
R19105 VCM.n1 VCM.t11 11.0112
R19106 VCM.n0 VCM.t17 11.0112
R19107 VCM.n4 VCM.n3 10.4523
R19108 VCM.n8 VCM.n7 10.4523
R19109 VCM.n12 VCM.n11 10.4523
R19110 VCM.n16 VCM.n15 10.4523
R19111 VCM.n20 VCM.n19 10.4523
R19112 VCM.n18 VCM.n17 9.51349
R19113 VCM.n14 VCM.n13 9.51349
R19114 VCM.n10 VCM.n9 9.51349
R19115 VCM.n6 VCM.n5 9.51349
R19116 VCM.n2 VCM.n1 9.51349
R19117 VCM.n20 VCM.n18 4.2629
R19118 VCM.n16 VCM.n14 4.2629
R19119 VCM.n12 VCM.n10 4.2629
R19120 VCM.n8 VCM.n6 4.2629
R19121 VCM.n4 VCM.n2 4.2629
R19122 VCM.n17 VCM.t1 4.12478
R19123 VCM.n13 VCM.t13 4.12478
R19124 VCM.n9 VCM.t3 4.12478
R19125 VCM.n5 VCM.t9 4.12478
R19126 VCM.n1 VCM.t14 4.12478
R19127 VCM.n19 VCM.t7 4.12461
R19128 VCM.n15 VCM.t19 4.12461
R19129 VCM.n11 VCM.t16 4.12461
R19130 VCM.n7 VCM.t21 4.12461
R19131 VCM.n3 VCM.t12 4.12461
R19132 VCM.n0 VCM.t5 4.12461
R19133 VCM VCM.n20 1.8104
R19134 VCM.n18 VCM.n16 0.5381
R19135 VCM.n14 VCM.n12 0.5381
R19136 VCM.n10 VCM.n8 0.5381
R19137 VCM.n6 VCM.n4 0.5381
R19138 a_36790_n4422.n2 a_36790_n4422.t0 11.0089
R19139 a_36790_n4422.n2 a_36790_n4422.n1 7.28488
R19140 a_36790_n4422.n1 a_36790_n4422.n0 5.39574
R19141 a_36790_n4422.n1 a_36790_n4422.t4 4.91281
R19142 a_36790_n4422.t1 a_36790_n4422.n2 4.12554
R19143 a_36790_n4422.n0 a_36790_n4422.t3 3.7821
R19144 a_36790_n4422.n0 a_36790_n4422.t2 3.77824
R19145 a_100604_n3162.n1 a_100604_n3162.t5 75.0252
R19146 a_100604_n3162.n1 a_100604_n3162.t4 44.0697
R19147 a_100604_n3162.n3 a_100604_n3162.t2 11.0112
R19148 a_100604_n3162.n0 a_100604_n3162.t0 10.6055
R19149 a_100604_n3162.n2 a_100604_n3162.n0 9.81776
R19150 a_100604_n3162.n2 a_100604_n3162.n1 5.81341
R19151 a_100604_n3162.n3 a_100604_n3162.n2 4.64798
R19152 a_100604_n3162.n0 a_100604_n3162.t3 4.53041
R19153 a_100604_n3162.t1 a_100604_n3162.n3 4.12612
R19154 SAR_Asynchronous_Logic_9/D_reset_FF_0.Q.n1 SAR_Asynchronous_Logic_9/D_reset_FF_0.Q.t3 74.8588
R19155 SAR_Asynchronous_Logic_9/D_reset_FF_0.Q.n3 SAR_Asynchronous_Logic_9/D_reset_FF_0.Q.t5 70.3153
R19156 SAR_Asynchronous_Logic_9/D_reset_FF_0.Q.n1 SAR_Asynchronous_Logic_9/D_reset_FF_0.Q.t6 44.2362
R19157 SAR_Asynchronous_Logic_9/D_reset_FF_0.Q.n3 SAR_Asynchronous_Logic_9/D_reset_FF_0.Q.t4 39.8548
R19158 SAR_Asynchronous_Logic_9/D_reset_FF_0.Q.n4 SAR_Asynchronous_Logic_9/D_reset_FF_0.Q.n0 11.62
R19159 SAR_Asynchronous_Logic_9/D_reset_FF_0.Q.n0 SAR_Asynchronous_Logic_9/D_reset_FF_0.Q.n2 5.39574
R19160 SAR_Asynchronous_Logic_9/D_reset_FF_0.Q.n0 SAR_Asynchronous_Logic_9/D_reset_FF_0.Q.t2 4.91281
R19161 SAR_Asynchronous_Logic_9/D_reset_FF_0.Q.n2 SAR_Asynchronous_Logic_9/D_reset_FF_0.Q.t1 3.7821
R19162 SAR_Asynchronous_Logic_9/D_reset_FF_0.Q.n2 SAR_Asynchronous_Logic_9/D_reset_FF_0.Q.t0 3.77824
R19163 SAR_Asynchronous_Logic_9/D_reset_FF_0.Q.n0 SAR_Asynchronous_Logic_9/D_reset_FF_0.Q.n1 3.04186
R19164 SAR_Asynchronous_Logic_9/D_reset_FF_0.Q SAR_Asynchronous_Logic_9/D_reset_FF_0.Q.n4 2.86313
R19165 SAR_Asynchronous_Logic_9/D_reset_FF_0.Q.n4 SAR_Asynchronous_Logic_9/D_reset_FF_0.Q.n3 2.84345
R19166 a_41050_n18422.n0 a_41050_n18422.t6 74.8588
R19167 a_41050_n18422.n0 a_41050_n18422.t5 44.2362
R19168 a_41050_n18422.n0 a_41050_n18422.n2 14.5242
R19169 a_41050_n18422.n2 a_41050_n18422.t0 11.0089
R19170 a_41050_n18422.n3 a_41050_n18422.n1 5.39574
R19171 a_41050_n18422.t1 a_41050_n18422.n3 4.91248
R19172 a_41050_n18422.n2 a_41050_n18422.t3 4.12478
R19173 a_41050_n18422.n1 a_41050_n18422.t2 3.7821
R19174 a_41050_n18422.n1 a_41050_n18422.t4 3.77824
R19175 a_41050_n18422.n3 a_41050_n18422.n0 1.83141
R19176 a_42678_n18422.n1 a_42678_n18422.t4 11.0083
R19177 a_42678_n18422.n2 a_42678_n18422.n1 7.51324
R19178 a_42678_n18422.n2 a_42678_n18422.n0 5.39574
R19179 a_42678_n18422.t0 a_42678_n18422.n2 4.91248
R19180 a_42678_n18422.n1 a_42678_n18422.t3 4.12425
R19181 a_42678_n18422.n0 a_42678_n18422.t1 3.7821
R19182 a_42678_n18422.n0 a_42678_n18422.t2 3.77824
R19183 a_3002_n80.n0 a_3002_n80.t2 85.7557
R19184 a_3002_n80.n3 a_3002_n80.t5 70.3153
R19185 a_3002_n80.n2 a_3002_n80.t4 51.5037
R19186 a_3002_n80.n2 a_3002_n80.t3 51.1583
R19187 a_3002_n80.n3 a_3002_n80.t7 39.854
R19188 a_3002_n80.n0 a_3002_n80.t6 24.4279
R19189 a_3002_n80.n1 a_3002_n80.n0 7.82327
R19190 a_3002_n80.n1 a_3002_n80.t1 5.96645
R19191 a_3002_n80.n1 a_3002_n80.n3 2.73367
R19192 a_3002_n80.t0 a_3002_n80.n1 2.52942
R19193 a_3002_n80.n0 a_3002_n80.n2 1.30714
R19194 Bit_9 Bit_9.n2 21.8158
R19195 Bit_9.n2 Bit_9.t3 12.5331
R19196 Bit_9.n1 Bit_9.t1 10.8182
R19197 Bit_9.n0 Bit_9.t0 3.00172
R19198 Bit_9.n0 Bit_9.t2 2.94206
R19199 Bit_9.n2 Bit_9.n1 2.2505
R19200 Bit_9.n1 Bit_9.n0 1.37321
R19201 a_136578_n314.n1 a_136578_n314.t3 11.0083
R19202 a_136578_n314.n2 a_136578_n314.n1 7.51324
R19203 a_136578_n314.n2 a_136578_n314.n0 5.39574
R19204 a_136578_n314.t0 a_136578_n314.n2 4.91248
R19205 a_136578_n314.n1 a_136578_n314.t2 4.12425
R19206 a_136578_n314.n0 a_136578_n314.t1 3.7821
R19207 a_136578_n314.n0 a_136578_n314.t4 3.77824
R19208 a_n26034_n314.n1 a_n26034_n314.t4 75.0252
R19209 a_n26034_n314.n1 a_n26034_n314.t5 44.0697
R19210 a_n26034_n314.n2 a_n26034_n314.t0 10.6055
R19211 a_n26034_n314.n0 a_n26034_n314.t1 10.6055
R19212 a_n26034_n314.n2 a_n26034_n314.n0 8.89791
R19213 a_n26034_n314.n0 a_n26034_n314.n1 5.7951
R19214 a_n26034_n314.t2 a_n26034_n314.n2 4.53117
R19215 a_n26034_n314.n0 a_n26034_n314.t3 4.53024
R19216 SAR_Asynchronous_Logic_6/D_reset_FF_1.Q.n7 SAR_Asynchronous_Logic_6/D_reset_FF_1.Q.t9 74.8588
R19217 SAR_Asynchronous_Logic_6/D_reset_FF_1.Q.n8 SAR_Asynchronous_Logic_6/D_reset_FF_1.Q.t10 70.3153
R19218 SAR_Asynchronous_Logic_6/D_reset_FF_1.Q.n7 SAR_Asynchronous_Logic_6/D_reset_FF_1.Q.t11 44.2362
R19219 SAR_Asynchronous_Logic_6/D_reset_FF_1.Q.n8 SAR_Asynchronous_Logic_6/D_reset_FF_1.Q.t12 39.854
R19220 SAR_Asynchronous_Logic_6/D_reset_FF_1.Q.n9 SAR_Asynchronous_Logic_6/D_reset_FF_1.Q.n0 11.62
R19221 SAR_Asynchronous_Logic_6/D_reset_FF_1.Q.n2 SAR_Asynchronous_Logic_6/D_reset_FF_1.Q.t0 11.0112
R19222 SAR_Asynchronous_Logic_6/D_reset_FF_1.Q.n3 SAR_Asynchronous_Logic_6/D_reset_FF_1.Q.t1 11.0112
R19223 SAR_Asynchronous_Logic_6/D_reset_FF_1.Q.n1 SAR_Asynchronous_Logic_6/D_reset_FF_1.Q.t3 11.0083
R19224 SAR_Asynchronous_Logic_6/D_reset_FF_1.Q.n5 SAR_Asynchronous_Logic_6/D_reset_FF_1.Q.n1 9.49928
R19225 SAR_Asynchronous_Logic_6/D_reset_FF_1.Q.n4 SAR_Asynchronous_Logic_6/D_reset_FF_1.Q.n2 7.28497
R19226 SAR_Asynchronous_Logic_6/D_reset_FF_1.Q.n4 SAR_Asynchronous_Logic_6/D_reset_FF_1.Q.n3 6.65722
R19227 SAR_Asynchronous_Logic_6/D_reset_FF_1.Q.n5 SAR_Asynchronous_Logic_6/D_reset_FF_1.Q.n4 5.53329
R19228 SAR_Asynchronous_Logic_6/D_reset_FF_1.Q.n0 SAR_Asynchronous_Logic_6/D_reset_FF_1.Q.n6 5.39574
R19229 SAR_Asynchronous_Logic_6/D_reset_FF_1.Q.n0 SAR_Asynchronous_Logic_6/D_reset_FF_1.Q.t7 4.91248
R19230 SAR_Asynchronous_Logic_6/D_reset_FF_1.Q SAR_Asynchronous_Logic_6/D_reset_FF_1.Q.n5 4.59604
R19231 SAR_Asynchronous_Logic_6/D_reset_FF_1.Q.n3 SAR_Asynchronous_Logic_6/D_reset_FF_1.Q.t4 4.12554
R19232 SAR_Asynchronous_Logic_6/D_reset_FF_1.Q.n2 SAR_Asynchronous_Logic_6/D_reset_FF_1.Q.t5 4.12461
R19233 SAR_Asynchronous_Logic_6/D_reset_FF_1.Q.n1 SAR_Asynchronous_Logic_6/D_reset_FF_1.Q.t6 4.12408
R19234 SAR_Asynchronous_Logic_6/D_reset_FF_1.Q.n6 SAR_Asynchronous_Logic_6/D_reset_FF_1.Q.t8 3.7821
R19235 SAR_Asynchronous_Logic_6/D_reset_FF_1.Q.n6 SAR_Asynchronous_Logic_6/D_reset_FF_1.Q.t2 3.77824
R19236 SAR_Asynchronous_Logic_6/D_reset_FF_1.Q.n0 SAR_Asynchronous_Logic_6/D_reset_FF_1.Q.n7 3.04286
R19237 SAR_Asynchronous_Logic_6/D_reset_FF_1.Q SAR_Asynchronous_Logic_6/D_reset_FF_1.Q.n9 2.86313
R19238 SAR_Asynchronous_Logic_6/D_reset_FF_1.Q.n9 SAR_Asynchronous_Logic_6/D_reset_FF_1.Q.n8 2.84345
R19239 a_32736_n13850.n3 a_32736_n13850.t3 81.0083
R19240 a_32736_n13850.n3 a_32736_n13850.t5 80.9469
R19241 a_32736_n13850.n2 a_32736_n13850.t2 70.3153
R19242 a_32736_n13850.n0 a_32736_n13850.t6 54.8876
R19243 a_32736_n13850.n2 a_32736_n13850.t7 39.8548
R19244 a_32736_n13850.n0 a_32736_n13850.t4 16.7884
R19245 a_32736_n13850.n1 a_32736_n13850.n0 9.8148
R19246 a_32736_n13850.n1 a_32736_n13850.t1 5.96645
R19247 a_32736_n13850.n1 a_32736_n13850.n2 2.6989
R19248 a_32736_n13850.t0 a_32736_n13850.n1 2.52922
R19249 a_32736_n13850.n0 a_32736_n13850.n3 1.30877
R19250 a_32736_n13096.n0 a_32736_n13096.t5 85.7547
R19251 a_32736_n13096.n2 a_32736_n13096.t7 70.3153
R19252 a_32736_n13096.n3 a_32736_n13096.t2 51.5027
R19253 a_32736_n13096.n3 a_32736_n13096.t4 51.1583
R19254 a_32736_n13096.n2 a_32736_n13096.t6 39.8548
R19255 a_32736_n13096.n0 a_32736_n13096.t3 24.4279
R19256 a_32736_n13096.n1 a_32736_n13096.n0 7.82327
R19257 a_32736_n13096.n1 a_32736_n13096.t1 5.96645
R19258 a_32736_n13096.n1 a_32736_n13096.n2 2.73467
R19259 a_32736_n13096.t0 a_32736_n13096.n1 2.52922
R19260 a_32736_n13096.n0 a_32736_n13096.n3 1.30714
R19261 D_C_10 D_C_10.n0 23.3324
R19262 D_C_10.n0 D_C_10.t1 11.0083
R19263 D_C_10.n0 D_C_10.t0 4.12425
R19264 a_5966_n314.n1 a_5966_n314.t4 75.0252
R19265 a_5966_n314.n1 a_5966_n314.t5 44.0697
R19266 a_5966_n314.n2 a_5966_n314.t2 10.6055
R19267 a_5966_n314.n0 a_5966_n314.t3 10.6055
R19268 a_5966_n314.n2 a_5966_n314.n0 8.89791
R19269 a_5966_n314.n0 a_5966_n314.n1 5.7951
R19270 a_5966_n314.t0 a_5966_n314.n2 4.53117
R19271 a_5966_n314.n0 a_5966_n314.t1 4.53024
R19272 CK_8.n0 CK_8.t1 70.3153
R19273 CK_8.n0 CK_8.t0 39.854
R19274 CK_8 CK_8.n0 18.4666
R19275 a_100722_n4054.n2 a_100722_n4054.t2 82.7757
R19276 a_100722_n4054.n3 a_100722_n4054.t4 82.6414
R19277 a_100722_n4054.n1 a_100722_n4054.t5 70.3153
R19278 a_100722_n4054.n2 a_100722_n4054.t6 55.8254
R19279 a_100722_n4054.n4 a_100722_n4054.t7 51.5648
R19280 a_100722_n4054.n1 a_100722_n4054.t3 39.8548
R19281 a_100722_n4054.n0 a_100722_n4054.t1 6.02308
R19282 a_100722_n4054.n4 a_100722_n4054.n3 3.9695
R19283 a_100722_n4054.n0 a_100722_n4054.n4 3.3953
R19284 a_100722_n4054.n0 a_100722_n4054.n1 2.70724
R19285 a_100722_n4054.t0 a_100722_n4054.n0 2.47188
R19286 a_100722_n4054.n3 a_100722_n4054.n2 1.3073
R19287 a_n28998_n80.n0 a_n28998_n80.t7 85.7557
R19288 a_n28998_n80.n3 a_n28998_n80.t4 70.3153
R19289 a_n28998_n80.n2 a_n28998_n80.t3 51.5037
R19290 a_n28998_n80.n2 a_n28998_n80.t6 51.1583
R19291 a_n28998_n80.n3 a_n28998_n80.t5 39.854
R19292 a_n28998_n80.n0 a_n28998_n80.t2 24.4279
R19293 a_n28998_n80.n1 a_n28998_n80.n0 7.82327
R19294 a_n28998_n80.n1 a_n28998_n80.t1 5.96645
R19295 a_n28998_n80.n1 a_n28998_n80.n3 2.73367
R19296 a_n28998_n80.t0 a_n28998_n80.n1 2.52942
R19297 a_n28998_n80.n0 a_n28998_n80.n2 1.30714
R19298 a_n13146_1076.n0 a_n13146_1076.t3 28.6634
R19299 a_n13146_1076.n0 a_n13146_1076.t0 11.2157
R19300 a_n13146_1076.n1 a_n13146_1076.t1 3.00172
R19301 a_n13146_1076.t2 a_n13146_1076.n1 2.9434
R19302 a_n13146_1076.n1 a_n13146_1076.n0 0.976737
R19303 a_36604_n3162.n1 a_36604_n3162.t4 75.0252
R19304 a_36604_n3162.n1 a_36604_n3162.t5 44.0697
R19305 a_36604_n3162.n3 a_36604_n3162.t3 11.0112
R19306 a_36604_n3162.n0 a_36604_n3162.t0 10.6055
R19307 a_36604_n3162.n2 a_36604_n3162.n0 9.81776
R19308 a_36604_n3162.n2 a_36604_n3162.n1 5.81341
R19309 a_36604_n3162.n3 a_36604_n3162.n2 4.64798
R19310 a_36604_n3162.n0 a_36604_n3162.t2 4.53041
R19311 a_36604_n3162.t1 a_36604_n3162.n3 4.12612
R19312 SAR_Asynchronous_Logic_2/D_reset_FF_1.Q.n1 SAR_Asynchronous_Logic_2/D_reset_FF_1.Q.t12 74.8588
R19313 SAR_Asynchronous_Logic_2/D_reset_FF_1.Q.n3 SAR_Asynchronous_Logic_2/D_reset_FF_1.Q.t11 70.3153
R19314 SAR_Asynchronous_Logic_2/D_reset_FF_1.Q.n1 SAR_Asynchronous_Logic_2/D_reset_FF_1.Q.t9 44.2362
R19315 SAR_Asynchronous_Logic_2/D_reset_FF_1.Q.n3 SAR_Asynchronous_Logic_2/D_reset_FF_1.Q.t10 39.8548
R19316 SAR_Asynchronous_Logic_2/D_reset_FF_1.Q.n4 SAR_Asynchronous_Logic_2/D_reset_FF_1.Q.n0 11.62
R19317 SAR_Asynchronous_Logic_2/D_reset_FF_1.Q.n7 SAR_Asynchronous_Logic_2/D_reset_FF_1.Q.t6 11.0112
R19318 SAR_Asynchronous_Logic_2/D_reset_FF_1.Q.n6 SAR_Asynchronous_Logic_2/D_reset_FF_1.Q.t5 11.0112
R19319 SAR_Asynchronous_Logic_2/D_reset_FF_1.Q.n5 SAR_Asynchronous_Logic_2/D_reset_FF_1.Q.t7 11.0083
R19320 SAR_Asynchronous_Logic_2/D_reset_FF_1.Q.n9 SAR_Asynchronous_Logic_2/D_reset_FF_1.Q.n5 9.49928
R19321 SAR_Asynchronous_Logic_2/D_reset_FF_1.Q.n8 SAR_Asynchronous_Logic_2/D_reset_FF_1.Q.n6 7.28497
R19322 SAR_Asynchronous_Logic_2/D_reset_FF_1.Q.n8 SAR_Asynchronous_Logic_2/D_reset_FF_1.Q.n7 6.65722
R19323 SAR_Asynchronous_Logic_2/D_reset_FF_1.Q.n9 SAR_Asynchronous_Logic_2/D_reset_FF_1.Q.n8 5.53329
R19324 SAR_Asynchronous_Logic_2/D_reset_FF_1.Q.n0 SAR_Asynchronous_Logic_2/D_reset_FF_1.Q.n2 5.39574
R19325 SAR_Asynchronous_Logic_2/D_reset_FF_1.Q.n0 SAR_Asynchronous_Logic_2/D_reset_FF_1.Q.t2 4.91281
R19326 SAR_Asynchronous_Logic_2/D_reset_FF_1.Q SAR_Asynchronous_Logic_2/D_reset_FF_1.Q.n9 4.59604
R19327 SAR_Asynchronous_Logic_2/D_reset_FF_1.Q.n6 SAR_Asynchronous_Logic_2/D_reset_FF_1.Q.t0 4.12612
R19328 SAR_Asynchronous_Logic_2/D_reset_FF_1.Q.n7 SAR_Asynchronous_Logic_2/D_reset_FF_1.Q.t1 4.12478
R19329 SAR_Asynchronous_Logic_2/D_reset_FF_1.Q.n5 SAR_Asynchronous_Logic_2/D_reset_FF_1.Q.t8 4.12425
R19330 SAR_Asynchronous_Logic_2/D_reset_FF_1.Q.n2 SAR_Asynchronous_Logic_2/D_reset_FF_1.Q.t3 3.7821
R19331 SAR_Asynchronous_Logic_2/D_reset_FF_1.Q.n2 SAR_Asynchronous_Logic_2/D_reset_FF_1.Q.t4 3.77824
R19332 SAR_Asynchronous_Logic_2/D_reset_FF_1.Q.n0 SAR_Asynchronous_Logic_2/D_reset_FF_1.Q.n1 3.04186
R19333 SAR_Asynchronous_Logic_2/D_reset_FF_1.Q SAR_Asynchronous_Logic_2/D_reset_FF_1.Q.n4 2.86313
R19334 SAR_Asynchronous_Logic_2/D_reset_FF_1.Q.n4 SAR_Asynchronous_Logic_2/D_reset_FF_1.Q.n3 2.84345
R19335 a_44918_n14314.n2 a_44918_n14314.t3 11.0083
R19336 a_44918_n14314.n2 a_44918_n14314.n1 7.51324
R19337 a_44918_n14314.n1 a_44918_n14314.n0 5.39574
R19338 a_44918_n14314.n1 a_44918_n14314.t2 4.91281
R19339 a_44918_n14314.t0 a_44918_n14314.n2 4.12501
R19340 a_44918_n14314.n0 a_44918_n14314.t1 3.7821
R19341 a_44918_n14314.n0 a_44918_n14314.t4 3.77824
R19342 a_138632_n3162.n1 a_138632_n3162.t5 75.0252
R19343 a_138632_n3162.n1 a_138632_n3162.t4 44.0697
R19344 a_138632_n3162.n2 a_138632_n3162.t3 10.6055
R19345 a_138632_n3162.n0 a_138632_n3162.t0 10.6055
R19346 a_138632_n3162.n2 a_138632_n3162.n0 8.89791
R19347 a_138632_n3162.n0 a_138632_n3162.n1 5.7951
R19348 a_138632_n3162.t1 a_138632_n3162.n2 4.53176
R19349 a_138632_n3162.n0 a_138632_n3162.t2 4.53041
R19350 a_138818_n4422.n1 a_138818_n4422.t4 11.0083
R19351 a_138818_n4422.n2 a_138818_n4422.n1 7.51324
R19352 a_138818_n4422.n2 a_138818_n4422.n0 5.39574
R19353 a_138818_n4422.t0 a_138818_n4422.n2 4.91281
R19354 a_138818_n4422.n1 a_138818_n4422.t3 4.12408
R19355 a_138818_n4422.n0 a_138818_n4422.t1 3.7821
R19356 a_138818_n4422.n0 a_138818_n4422.t2 3.77824
R19357 a_68722_n82.n0 a_68722_n82.t5 86.4194
R19358 a_68722_n82.n2 a_68722_n82.t3 82.416
R19359 a_68722_n82.n1 a_68722_n82.t4 51.8544
R19360 a_68722_n82.n0 a_68722_n82.t2 51.8072
R19361 a_68722_n82.n3 a_68722_n82.t1 6.28457
R19362 a_68722_n82.n2 a_68722_n82.n1 4.1171
R19363 a_68722_n82.n3 a_68722_n82.n2 2.66253
R19364 a_68722_n82.t0 a_68722_n82.n3 2.21122
R19365 a_68722_n82.n1 a_68722_n82.n0 1.3775
R19366 a_108732_n13054.n1 a_108732_n13054.t4 75.0252
R19367 a_108732_n13054.n1 a_108732_n13054.t5 44.0697
R19368 a_108732_n13054.n2 a_108732_n13054.t2 10.6055
R19369 a_108732_n13054.n0 a_108732_n13054.t1 10.6055
R19370 a_108732_n13054.n2 a_108732_n13054.n0 8.89791
R19371 a_108732_n13054.n0 a_108732_n13054.n1 5.7951
R19372 a_108732_n13054.t0 a_108732_n13054.n2 4.53176
R19373 a_108732_n13054.n0 a_108732_n13054.t3 4.53041
R19374 D_C_4 D_C_4.n0 17.0359
R19375 D_C_4.n0 D_C_4.t0 11.0083
R19376 D_C_4.n0 D_C_4.t1 4.12408
R19377 SAR_Asynchronous_Logic_6/D_reset_FF_0.Q.n1 SAR_Asynchronous_Logic_6/D_reset_FF_0.Q.t3 74.8588
R19378 SAR_Asynchronous_Logic_6/D_reset_FF_0.Q.n3 SAR_Asynchronous_Logic_6/D_reset_FF_0.Q.t6 70.3153
R19379 SAR_Asynchronous_Logic_6/D_reset_FF_0.Q.n1 SAR_Asynchronous_Logic_6/D_reset_FF_0.Q.t4 44.2362
R19380 SAR_Asynchronous_Logic_6/D_reset_FF_0.Q.n3 SAR_Asynchronous_Logic_6/D_reset_FF_0.Q.t5 39.8548
R19381 SAR_Asynchronous_Logic_6/D_reset_FF_0.Q.n4 SAR_Asynchronous_Logic_6/D_reset_FF_0.Q.n0 11.62
R19382 SAR_Asynchronous_Logic_6/D_reset_FF_0.Q.n0 SAR_Asynchronous_Logic_6/D_reset_FF_0.Q.n2 5.39574
R19383 SAR_Asynchronous_Logic_6/D_reset_FF_0.Q.n0 SAR_Asynchronous_Logic_6/D_reset_FF_0.Q.t2 4.91281
R19384 SAR_Asynchronous_Logic_6/D_reset_FF_0.Q.n2 SAR_Asynchronous_Logic_6/D_reset_FF_0.Q.t0 3.7821
R19385 SAR_Asynchronous_Logic_6/D_reset_FF_0.Q.n2 SAR_Asynchronous_Logic_6/D_reset_FF_0.Q.t1 3.77824
R19386 SAR_Asynchronous_Logic_6/D_reset_FF_0.Q.n0 SAR_Asynchronous_Logic_6/D_reset_FF_0.Q.n1 3.04186
R19387 SAR_Asynchronous_Logic_6/D_reset_FF_0.Q SAR_Asynchronous_Logic_6/D_reset_FF_0.Q.n4 2.86313
R19388 SAR_Asynchronous_Logic_6/D_reset_FF_0.Q.n4 SAR_Asynchronous_Logic_6/D_reset_FF_0.Q.n3 2.84345
R19389 a_106678_n18422.n1 a_106678_n18422.t0 11.0083
R19390 a_106678_n18422.n2 a_106678_n18422.n1 7.51324
R19391 a_106678_n18422.n2 a_106678_n18422.n0 5.39574
R19392 a_106678_n18422.t1 a_106678_n18422.n2 4.91248
R19393 a_106678_n18422.n1 a_106678_n18422.t4 4.12425
R19394 a_106678_n18422.n0 a_106678_n18422.t2 3.7821
R19395 a_106678_n18422.n0 a_106678_n18422.t3 3.77824
R19396 a_38890_n14314.n2 a_38890_n14314.t1 11.0089
R19397 a_38890_n14314.n2 a_38890_n14314.n1 7.28488
R19398 a_38890_n14314.n1 a_38890_n14314.n0 5.39574
R19399 a_38890_n14314.n1 a_38890_n14314.t3 4.91281
R19400 a_38890_n14314.t2 a_38890_n14314.n2 4.12554
R19401 a_38890_n14314.n0 a_38890_n14314.t4 3.7821
R19402 a_38890_n14314.n0 a_38890_n14314.t0 3.77824
R19403 a_137342_n4422.n0 a_137342_n4422.t5 74.8588
R19404 a_137342_n4422.n0 a_137342_n4422.t6 44.2362
R19405 a_137342_n4422.n3 a_137342_n4422.n0 14.5242
R19406 a_137342_n4422.n3 a_137342_n4422.t1 11.0089
R19407 a_137342_n4422.n2 a_137342_n4422.n1 5.39574
R19408 a_137342_n4422.n2 a_137342_n4422.t3 4.91281
R19409 a_137342_n4422.t0 a_137342_n4422.n3 4.12554
R19410 a_137342_n4422.n1 a_137342_n4422.t4 3.7821
R19411 a_137342_n4422.n1 a_137342_n4422.t2 3.77824
R19412 a_137342_n4422.n0 a_137342_n4422.n2 1.83141
R19413 a_38822_n18190.n0 a_38822_n18190.t4 86.4194
R19414 a_38822_n18190.n2 a_38822_n18190.t3 82.416
R19415 a_38822_n18190.n1 a_38822_n18190.t5 51.8544
R19416 a_38822_n18190.n0 a_38822_n18190.t2 51.8072
R19417 a_38822_n18190.n3 a_38822_n18190.t1 6.28457
R19418 a_38822_n18190.n2 a_38822_n18190.n1 4.1171
R19419 a_38822_n18190.n3 a_38822_n18190.n2 2.66253
R19420 a_38822_n18190.t0 a_38822_n18190.n3 2.21122
R19421 a_38822_n18190.n1 a_38822_n18190.n0 1.3775
R19422 a_35002_n80.n0 a_35002_n80.t7 85.7557
R19423 a_35002_n80.n3 a_35002_n80.t5 70.3153
R19424 a_35002_n80.n2 a_35002_n80.t3 51.5037
R19425 a_35002_n80.n2 a_35002_n80.t2 51.1583
R19426 a_35002_n80.n3 a_35002_n80.t6 39.854
R19427 a_35002_n80.n0 a_35002_n80.t4 24.4279
R19428 a_35002_n80.n1 a_35002_n80.n0 7.82327
R19429 a_35002_n80.n1 a_35002_n80.t1 5.96645
R19430 a_35002_n80.n1 a_35002_n80.n3 2.73367
R19431 a_35002_n80.t0 a_35002_n80.n1 2.52942
R19432 a_35002_n80.n0 a_35002_n80.n2 1.30714
R19433 a_74818_n4422.n2 a_74818_n4422.t3 11.0083
R19434 a_74818_n4422.n2 a_74818_n4422.n1 7.51324
R19435 a_74818_n4422.n1 a_74818_n4422.n0 5.39574
R19436 a_74818_n4422.n1 a_74818_n4422.t2 4.91281
R19437 a_74818_n4422.t0 a_74818_n4422.n2 4.12501
R19438 a_74818_n4422.n0 a_74818_n4422.t1 3.7821
R19439 a_74818_n4422.n0 a_74818_n4422.t4 3.77824
R19440 a_106632_n3162.n1 a_106632_n3162.t5 75.0252
R19441 a_106632_n3162.n1 a_106632_n3162.t4 44.0697
R19442 a_106632_n3162.n2 a_106632_n3162.t1 10.6055
R19443 a_106632_n3162.n0 a_106632_n3162.t2 10.6055
R19444 a_106632_n3162.n0 a_106632_n3162.n2 8.89791
R19445 a_106632_n3162.n0 a_106632_n3162.n1 5.7951
R19446 a_106632_n3162.t0 a_106632_n3162.n0 4.53176
R19447 a_106632_n3162.n2 a_106632_n3162.t3 4.53041
R19448 a_46134_n18422.n1 a_46134_n18422.t4 75.0252
R19449 a_46134_n18422.n1 a_46134_n18422.t5 44.0697
R19450 a_46134_n18422.n0 a_46134_n18422.t1 11.0112
R19451 a_46134_n18422.n3 a_46134_n18422.t2 10.6055
R19452 a_46134_n18422.n3 a_46134_n18422.n2 9.81776
R19453 a_46134_n18422.n2 a_46134_n18422.n1 5.81441
R19454 a_46134_n18422.n2 a_46134_n18422.n0 4.64798
R19455 a_46134_n18422.t0 a_46134_n18422.n3 4.53117
R19456 a_46134_n18422.n0 a_46134_n18422.t3 4.12461
R19457 CK_2.n0 CK_2.t1 70.3153
R19458 CK_2.n0 CK_2.t0 39.8548
R19459 CK_2 CK_2.n0 12.1494
R19460 a_35902_n82.n2 a_35902_n82.t5 82.7757
R19461 a_35902_n82.n3 a_35902_n82.t7 82.6424
R19462 a_35902_n82.n1 a_35902_n82.t3 70.3153
R19463 a_35902_n82.n2 a_35902_n82.t2 55.8264
R19464 a_35902_n82.n4 a_35902_n82.t6 51.5658
R19465 a_35902_n82.n1 a_35902_n82.t4 39.854
R19466 a_35902_n82.n0 a_35902_n82.t1 6.02308
R19467 a_35902_n82.n4 a_35902_n82.n3 3.9695
R19468 a_35902_n82.n0 a_35902_n82.n4 3.3953
R19469 a_35902_n82.n0 a_35902_n82.n1 2.70724
R19470 a_35902_n82.t0 a_35902_n82.n0 2.47208
R19471 a_35902_n82.n3 a_35902_n82.n2 1.3073
R19472 D_C_3 D_C_3.n0 17.0391
R19473 D_C_3.n0 D_C_3.t1 11.0083
R19474 D_C_3.n0 D_C_3.t0 4.12408
R19475 a_74678_n18422.n1 a_74678_n18422.t4 11.0083
R19476 a_74678_n18422.n2 a_74678_n18422.n1 7.51324
R19477 a_74678_n18422.n2 a_74678_n18422.n0 5.39574
R19478 a_74678_n18422.t1 a_74678_n18422.n2 4.91248
R19479 a_74678_n18422.n1 a_74678_n18422.t2 4.12425
R19480 a_74678_n18422.n0 a_74678_n18422.t0 3.7821
R19481 a_74678_n18422.n0 a_74678_n18422.t3 3.77824
R19482 a_34012_n13060.n0 a_34012_n13060.t3 28.6634
R19483 a_34012_n13060.n0 a_34012_n13060.t1 11.2157
R19484 a_34012_n13060.n1 a_34012_n13060.t2 3.00189
R19485 a_34012_n13060.t0 a_34012_n13060.n1 2.94281
R19486 a_34012_n13060.n1 a_34012_n13060.n0 0.976737
R19487 SAR_Asynchronous_Logic_1/D_reset_FF_0.Q.n1 SAR_Asynchronous_Logic_1/D_reset_FF_0.Q.t3 74.8588
R19488 SAR_Asynchronous_Logic_1/D_reset_FF_0.Q.n3 SAR_Asynchronous_Logic_1/D_reset_FF_0.Q.t6 70.3153
R19489 SAR_Asynchronous_Logic_1/D_reset_FF_0.Q.n1 SAR_Asynchronous_Logic_1/D_reset_FF_0.Q.t4 44.2362
R19490 SAR_Asynchronous_Logic_1/D_reset_FF_0.Q.n3 SAR_Asynchronous_Logic_1/D_reset_FF_0.Q.t5 39.8548
R19491 SAR_Asynchronous_Logic_1/D_reset_FF_0.Q.n4 SAR_Asynchronous_Logic_1/D_reset_FF_0.Q.n0 11.62
R19492 SAR_Asynchronous_Logic_1/D_reset_FF_0.Q.n0 SAR_Asynchronous_Logic_1/D_reset_FF_0.Q.n2 5.39574
R19493 SAR_Asynchronous_Logic_1/D_reset_FF_0.Q.n0 SAR_Asynchronous_Logic_1/D_reset_FF_0.Q.t0 4.91281
R19494 SAR_Asynchronous_Logic_1/D_reset_FF_0.Q.n2 SAR_Asynchronous_Logic_1/D_reset_FF_0.Q.t1 3.7821
R19495 SAR_Asynchronous_Logic_1/D_reset_FF_0.Q.n2 SAR_Asynchronous_Logic_1/D_reset_FF_0.Q.t2 3.77824
R19496 SAR_Asynchronous_Logic_1/D_reset_FF_0.Q.n0 SAR_Asynchronous_Logic_1/D_reset_FF_0.Q.n1 3.04186
R19497 SAR_Asynchronous_Logic_1/D_reset_FF_0.Q SAR_Asynchronous_Logic_1/D_reset_FF_0.Q.n4 2.86313
R19498 SAR_Asynchronous_Logic_1/D_reset_FF_0.Q.n4 SAR_Asynchronous_Logic_1/D_reset_FF_0.Q.n3 2.84345
R19499 a_42632_n3162.n1 a_42632_n3162.t5 75.0252
R19500 a_42632_n3162.n1 a_42632_n3162.t4 44.0697
R19501 a_42632_n3162.n2 a_42632_n3162.t2 10.6055
R19502 a_42632_n3162.n0 a_42632_n3162.t1 10.6055
R19503 a_42632_n3162.n2 a_42632_n3162.n0 8.89791
R19504 a_42632_n3162.n0 a_42632_n3162.n1 5.7951
R19505 a_42632_n3162.t0 a_42632_n3162.n2 4.53176
R19506 a_42632_n3162.n0 a_42632_n3162.t3 4.53041
R19507 a_102890_n14314.n2 a_102890_n14314.t0 11.0089
R19508 a_102890_n14314.n2 a_102890_n14314.n1 7.28488
R19509 a_102890_n14314.n1 a_102890_n14314.n0 5.39574
R19510 a_102890_n14314.n1 a_102890_n14314.t4 4.91281
R19511 a_102890_n14314.t2 a_102890_n14314.n2 4.12554
R19512 a_102890_n14314.n0 a_102890_n14314.t3 3.7821
R19513 a_102890_n14314.n0 a_102890_n14314.t1 3.77824
R19514 a_132604_n3162.n1 a_132604_n3162.t4 75.0252
R19515 a_132604_n3162.n1 a_132604_n3162.t5 44.0697
R19516 a_132604_n3162.n3 a_132604_n3162.t3 11.0112
R19517 a_132604_n3162.n0 a_132604_n3162.t0 10.6055
R19518 a_132604_n3162.n2 a_132604_n3162.n0 9.81776
R19519 a_132604_n3162.n2 a_132604_n3162.n1 5.81341
R19520 a_132604_n3162.n3 a_132604_n3162.n2 4.64798
R19521 a_132604_n3162.n0 a_132604_n3162.t2 4.53041
R19522 a_132604_n3162.t1 a_132604_n3162.n3 4.12612
R19523 a_6002_n18190.n2 a_6002_n18190.t5 82.7757
R19524 a_6002_n18190.n3 a_6002_n18190.t2 82.6424
R19525 a_6002_n18190.n1 a_6002_n18190.t6 70.3153
R19526 a_6002_n18190.n2 a_6002_n18190.t7 55.8264
R19527 a_6002_n18190.n4 a_6002_n18190.t3 51.5658
R19528 a_6002_n18190.n1 a_6002_n18190.t4 39.854
R19529 a_6002_n18190.n0 a_6002_n18190.t1 6.02308
R19530 a_6002_n18190.n4 a_6002_n18190.n3 3.9695
R19531 a_6002_n18190.n0 a_6002_n18190.n4 3.3953
R19532 a_6002_n18190.n0 a_6002_n18190.n1 2.70724
R19533 a_6002_n18190.t0 a_6002_n18190.n0 2.47208
R19534 a_6002_n18190.n3 a_6002_n18190.n2 1.3073
R19535 a_10678_n18422.n1 a_10678_n18422.t3 11.0083
R19536 a_10678_n18422.n2 a_10678_n18422.n1 7.51324
R19537 a_10678_n18422.n2 a_10678_n18422.n0 5.39574
R19538 a_10678_n18422.t1 a_10678_n18422.n2 4.91248
R19539 a_10678_n18422.n1 a_10678_n18422.t4 4.12425
R19540 a_10678_n18422.n0 a_10678_n18422.t0 3.7821
R19541 a_10678_n18422.n0 a_10678_n18422.t2 3.77824
R19542 a_72578_n314.n1 a_72578_n314.t3 11.0083
R19543 a_72578_n314.n2 a_72578_n314.n1 7.51324
R19544 a_72578_n314.n2 a_72578_n314.n0 5.39574
R19545 a_72578_n314.t2 a_72578_n314.n2 4.91248
R19546 a_72578_n314.n1 a_72578_n314.t4 4.12425
R19547 a_72578_n314.n0 a_72578_n314.t1 3.7821
R19548 a_72578_n314.n0 a_72578_n314.t0 3.77824
R19549 a_69966_n314.n1 a_69966_n314.t4 75.0252
R19550 a_69966_n314.n1 a_69966_n314.t5 44.0697
R19551 a_69966_n314.n2 a_69966_n314.t1 10.6055
R19552 a_69966_n314.n0 a_69966_n314.t3 10.6055
R19553 a_69966_n314.n0 a_69966_n314.n2 8.89791
R19554 a_69966_n314.n0 a_69966_n314.n1 5.7951
R19555 a_69966_n314.t0 a_69966_n314.n0 4.53117
R19556 a_69966_n314.n2 a_69966_n314.t2 4.53024
R19557 a_73050_n18422.n0 a_73050_n18422.t5 74.8588
R19558 a_73050_n18422.n0 a_73050_n18422.t6 44.2362
R19559 a_73050_n18422.n3 a_73050_n18422.n0 14.5242
R19560 a_73050_n18422.n3 a_73050_n18422.t3 11.0089
R19561 a_73050_n18422.n2 a_73050_n18422.n1 5.39574
R19562 a_73050_n18422.n2 a_73050_n18422.t1 4.91248
R19563 a_73050_n18422.t0 a_73050_n18422.n3 4.12612
R19564 a_73050_n18422.n1 a_73050_n18422.t2 3.7821
R19565 a_73050_n18422.n1 a_73050_n18422.t4 3.77824
R19566 a_73050_n18422.n0 a_73050_n18422.n2 1.83141
R19567 a_70890_n14314.n2 a_70890_n14314.t2 11.0089
R19568 a_70890_n14314.n2 a_70890_n14314.n1 7.28488
R19569 a_70890_n14314.n1 a_70890_n14314.n0 5.39574
R19570 a_70890_n14314.n1 a_70890_n14314.t4 4.91281
R19571 a_70890_n14314.t1 a_70890_n14314.n2 4.12554
R19572 a_70890_n14314.n0 a_70890_n14314.t3 3.7821
R19573 a_70890_n14314.n0 a_70890_n14314.t0 3.77824
R19574 a_40066_n18422.n1 a_40066_n18422.t4 75.0252
R19575 a_40066_n18422.n1 a_40066_n18422.t5 44.0697
R19576 a_40066_n18422.n2 a_40066_n18422.t1 10.6055
R19577 a_40066_n18422.n0 a_40066_n18422.t2 10.6055
R19578 a_40066_n18422.n0 a_40066_n18422.n2 8.89791
R19579 a_40066_n18422.n0 a_40066_n18422.n1 5.7951
R19580 a_40066_n18422.t0 a_40066_n18422.n0 4.53117
R19581 a_40066_n18422.n2 a_40066_n18422.t3 4.53024
R19582 a_14134_n18422.n1 a_14134_n18422.t4 75.0252
R19583 a_14134_n18422.n1 a_14134_n18422.t5 44.0697
R19584 a_14134_n18422.n0 a_14134_n18422.t0 11.0112
R19585 a_14134_n18422.n3 a_14134_n18422.t2 10.6055
R19586 a_14134_n18422.n3 a_14134_n18422.n2 9.81776
R19587 a_14134_n18422.n2 a_14134_n18422.n1 5.81441
R19588 a_14134_n18422.n2 a_14134_n18422.n0 4.64798
R19589 a_14134_n18422.t1 a_14134_n18422.n3 4.53117
R19590 a_14134_n18422.n0 a_14134_n18422.t3 4.12461
R19591 a_64736_n13850.n3 a_64736_n13850.t6 81.0083
R19592 a_64736_n13850.n3 a_64736_n13850.t2 80.9469
R19593 a_64736_n13850.n2 a_64736_n13850.t5 70.3153
R19594 a_64736_n13850.n0 a_64736_n13850.t3 54.8876
R19595 a_64736_n13850.n2 a_64736_n13850.t4 39.8548
R19596 a_64736_n13850.n0 a_64736_n13850.t7 16.7884
R19597 a_64736_n13850.n1 a_64736_n13850.n0 9.8148
R19598 a_64736_n13850.n1 a_64736_n13850.t0 5.96645
R19599 a_64736_n13850.n1 a_64736_n13850.n2 2.6989
R19600 a_64736_n13850.t1 a_64736_n13850.n1 2.52922
R19601 a_64736_n13850.n0 a_64736_n13850.n3 1.30877
R19602 a_134822_n13192.n0 a_134822_n13192.t3 86.4194
R19603 a_134822_n13192.n2 a_134822_n13192.t2 82.415
R19604 a_134822_n13192.n1 a_134822_n13192.t4 51.8534
R19605 a_134822_n13192.n0 a_134822_n13192.t5 51.8062
R19606 a_134822_n13192.n3 a_134822_n13192.t1 6.28457
R19607 a_134822_n13192.n2 a_134822_n13192.n1 4.1171
R19608 a_134822_n13192.n3 a_134822_n13192.n2 2.66254
R19609 a_134822_n13192.t0 a_134822_n13192.n3 2.21138
R19610 a_134822_n13192.n1 a_134822_n13192.n0 1.3775
R19611 a_140732_n13054.n1 a_140732_n13054.t4 75.0252
R19612 a_140732_n13054.n1 a_140732_n13054.t5 44.0697
R19613 a_140732_n13054.n2 a_140732_n13054.t0 10.6055
R19614 a_140732_n13054.n0 a_140732_n13054.t3 10.6055
R19615 a_140732_n13054.n0 a_140732_n13054.n2 8.89791
R19616 a_140732_n13054.n0 a_140732_n13054.n1 5.7951
R19617 a_140732_n13054.t1 a_140732_n13054.n0 4.53176
R19618 a_140732_n13054.n2 a_140732_n13054.t2 4.53041
R19619 D_C_5 D_C_5.n0 17.04
R19620 D_C_5.n0 D_C_5.t1 11.0083
R19621 D_C_5.n0 D_C_5.t0 4.12408
R19622 a_138678_n18422.n1 a_138678_n18422.t3 11.0083
R19623 a_138678_n18422.n2 a_138678_n18422.n1 7.51324
R19624 a_138678_n18422.n2 a_138678_n18422.n0 5.39574
R19625 a_138678_n18422.t1 a_138678_n18422.n2 4.91248
R19626 a_138678_n18422.n1 a_138678_n18422.t4 4.12425
R19627 a_138678_n18422.n0 a_138678_n18422.t2 3.7821
R19628 a_138678_n18422.n0 a_138678_n18422.t0 3.77824
R19629 a_3902_n82.n2 a_3902_n82.t4 82.7757
R19630 a_3902_n82.n3 a_3902_n82.t6 82.6424
R19631 a_3902_n82.n1 a_3902_n82.t5 70.3153
R19632 a_3902_n82.n2 a_3902_n82.t3 55.8264
R19633 a_3902_n82.n4 a_3902_n82.t2 51.5658
R19634 a_3902_n82.n1 a_3902_n82.t7 39.854
R19635 a_3902_n82.n0 a_3902_n82.t1 6.02308
R19636 a_3902_n82.n4 a_3902_n82.n3 3.9695
R19637 a_3902_n82.n0 a_3902_n82.n4 3.3953
R19638 a_3902_n82.n0 a_3902_n82.n1 2.70724
R19639 a_3902_n82.t0 a_3902_n82.n0 2.47208
R19640 a_3902_n82.n3 a_3902_n82.n2 1.3073
R19641 CK_11.n0 CK_11.t0 70.3153
R19642 CK_11.n0 CK_11.t1 39.854
R19643 CK_11 CK_11.n0 18.4666
R19644 a_9342_n4422.n0 a_9342_n4422.t5 74.8588
R19645 a_9342_n4422.n0 a_9342_n4422.t6 44.2362
R19646 a_9342_n4422.n0 a_9342_n4422.n2 14.5242
R19647 a_9342_n4422.n2 a_9342_n4422.t3 11.0089
R19648 a_9342_n4422.n3 a_9342_n4422.n1 5.39574
R19649 a_9342_n4422.t1 a_9342_n4422.n3 4.91281
R19650 a_9342_n4422.n2 a_9342_n4422.t2 4.12461
R19651 a_9342_n4422.n1 a_9342_n4422.t0 3.7821
R19652 a_9342_n4422.n1 a_9342_n4422.t4 3.77824
R19653 a_9342_n4422.n3 a_9342_n4422.n0 1.83141
R19654 a_96736_n13850.n3 a_96736_n13850.t7 81.0083
R19655 a_96736_n13850.n3 a_96736_n13850.t5 80.9469
R19656 a_96736_n13850.n2 a_96736_n13850.t4 70.3153
R19657 a_96736_n13850.n0 a_96736_n13850.t6 54.8876
R19658 a_96736_n13850.n2 a_96736_n13850.t3 39.8548
R19659 a_96736_n13850.n0 a_96736_n13850.t2 16.7884
R19660 a_96736_n13850.n1 a_96736_n13850.n0 9.8148
R19661 a_96736_n13850.n1 a_96736_n13850.t1 5.96645
R19662 a_96736_n13850.n1 a_96736_n13850.n2 2.6989
R19663 a_96736_n13850.t0 a_96736_n13850.n1 2.52922
R19664 a_96736_n13850.n0 a_96736_n13850.n3 1.30877
R19665 a_128736_n13096.n0 a_128736_n13096.t2 85.7547
R19666 a_128736_n13096.n2 a_128736_n13096.t5 70.3153
R19667 a_128736_n13096.n3 a_128736_n13096.t4 51.5027
R19668 a_128736_n13096.n3 a_128736_n13096.t7 51.1583
R19669 a_128736_n13096.n2 a_128736_n13096.t3 39.8548
R19670 a_128736_n13096.n0 a_128736_n13096.t6 24.4279
R19671 a_128736_n13096.n1 a_128736_n13096.n0 7.82327
R19672 a_128736_n13096.n1 a_128736_n13096.t1 5.96645
R19673 a_128736_n13096.n1 a_128736_n13096.n2 2.73467
R19674 a_128736_n13096.t0 a_128736_n13096.n1 2.52922
R19675 a_128736_n13096.n0 a_128736_n13096.n3 1.30714
R19676 a_132722_n82.n0 a_132722_n82.t2 86.4194
R19677 a_132722_n82.n2 a_132722_n82.t5 82.416
R19678 a_132722_n82.n1 a_132722_n82.t3 51.8544
R19679 a_132722_n82.n0 a_132722_n82.t4 51.8072
R19680 a_132722_n82.n3 a_132722_n82.t0 6.28457
R19681 a_132722_n82.n2 a_132722_n82.n1 4.1171
R19682 a_132722_n82.n3 a_132722_n82.n2 2.66253
R19683 a_132722_n82.t1 a_132722_n82.n3 2.21122
R19684 a_132722_n82.n1 a_132722_n82.n0 1.3775
R19685 a_142798_n314.n2 a_142798_n314.t2 11.0089
R19686 a_142798_n314.n2 a_142798_n314.n1 7.28488
R19687 a_142798_n314.n1 a_142798_n314.n0 5.39574
R19688 a_142798_n314.n1 a_142798_n314.t4 4.91248
R19689 a_142798_n314.t1 a_142798_n314.n2 4.12612
R19690 a_142798_n314.n0 a_142798_n314.t3 3.7821
R19691 a_142798_n314.n0 a_142798_n314.t0 3.77824
R19692 Bit_2 Bit_2.n2 14.6293
R19693 Bit_2.n2 Bit_2.t1 12.5331
R19694 Bit_2.n1 Bit_2.t2 10.8182
R19695 Bit_2.n0 Bit_2.t3 3.00189
R19696 Bit_2.n0 Bit_2.t0 2.94188
R19697 Bit_2.n2 Bit_2.n1 2.2505
R19698 Bit_2.n1 Bit_2.n0 1.37321
R19699 a_104578_n314.n2 a_104578_n314.t1 11.0083
R19700 a_104578_n314.n2 a_104578_n314.n1 7.51324
R19701 a_104578_n314.n1 a_104578_n314.n0 5.39574
R19702 a_104578_n314.n1 a_104578_n314.t4 4.91248
R19703 a_104578_n314.t0 a_104578_n314.n2 4.12559
R19704 a_104578_n314.n0 a_104578_n314.t3 3.7821
R19705 a_104578_n314.n0 a_104578_n314.t2 3.77824
R19706 a_101966_n314.n1 a_101966_n314.t5 75.0252
R19707 a_101966_n314.n1 a_101966_n314.t4 44.0697
R19708 a_101966_n314.n2 a_101966_n314.t2 10.6055
R19709 a_101966_n314.n0 a_101966_n314.t1 10.6055
R19710 a_101966_n314.n2 a_101966_n314.n0 8.89791
R19711 a_101966_n314.n0 a_101966_n314.n1 5.7951
R19712 a_101966_n314.t0 a_101966_n314.n2 4.53117
R19713 a_101966_n314.n0 a_101966_n314.t3 4.53024
R19714 a_n27396_n3162.n1 a_n27396_n3162.t4 75.0252
R19715 a_n27396_n3162.n1 a_n27396_n3162.t5 44.0697
R19716 a_n27396_n3162.n3 a_n27396_n3162.t2 11.0112
R19717 a_n27396_n3162.n0 a_n27396_n3162.t1 10.6055
R19718 a_n27396_n3162.n2 a_n27396_n3162.n0 9.81776
R19719 a_n27396_n3162.n2 a_n27396_n3162.n1 5.81341
R19720 a_n27396_n3162.n3 a_n27396_n3162.n2 4.64798
R19721 a_n27396_n3162.n0 a_n27396_n3162.t3 4.53041
R19722 a_n27396_n3162.t0 a_n27396_n3162.n3 4.12612
R19723 a_131902_n82.n2 a_131902_n82.t3 82.7757
R19724 a_131902_n82.n3 a_131902_n82.t5 82.6424
R19725 a_131902_n82.n1 a_131902_n82.t4 70.3153
R19726 a_131902_n82.n2 a_131902_n82.t6 55.8264
R19727 a_131902_n82.n4 a_131902_n82.t2 51.5658
R19728 a_131902_n82.n1 a_131902_n82.t7 39.854
R19729 a_131902_n82.n0 a_131902_n82.t1 6.02308
R19730 a_131902_n82.n4 a_131902_n82.n3 3.9695
R19731 a_131902_n82.n0 a_131902_n82.n4 3.3953
R19732 a_131902_n82.n0 a_131902_n82.n1 2.70724
R19733 a_131902_n82.t0 a_131902_n82.n0 2.47208
R19734 a_131902_n82.n3 a_131902_n82.n2 1.3073
R19735 D_C_6 D_C_6.n0 23.3373
R19736 D_C_6.n0 D_C_6.t1 11.0083
R19737 D_C_6.n0 D_C_6.t0 4.12425
R19738 a_11442_n14314.n0 a_11442_n14314.t5 74.8588
R19739 a_11442_n14314.n0 a_11442_n14314.t6 44.2362
R19740 a_11442_n14314.n0 a_11442_n14314.n2 14.5242
R19741 a_11442_n14314.n2 a_11442_n14314.t3 11.0089
R19742 a_11442_n14314.n3 a_11442_n14314.n1 5.39574
R19743 a_11442_n14314.t0 a_11442_n14314.n3 4.91281
R19744 a_11442_n14314.n2 a_11442_n14314.t2 4.12461
R19745 a_11442_n14314.n1 a_11442_n14314.t1 3.7821
R19746 a_11442_n14314.n1 a_11442_n14314.t4 3.77824
R19747 a_11442_n14314.n3 a_11442_n14314.n0 1.83141
R19748 a_2110_n80.n3 a_2110_n80.t4 81.0083
R19749 a_2110_n80.n3 a_2110_n80.t5 80.9469
R19750 a_2110_n80.n2 a_2110_n80.t6 70.3153
R19751 a_2110_n80.n0 a_2110_n80.t2 54.8886
R19752 a_2110_n80.n2 a_2110_n80.t7 39.854
R19753 a_2110_n80.n0 a_2110_n80.t3 16.7884
R19754 a_2110_n80.n1 a_2110_n80.n0 9.8148
R19755 a_2110_n80.n1 a_2110_n80.t1 5.96645
R19756 a_2110_n80.n1 a_2110_n80.n2 2.69789
R19757 a_2110_n80.t0 a_2110_n80.n1 2.52942
R19758 a_2110_n80.n0 a_2110_n80.n3 1.30877
R19759 a_n28098_n82.n2 a_n28098_n82.t3 82.7757
R19760 a_n28098_n82.n3 a_n28098_n82.t2 82.6424
R19761 a_n28098_n82.n1 a_n28098_n82.t4 70.3153
R19762 a_n28098_n82.n2 a_n28098_n82.t6 55.8264
R19763 a_n28098_n82.n4 a_n28098_n82.t7 51.5658
R19764 a_n28098_n82.n1 a_n28098_n82.t5 39.854
R19765 a_n28098_n82.n0 a_n28098_n82.t1 6.02308
R19766 a_n28098_n82.n4 a_n28098_n82.n3 3.9695
R19767 a_n28098_n82.n0 a_n28098_n82.n4 3.3953
R19768 a_n28098_n82.n0 a_n28098_n82.n1 2.70724
R19769 a_n28098_n82.t0 a_n28098_n82.n0 2.47208
R19770 a_n28098_n82.n3 a_n28098_n82.n2 1.3073
R19771 D_C_8 D_C_8.n0 23.3373
R19772 D_C_8.n0 D_C_8.t1 11.0083
R19773 D_C_8.n0 D_C_8.t0 4.12425
R19774 a_18854_1076.n0 a_18854_1076.t3 28.6634
R19775 a_18854_1076.n0 a_18854_1076.t1 11.2157
R19776 a_18854_1076.n1 a_18854_1076.t0 3.00172
R19777 a_18854_1076.t2 a_18854_1076.n1 2.9434
R19778 a_18854_1076.n1 a_18854_1076.n0 0.976737
R19779 a_114854_1076.n0 a_114854_1076.t3 28.6634
R19780 a_114854_1076.n0 a_114854_1076.t1 11.2157
R19781 a_114854_1076.n1 a_114854_1076.t2 3.00172
R19782 a_114854_1076.t0 a_114854_1076.n1 2.9434
R19783 a_114854_1076.n1 a_114854_1076.n0 0.976737
R19784 SAR_Asynchronous_Logic_8/D_reset_FF_0.Q.n2 SAR_Asynchronous_Logic_8/D_reset_FF_0.Q.t5 74.8588
R19785 SAR_Asynchronous_Logic_8/D_reset_FF_0.Q.n3 SAR_Asynchronous_Logic_8/D_reset_FF_0.Q.t4 70.3153
R19786 SAR_Asynchronous_Logic_8/D_reset_FF_0.Q.n2 SAR_Asynchronous_Logic_8/D_reset_FF_0.Q.t6 44.2362
R19787 SAR_Asynchronous_Logic_8/D_reset_FF_0.Q.n3 SAR_Asynchronous_Logic_8/D_reset_FF_0.Q.t3 39.854
R19788 SAR_Asynchronous_Logic_8/D_reset_FF_0.Q.n4 SAR_Asynchronous_Logic_8/D_reset_FF_0.Q.n0 11.62
R19789 SAR_Asynchronous_Logic_8/D_reset_FF_0.Q.n0 SAR_Asynchronous_Logic_8/D_reset_FF_0.Q.n1 5.39574
R19790 SAR_Asynchronous_Logic_8/D_reset_FF_0.Q.n0 SAR_Asynchronous_Logic_8/D_reset_FF_0.Q.t2 4.91248
R19791 SAR_Asynchronous_Logic_8/D_reset_FF_0.Q.n1 SAR_Asynchronous_Logic_8/D_reset_FF_0.Q.t1 3.7821
R19792 SAR_Asynchronous_Logic_8/D_reset_FF_0.Q.n1 SAR_Asynchronous_Logic_8/D_reset_FF_0.Q.t0 3.77824
R19793 SAR_Asynchronous_Logic_8/D_reset_FF_0.Q.n0 SAR_Asynchronous_Logic_8/D_reset_FF_0.Q.n2 3.04286
R19794 SAR_Asynchronous_Logic_8/D_reset_FF_0.Q SAR_Asynchronous_Logic_8/D_reset_FF_0.Q.n4 2.86313
R19795 SAR_Asynchronous_Logic_8/D_reset_FF_0.Q.n4 SAR_Asynchronous_Logic_8/D_reset_FF_0.Q.n3 2.84345
R19796 a_736_n13096.n0 a_736_n13096.t2 85.7547
R19797 a_736_n13096.n2 a_736_n13096.t7 70.3153
R19798 a_736_n13096.n3 a_736_n13096.t3 51.5027
R19799 a_736_n13096.n3 a_736_n13096.t6 51.1583
R19800 a_736_n13096.n2 a_736_n13096.t5 39.8548
R19801 a_736_n13096.n0 a_736_n13096.t4 24.4279
R19802 a_736_n13096.n1 a_736_n13096.n0 7.82327
R19803 a_736_n13096.n1 a_736_n13096.t0 5.96645
R19804 a_736_n13096.n1 a_736_n13096.n2 2.73467
R19805 a_736_n13096.t1 a_736_n13096.n1 2.52922
R19806 a_736_n13096.n0 a_736_n13096.n3 1.30714
R19807 Bit_0 Bit_0.n2 14.6289
R19808 Bit_0.n2 Bit_0.t3 12.5331
R19809 Bit_0.n1 Bit_0.t1 10.8182
R19810 Bit_0.n0 Bit_0.t2 3.00189
R19811 Bit_0.n0 Bit_0.t0 2.94188
R19812 Bit_0.n2 Bit_0.n1 2.2505
R19813 Bit_0.n1 Bit_0.n0 1.37321
R19814 a_16898_n18422.n2 a_16898_n18422.t4 11.0089
R19815 a_16898_n18422.n2 a_16898_n18422.n1 7.28488
R19816 a_16898_n18422.n1 a_16898_n18422.n0 5.39574
R19817 a_16898_n18422.n1 a_16898_n18422.t3 4.91248
R19818 a_16898_n18422.t1 a_16898_n18422.n2 4.12612
R19819 a_16898_n18422.n0 a_16898_n18422.t2 3.7821
R19820 a_16898_n18422.n0 a_16898_n18422.t0 3.77824
R19821 a_134822_n13946.n2 a_134822_n13946.t6 82.7757
R19822 a_134822_n13946.n3 a_134822_n13946.t4 82.6414
R19823 a_134822_n13946.n1 a_134822_n13946.t5 70.3153
R19824 a_134822_n13946.n2 a_134822_n13946.t7 55.8254
R19825 a_134822_n13946.n4 a_134822_n13946.t3 51.5648
R19826 a_134822_n13946.n1 a_134822_n13946.t2 39.8548
R19827 a_134822_n13946.n0 a_134822_n13946.t1 6.02308
R19828 a_134822_n13946.n4 a_134822_n13946.n3 3.9695
R19829 a_134822_n13946.n0 a_134822_n13946.n4 3.3953
R19830 a_134822_n13946.n0 a_134822_n13946.n1 2.70724
R19831 a_134822_n13946.t0 a_134822_n13946.n0 2.47188
R19832 a_134822_n13946.n3 a_134822_n13946.n2 1.3073
R19833 a_130110_n80.n3 a_130110_n80.t4 81.0083
R19834 a_130110_n80.n3 a_130110_n80.t5 80.9469
R19835 a_130110_n80.n2 a_130110_n80.t3 70.3153
R19836 a_130110_n80.n0 a_130110_n80.t2 54.8886
R19837 a_130110_n80.n2 a_130110_n80.t6 39.854
R19838 a_130110_n80.n0 a_130110_n80.t7 16.7884
R19839 a_130110_n80.n1 a_130110_n80.n0 9.8148
R19840 a_130110_n80.n1 a_130110_n80.t0 5.96645
R19841 a_130110_n80.n1 a_130110_n80.n2 2.69789
R19842 a_130110_n80.t1 a_130110_n80.n1 2.52942
R19843 a_130110_n80.n0 a_130110_n80.n3 1.30877
R19844 a_140918_n14314.n1 a_140918_n14314.t4 11.0083
R19845 a_140918_n14314.n2 a_140918_n14314.n1 7.51324
R19846 a_140918_n14314.n2 a_140918_n14314.n0 5.39574
R19847 a_140918_n14314.t1 a_140918_n14314.n2 4.91281
R19848 a_140918_n14314.n1 a_140918_n14314.t3 4.12408
R19849 a_140918_n14314.n0 a_140918_n14314.t2 3.7821
R19850 a_140918_n14314.n0 a_140918_n14314.t0 3.77824
R19851 a_100722_n3300.n0 a_100722_n3300.t4 86.4194
R19852 a_100722_n3300.n2 a_100722_n3300.t5 82.415
R19853 a_100722_n3300.n1 a_100722_n3300.t3 51.8534
R19854 a_100722_n3300.n0 a_100722_n3300.t2 51.8062
R19855 a_100722_n3300.n3 a_100722_n3300.t1 6.28457
R19856 a_100722_n3300.n2 a_100722_n3300.n1 4.1171
R19857 a_100722_n3300.n3 a_100722_n3300.n2 2.66254
R19858 a_100722_n3300.t0 a_100722_n3300.n3 2.21138
R19859 a_100722_n3300.n1 a_100722_n3300.n0 1.3775
R19860 a_82854_1076.n0 a_82854_1076.t3 28.6634
R19861 a_82854_1076.n0 a_82854_1076.t2 11.2157
R19862 a_82854_1076.n1 a_82854_1076.t1 3.00172
R19863 a_82854_1076.t0 a_82854_1076.n1 2.9434
R19864 a_82854_1076.n1 a_82854_1076.n0 0.976737
R19865 a_736_n13850.n3 a_736_n13850.t4 81.0083
R19866 a_736_n13850.n3 a_736_n13850.t2 80.9469
R19867 a_736_n13850.n2 a_736_n13850.t7 70.3153
R19868 a_736_n13850.n0 a_736_n13850.t3 54.8876
R19869 a_736_n13850.n2 a_736_n13850.t5 39.8548
R19870 a_736_n13850.n0 a_736_n13850.t6 16.7884
R19871 a_736_n13850.n1 a_736_n13850.n0 9.8148
R19872 a_736_n13850.n1 a_736_n13850.t0 5.96645
R19873 a_736_n13850.n1 a_736_n13850.n2 2.6989
R19874 a_736_n13850.t1 a_736_n13850.n1 2.52922
R19875 a_736_n13850.n0 a_736_n13850.n3 1.30877
R19876 a_130012_n13060.n0 a_130012_n13060.t3 28.6634
R19877 a_130012_n13060.n0 a_130012_n13060.t2 11.2157
R19878 a_130012_n13060.n1 a_130012_n13060.t1 3.00189
R19879 a_130012_n13060.t0 a_130012_n13060.n1 2.94281
R19880 a_130012_n13060.n1 a_130012_n13060.n0 0.976737
R19881 a_n27278_n82.n0 a_n27278_n82.t3 86.4194
R19882 a_n27278_n82.n2 a_n27278_n82.t5 82.416
R19883 a_n27278_n82.n1 a_n27278_n82.t4 51.8544
R19884 a_n27278_n82.n0 a_n27278_n82.t2 51.8072
R19885 a_n27278_n82.n3 a_n27278_n82.t1 6.28457
R19886 a_n27278_n82.n2 a_n27278_n82.n1 4.1171
R19887 a_n27278_n82.n3 a_n27278_n82.n2 2.66253
R19888 a_n27278_n82.t0 a_n27278_n82.n3 2.21122
R19889 a_n27278_n82.n1 a_n27278_n82.n0 1.3775
R19890 a_78798_n314.n2 a_78798_n314.t2 11.0089
R19891 a_78798_n314.n2 a_78798_n314.n1 7.28488
R19892 a_78798_n314.n1 a_78798_n314.n0 5.39574
R19893 a_78798_n314.n1 a_78798_n314.t3 4.91248
R19894 a_78798_n314.t0 a_78798_n314.n2 4.12612
R19895 a_78798_n314.n0 a_78798_n314.t4 3.7821
R19896 a_78798_n314.n0 a_78798_n314.t1 3.77824
R19897 a_73342_n4422.n0 a_73342_n4422.t5 74.8588
R19898 a_73342_n4422.n0 a_73342_n4422.t6 44.2362
R19899 a_73342_n4422.n0 a_73342_n4422.n2 14.5242
R19900 a_73342_n4422.n2 a_73342_n4422.t3 11.0089
R19901 a_73342_n4422.n3 a_73342_n4422.n1 5.39574
R19902 a_73342_n4422.t0 a_73342_n4422.n3 4.91281
R19903 a_73342_n4422.n2 a_73342_n4422.t2 4.12461
R19904 a_73342_n4422.n1 a_73342_n4422.t1 3.7821
R19905 a_73342_n4422.n1 a_73342_n4422.t4 3.77824
R19906 a_73342_n4422.n3 a_73342_n4422.n0 1.83141
R19907 a_38950_n314.n0 a_38950_n314.t6 74.8588
R19908 a_38950_n314.n0 a_38950_n314.t5 44.2362
R19909 a_38950_n314.n0 a_38950_n314.n2 14.5242
R19910 a_38950_n314.n2 a_38950_n314.t4 11.0089
R19911 a_38950_n314.n3 a_38950_n314.n1 5.39574
R19912 a_38950_n314.t1 a_38950_n314.n3 4.91248
R19913 a_38950_n314.n2 a_38950_n314.t2 4.12478
R19914 a_38950_n314.n1 a_38950_n314.t0 3.7821
R19915 a_38950_n314.n1 a_38950_n314.t3 3.77824
R19916 a_38950_n314.n3 a_38950_n314.n0 1.83141
R19917 a_68790_n4422.n2 a_68790_n4422.t1 11.0089
R19918 a_68790_n4422.n2 a_68790_n4422.n1 7.28488
R19919 a_68790_n4422.n1 a_68790_n4422.n0 5.39574
R19920 a_68790_n4422.n1 a_68790_n4422.t4 4.91281
R19921 a_68790_n4422.t2 a_68790_n4422.n2 4.12554
R19922 a_68790_n4422.n0 a_68790_n4422.t3 3.7821
R19923 a_68790_n4422.n0 a_68790_n4422.t0 3.77824
R19924 a_76918_n14314.n1 a_76918_n14314.t0 11.0083
R19925 a_76918_n14314.n2 a_76918_n14314.n1 7.51324
R19926 a_76918_n14314.n2 a_76918_n14314.n0 5.39574
R19927 a_76918_n14314.t1 a_76918_n14314.n2 4.91281
R19928 a_76918_n14314.n1 a_76918_n14314.t4 4.12408
R19929 a_76918_n14314.n0 a_76918_n14314.t2 3.7821
R19930 a_76918_n14314.n0 a_76918_n14314.t3 3.77824
R19931 CK_4.n0 CK_4.t1 70.3153
R19932 CK_4.n0 CK_4.t0 39.8548
R19933 CK_4 CK_4.n0 12.1445
R19934 a_68604_n3162.n1 a_68604_n3162.t4 75.0252
R19935 a_68604_n3162.n1 a_68604_n3162.t5 44.0697
R19936 a_68604_n3162.n3 a_68604_n3162.t2 11.0112
R19937 a_68604_n3162.n0 a_68604_n3162.t1 10.6055
R19938 a_68604_n3162.n2 a_68604_n3162.n0 9.81776
R19939 a_68604_n3162.n2 a_68604_n3162.n1 5.81341
R19940 a_68604_n3162.n3 a_68604_n3162.n2 4.64798
R19941 a_68604_n3162.n0 a_68604_n3162.t3 4.53041
R19942 a_68604_n3162.t0 a_68604_n3162.n3 4.12612
R19943 CK_3.n0 CK_3.t1 70.3153
R19944 CK_3.n0 CK_3.t0 39.8548
R19945 CK_3 CK_3.n0 12.1512
R19946 a_66012_n13060.n0 a_66012_n13060.t3 28.6634
R19947 a_66012_n13060.n0 a_66012_n13060.t0 11.2157
R19948 a_66012_n13060.n1 a_66012_n13060.t1 3.00189
R19949 a_66012_n13060.t2 a_66012_n13060.n1 2.94281
R19950 a_66012_n13060.n1 a_66012_n13060.n0 0.976737
R19951 Bit_1 Bit_1.n2 14.6289
R19952 Bit_1.n2 Bit_1.t2 12.5331
R19953 Bit_1.n1 Bit_1.t0 10.8182
R19954 Bit_1.n0 Bit_1.t3 3.00189
R19955 Bit_1.n0 Bit_1.t1 2.94188
R19956 Bit_1.n2 Bit_1.n1 2.2505
R19957 Bit_1.n1 Bit_1.n0 1.37321
R19958 a_104066_n18422.n1 a_104066_n18422.t4 75.0252
R19959 a_104066_n18422.n1 a_104066_n18422.t5 44.0697
R19960 a_104066_n18422.n2 a_104066_n18422.t1 10.6055
R19961 a_104066_n18422.n0 a_104066_n18422.t2 10.6055
R19962 a_104066_n18422.n0 a_104066_n18422.n2 8.89791
R19963 a_104066_n18422.n0 a_104066_n18422.n1 5.7951
R19964 a_104066_n18422.t0 a_104066_n18422.n0 4.53117
R19965 a_104066_n18422.n2 a_104066_n18422.t3 4.53024
R19966 a_n17202_n314.n2 a_n17202_n314.t2 11.0089
R19967 a_n17202_n314.n2 a_n17202_n314.n1 7.28488
R19968 a_n17202_n314.n1 a_n17202_n314.n0 5.39574
R19969 a_n17202_n314.n1 a_n17202_n314.t3 4.91248
R19970 a_n17202_n314.t1 a_n17202_n314.n2 4.12612
R19971 a_n17202_n314.n0 a_n17202_n314.t4 3.7821
R19972 a_n17202_n314.n0 a_n17202_n314.t0 3.77824
R19973 D_C_7 D_C_7.n0 23.3373
R19974 D_C_7.n0 D_C_7.t0 11.0083
R19975 D_C_7.n0 D_C_7.t1 4.12425
R19976 a_72066_n18422.n1 a_72066_n18422.t4 75.0252
R19977 a_72066_n18422.n1 a_72066_n18422.t5 44.0697
R19978 a_72066_n18422.n2 a_72066_n18422.t3 10.6055
R19979 a_72066_n18422.n0 a_72066_n18422.t0 10.6055
R19980 a_72066_n18422.n2 a_72066_n18422.n0 8.89791
R19981 a_72066_n18422.n0 a_72066_n18422.n1 5.7951
R19982 a_72066_n18422.t1 a_72066_n18422.n2 4.53117
R19983 a_72066_n18422.n0 a_72066_n18422.t2 4.53024
R19984 CK_6.n0 CK_6.t0 70.3153
R19985 CK_6.n0 CK_6.t1 39.854
R19986 CK_6 CK_6.n0 18.4706
R19987 Bit_6 Bit_6.n2 21.8158
R19988 Bit_6.n2 Bit_6.t2 12.5331
R19989 Bit_6.n1 Bit_6.t1 10.8182
R19990 Bit_6.n0 Bit_6.t0 3.00172
R19991 Bit_6.n0 Bit_6.t3 2.94206
R19992 Bit_6.n2 Bit_6.n1 2.2505
R19993 Bit_6.n1 Bit_6.n0 1.37321
R19994 a_100790_n4422.n2 a_100790_n4422.t2 11.0089
R19995 a_100790_n4422.n2 a_100790_n4422.n1 7.28488
R19996 a_100790_n4422.n1 a_100790_n4422.n0 5.39574
R19997 a_100790_n4422.n1 a_100790_n4422.t3 4.91281
R19998 a_100790_n4422.t0 a_100790_n4422.n2 4.12554
R19999 a_100790_n4422.n0 a_100790_n4422.t4 3.7821
R20000 a_100790_n4422.n0 a_100790_n4422.t1 3.77824
R20001 Bit_8 Bit_8.n2 21.8197
R20002 Bit_8.n2 Bit_8.t3 12.5331
R20003 Bit_8.n1 Bit_8.t1 10.8182
R20004 Bit_8.n0 Bit_8.t2 3.00172
R20005 Bit_8.n0 Bit_8.t0 2.94206
R20006 Bit_8.n2 Bit_8.n1 2.2505
R20007 Bit_8.n1 Bit_8.n0 1.37321
R20008 a_2012_n13060.n0 a_2012_n13060.t3 28.6634
R20009 a_2012_n13060.n0 a_2012_n13060.t0 11.2157
R20010 a_2012_n13060.n1 a_2012_n13060.t1 3.00189
R20011 a_2012_n13060.t2 a_2012_n13060.n1 2.94281
R20012 a_2012_n13060.n1 a_2012_n13060.n0 0.976737
R20013 CK_9.n0 CK_9.t0 70.3153
R20014 CK_9.n0 CK_9.t1 39.854
R20015 CK_9 CK_9.n0 18.4666
R20016 a_110798_n314.n2 a_110798_n314.t0 11.0089
R20017 a_110798_n314.n2 a_110798_n314.n1 7.28488
R20018 a_110798_n314.n1 a_110798_n314.n0 5.39574
R20019 a_110798_n314.n1 a_110798_n314.t4 4.91248
R20020 a_110798_n314.t2 a_110798_n314.n2 4.12612
R20021 a_110798_n314.n0 a_110798_n314.t3 3.7821
R20022 a_110798_n314.n0 a_110798_n314.t1 3.77824
R20023 D_C_1 D_C_1.n0 17.0373
R20024 D_C_1.n0 D_C_1.t0 11.0083
R20025 D_C_1.n0 D_C_1.t1 4.12408
R20026 CK_10.n0 CK_10.t0 70.3153
R20027 CK_10.n0 CK_10.t1 39.854
R20028 CK_10 CK_10.n0 18.4666
R20029 CK_5.n0 CK_5.t1 70.3153
R20030 CK_5.n0 CK_5.t0 39.8548
R20031 CK_5 CK_5.n0 12.1458
R20032 D_C_11 D_C_11.n0 23.3391
R20033 D_C_11.n0 D_C_11.t1 11.0083
R20034 D_C_11.n0 D_C_11.t0 4.12425
R20035 CK_1.n0 CK_1.t1 70.3153
R20036 CK_1.n0 CK_1.t0 39.8548
R20037 CK_1 CK_1.n0 12.1476
R20038 D_C_9 D_C_9.n0 23.3337
R20039 D_C_9.n0 D_C_9.t0 11.0083
R20040 D_C_9.n0 D_C_9.t1 4.12425
C0 a_38704_n13054# Reset 0.984662f
C1 SAR_Asynchronous_Logic_10/D_reset_FF_1.Q clks 0.187023f
C2 VDDD Bit_7 3.66321f
C3 VCM Bit_9 2.52491f
C4 CK_10 D_C_10 0.607776f
C5 Reset D_C_9 1.69398f
C6 Set Bit_8 0.505241f
C7 SAR_Asynchronous_Logic_10/D_reset_FF_0.Q Reset 1.97263f
C8 a_12034_n314# SAR_Asynchronous_Logic_3/D_reset_FF_1.Q 1.72539f
C9 SAR_Asynchronous_Logic_7/D_reset_FF_0.nQ Set 0.114786f
C10 SAR_Asynchronous_Logic_4/D_reset_FF_0.Q Set 1.08303f
C11 a_12034_n314# VDDD 1.99532f
C12 clks D_C_5 0.249677f
C13 Bit_5 CK_5 0.495743f
C14 a_78282_n13054# VDDD 0.638355f
C15 a_76034_n314# a_76182_n3162# 1.51e-19
C16 SAR_Asynchronous_Logic_10/D_reset_FF_0.Q SAR_Asynchronous_Logic_10/D_reset_FF_0.nQ 0.374416f
C17 SAR_Asynchronous_Logic_10/D_reset_FF_1.Q a_137702_n13054# 0.309485f
C18 a_104578_946# VDDD 0.638355f
C19 a_38950_946# Set 0.031756f
C20 a_143258_n17162# Reset 0.095228f
C21 a_147052_n4460# VDDD 0.821215f
C22 a_12034_n314# a_13158_946# 0.051153f
C23 D_C_10 clks 0.022253f
C24 Set D_C_2 0.590372f
C25 VDDD D_C_3 2.28872f
C26 CK_10 Bit_0 0.139023f
C27 SAR_Asynchronous_Logic_6/D_reset_FF_1.Q clks 0.187023f
C28 SAR_Asynchronous_Logic_8/D_reset_FF_1.Q Bit_3 0.76882f
C29 SAR_Asynchronous_Logic_2/D_reset_FF_1.Q clks 0.187023f
C30 SAR_Asynchronous_Logic_2/D_reset_FF_0.nQ VDDD 0.493779f
C31 a_41050_n17162# Reset 0.035956f
C32 a_6704_n13054# a_9702_n13054# 0.051153f
C33 D_C_5 CK_5 0.423906f
C34 SAR_Asynchronous_Logic_10/D_reset_FF_1.Q a_136062_n13054# 0.097922f
C35 a_n25050_946# Set 0.031756f
C36 a_111258_n17162# SAR_Asynchronous_Logic_8/D_reset_FF_0.Q 0.309485f
C37 VDDD D_C_11 3.81918f
C38 a_141810_n3162# VDDD 0.638355f
C39 a_80898_n17162# Set 0.03149f
C40 SAR_Asynchronous_Logic_8/D_reset_FF_1.Q Reset 0.825624f
C41 SAR_Asynchronous_Logic_3/D_reset_FF_0.Q out_10 0.142346f
C42 SAR_Asynchronous_Logic_5/D_reset_FF_0.Q Reset 2.18571f
C43 a_6704_n13054# a_10678_n17162# 1.51e-19
C44 Reset out_9 0.103985f
C45 VDDD out_7 0.62528f
C46 clks Bit_0 0.050875f
C47 Set out_2 1.40903f
C48 SAR_Asynchronous_Logic_10/D_reset_FF_0.Q a_144898_n17162# 0.097922f
C49 a_102950_946# VDDD 0.638355f
C50 SAR_Asynchronous_Logic_1/D_reset_FF_1.Q clks 0.187023f
C51 a_83052_n4460# clks 0.017217f
C52 a_140182_n3162# VDDD 0.638355f
C53 a_104062_n13054# Set 0.03149f
C54 a_69962_n3162# Set 0.03149f
C55 VDDD D_C_7 4.55388f
C56 Reset CK_8 1.00176f
C57 Set D_C_8 1.1523f
C58 VCM D_C_9 1.11867f
C59 a_129966_n18540# VDDD 0.821215f
C60 SAR_Asynchronous_Logic_9/D_reset_FF_1.Q Reset 0.825624f
C61 a_48898_n17162# VDDD 0.638355f
C62 a_39602_n3162# VDDD 0.638355f
C63 SAR_Asynchronous_Logic_4/D_reset_FF_1.Q Reset 0.825624f
C64 SAR_Asynchronous_Logic_0/D_reset_FF_1.Q clks 0.187023f
C65 CK_7 out_3 0.00736f
C66 Bit_7 out_7 0.230932f
C67 SAR_Asynchronous_Logic_10/D_reset_FF_1.Q a_134704_n13054# 1.72539f
C68 SAR_Asynchronous_Logic_2/D_reset_FF_1.Q a_41702_n13054# 0.309485f
C69 a_111910_n13054# clks 0.001362f
C70 a_138678_n17162# Reset 0.03149f
C71 SAR_Asynchronous_Logic_6/D_reset_FF_0.nQ Reset 0.006269f
C72 a_45810_n3162# Reset 0.035956f
C73 SAR_Asynchronous_Logic_3/D_reset_FF_0.nQ Set 0.114786f
C74 a_109158_946# Reset 0.061452f
C75 VCM Bit_1 2.31579f
C76 Reset CK_2 0.479771f
C77 SAR_Asynchronous_Logic_4/D_reset_FF_0.Q SAR_Asynchronous_Logic_4/D_reset_FF_0.nQ 0.374416f
C78 CK_9 clks 0.022253f
C79 VDDD Bit_3 3.52357f
C80 a_37962_n3162# VDDD 0.638355f
C81 SAR_Asynchronous_Logic_10/D_reset_FF_0.Q Bit_5 0.001811f
C82 a_8062_n13054# Set 0.03149f
C83 SAR_Asynchronous_Logic_7/D_reset_FF_1.nQ a_70704_n13054# 0.039104f
C84 SAR_Asynchronous_Logic_7/D_reset_FF_1.Q Bit_2 0.76882f
C85 SAR_Asynchronous_Logic_8/D_reset_FF_0.Q Set 1.08303f
C86 SAR_Asynchronous_Logic_2/D_reset_FF_1.Q a_40062_n13054# 0.097922f
C87 SAR_Asynchronous_Logic_9/D_reset_FF_0.Q a_103602_n3162# 0.309485f
C88 SAR_Asynchronous_Logic_3/D_reset_FF_1.Q Reset 0.825624f
C89 CK_3 out_3 0.257296f
C90 a_102704_n13054# Set 1.2872f
C91 a_44182_n3162# Reset 0.03149f
C92 a_102704_n13054# a_106678_n17162# 1.51e-19
C93 SAR_Asynchronous_Logic_8/D_reset_FF_0.Q out_4 0.145264f
C94 CK_11 Set 0.097437f
C95 VDDD Reset 0.164043p
C96 a_65966_n18540# clks 0.017217f
C97 a_108034_n314# Reset 0.984662f
C98 a_73702_n13054# VDDD 0.638355f
C99 a_15910_n13054# clks 0.001362f
C100 a_6950_946# Reset 0.035956f
C101 SAR_Asynchronous_Logic_0/D_reset_FF_0.nQ VDDD 0.493779f
C102 Set out_3 1.40903f
C103 D_C_10 out_10 0.046364f
C104 VDDD out_6 0.62528f
C105 CK_7 CK_3 0.296999f
C106 Reset out_8 0.103985f
C107 clks CK_1 0.022253f
C108 SAR_Asynchronous_Logic_10/D_reset_FF_0.Q D_C_5 0.173058f
C109 SAR_Asynchronous_Logic_9/D_reset_FF_0.Q a_101962_n3162# 0.097922f
C110 SAR_Asynchronous_Logic_8/D_reset_FF_0.Q Bit_6 0.001811f
C111 SAR_Asynchronous_Logic_10/D_reset_FF_0.nQ VDDD 0.493779f
C112 a_13158_946# Reset 0.061452f
C113 a_137050_n17162# Reset 0.035956f
C114 a_79910_n13054# Reset 0.035956f
C115 SAR_Asynchronous_Logic_7/D_reset_FF_0.Q VDDD 4.94322f
C116 a_9050_n17162# Set 0.070513f
C117 a_72062_n13054# VDDD 0.638355f
C118 SAR_Asynchronous_Logic_4/D_reset_FF_0.Q a_16898_n17162# 0.097922f
C119 Reset Bit_7 0.54269f
C120 VDDD CK_6 2.64399f
C121 Bit_9 CK_9 0.432659f
C122 VCM CK_8 0.894295f
C123 Set CK_7 0.509253f
C124 a_6704_n13054# Set 1.2872f
C125 SAR_Asynchronous_Logic_2/D_reset_FF_1.Q a_38704_n13054# 1.72539f
C126 SAR_Asynchronous_Logic_8/D_reset_FF_1.Q SAR_Asynchronous_Logic_8/D_reset_FF_1.nQ 0.59306f
C127 SAR_Asynchronous_Logic_0/D_reset_FF_0.Q out_11 0.142346f
C128 SAR_Asynchronous_Logic_1/D_reset_FF_0.Q Set 1.23193f
C129 a_12034_n314# Reset 0.984662f
C130 SAR_Asynchronous_Logic_5/D_reset_FF_0.Q SAR_Asynchronous_Logic_5/D_reset_FF_0.nQ 0.374416f
C131 D_C_7 out_7 0.046364f
C132 a_78282_n13054# Reset 0.03149f
C133 a_79258_n17162# VDDD 0.638355f
C134 SAR_Asynchronous_Logic_8/D_reset_FF_0.Q D_C_4 0.173058f
C135 SAR_Asynchronous_Logic_7/D_reset_FF_0.Q Bit_7 0.001811f
C136 a_104578_946# Reset 0.03149f
C137 SAR_Asynchronous_Logic_9/D_reset_FF_1.Q SAR_Asynchronous_Logic_9/D_reset_FF_1.nQ 0.59306f
C138 Set CK_3 0.057025f
C139 Bit_8 clks 0.050875f
C140 Bit_9 CK_1 0.495743f
C141 VDDD CK_4 1.15692f
C142 Reset D_C_3 1.04538f
C143 a_19052_n4460# Set 5.24e-19
C144 a_135602_n3162# VDDD 0.638355f
C145 a_144898_n17162# VDDD 0.638355f
C146 a_142798_946# Set 0.03149f
C147 SAR_Asynchronous_Logic_7/D_reset_FF_0.nQ clks 5.5e-19
C148 SAR_Asynchronous_Logic_2/D_reset_FF_1.Q Bit_1 0.76882f
C149 SAR_Asynchronous_Logic_2/D_reset_FF_0.nQ Reset 0.006269f
C150 SAR_Asynchronous_Logic_4/D_reset_FF_0.Q clks 0.090182f
C151 SAR_Asynchronous_Logic_3/D_reset_FF_0.Q VDDD 4.94322f
C152 a_70704_n13054# VDDD 1.99532f
C153 VDDD VCM 33.4341f
C154 D_C_11 Reset 1.6946f
C155 a_141810_n3162# Reset 0.035956f
C156 SAR_Asynchronous_Logic_7/D_reset_FF_0.Q D_C_3 0.173058f
C157 SAR_Asynchronous_Logic_0/D_reset_FF_0.Q a_n24398_n3162# 0.309485f
C158 SAR_Asynchronous_Logic_9/D_reset_FF_0.nQ Set 0.114786f
C159 SAR_Asynchronous_Logic_2/D_reset_FF_0.Q Bit_8 0.001811f
C160 SAR_Asynchronous_Logic_7/D_reset_FF_1.Q Set 0.877082f
C161 a_13810_n3162# Set 0.070513f
C162 a_133962_n3162# VDDD 0.638355f
C163 Set out_4 1.40903f
C164 Reset out_7 0.103985f
C165 D_C_1 CK_1 0.423733f
C166 Bit_9 out_1 2.06776f
C167 clks D_C_2 0.27193f
C168 D_C_7 Bit_3 0.687474f
C169 a_n12948_n4460# VDDD 0.821215f
C170 SAR_Asynchronous_Logic_9/D_reset_FF_1.nQ VDDD 0.684985f
C171 a_102950_946# Reset 0.035956f
C172 SAR_Asynchronous_Logic_9/D_reset_FF_1.Q a_110798_946# 0.097922f
C173 a_108034_n314# SAR_Asynchronous_Logic_9/D_reset_FF_1.nQ 0.039104f
C174 a_46798_946# Set 0.03149f
C175 a_140182_n3162# Reset 0.03149f
C176 SAR_Asynchronous_Logic_0/D_reset_FF_0.Q a_n26038_n3162# 0.097922f
C177 CK_9 D_C_9 0.607776f
C178 VCM Bit_7 2.52491f
C179 VDDD Bit_5 3.6391f
C180 Reset D_C_7 1.69398f
C181 Set Bit_6 0.505241f
C182 SAR_Asynchronous_Logic_4/D_reset_FF_1.Q SAR_Asynchronous_Logic_4/D_reset_FF_1.nQ 0.59306f
C183 a_80898_n17162# clks 0.024625f
C184 SAR_Asynchronous_Logic_8/D_reset_FF_1.nQ VDDD 0.684985f
C185 SAR_Asynchronous_Logic_2/D_reset_FF_0.Q D_C_2 0.173058f
C186 a_74678_n17162# VDDD 0.638355f
C187 SAR_Asynchronous_Logic_5/D_reset_FF_1.Q Set 0.877082f
C188 SAR_Asynchronous_Logic_5/D_reset_FF_0.nQ VDDD 0.493779f
C189 a_39602_n3162# Reset 0.095228f
C190 SAR_Asynchronous_Logic_4/D_reset_FF_0.Q Bit_9 0.001811f
C191 a_1966_n18540# Set 5.24e-19
C192 a_n18190_n3162# VDDD 0.638355f
C193 D_C_1 out_1 0.010097f
C194 a_n17202_946# Set 0.03149f
C195 Bit_6 out_4 2.06776f
C196 SAR_Asynchronous_Logic_3/D_reset_FF_1.Q SAR_Asynchronous_Logic_3/D_reset_FF_1.nQ 0.59306f
C197 SAR_Asynchronous_Logic_10/D_reset_FF_1.Q VDDD 9.51131f
C198 a_105050_n17162# Set 0.070513f
C199 SAR_Asynchronous_Logic_3/D_reset_FF_1.nQ VDDD 0.684985f
C200 CK_9 Bit_1 0.139023f
C201 Set D_C_4 0.590314f
C202 VDDD D_C_5 2.28872f
C203 D_C_8 clks 0.022253f
C204 a_143910_n13054# Set 0.031756f
C205 a_n19818_n3162# VDDD 0.638355f
C206 SAR_Asynchronous_Logic_2/D_reset_FF_0.Q out_2 0.145264f
C207 SAR_Asynchronous_Logic_6/D_reset_FF_0.Q Set 1.23193f
C208 a_110798_946# VDDD 0.638355f
C209 SAR_Asynchronous_Logic_4/D_reset_FF_0.Q D_C_1 0.173058f
C210 SAR_Asynchronous_Logic_1/D_reset_FF_1.Q a_51052_n4460# 1.30266f
C211 SAR_Asynchronous_Logic_4/D_reset_FF_1.Q Bit_0 0.76882f
C212 SAR_Asynchronous_Logic_4/D_reset_FF_1.nQ VDDD 0.684985f
C213 D_C_4 out_4 0.010097f
C214 VDDD D_C_10 4.55388f
C215 Set Bit_10 0.519371f
C216 SAR_Asynchronous_Logic_6/D_reset_FF_1.Q VDDD 9.51131f
C217 a_73702_n13054# Reset 0.061452f
C218 a_73050_n17162# VDDD 0.638355f
C219 a_76034_n314# Set 1.2872f
C220 a_147052_n4460# Bit_5 0.198503f
C221 SAR_Asynchronous_Logic_2/D_reset_FF_1.Q VDDD 9.51131f
C222 a_115052_n4460# Set 5.24e-19
C223 SAR_Asynchronous_Logic_0/D_reset_FF_0.nQ Reset 0.006269f
C224 clks Bit_2 0.050875f
C225 Reset out_6 0.103895f
C226 Set out_5 1.40903f
C227 CK_9 out_9 0.254741f
C228 SAR_Asynchronous_Logic_2/D_reset_FF_1.Q a_33966_n18540# 1.30266f
C229 SAR_Asynchronous_Logic_10/D_reset_FF_0.nQ Reset 0.006269f
C230 SAR_Asynchronous_Logic_6/D_reset_FF_0.Q Bit_6 6.07e-19
C231 SAR_Asynchronous_Logic_8/D_reset_FF_0.Q clks 0.090182f
C232 SAR_Asynchronous_Logic_3/D_reset_FF_1.Q a_14798_946# 0.097922f
C233 a_12034_n314# SAR_Asynchronous_Logic_3/D_reset_FF_1.nQ 0.039104f
C234 a_77158_946# SAR_Asynchronous_Logic_5/D_reset_FF_1.Q 0.309485f
C235 SAR_Asynchronous_Logic_9/D_reset_FF_0.Q VDDD 4.94322f
C236 SAR_Asynchronous_Logic_7/D_reset_FF_0.Q Reset 1.97263f
C237 a_47910_n13054# Set 0.031756f
C238 SAR_Asynchronous_Logic_4/D_reset_FF_0.nQ Set 0.114786f
C239 a_14798_946# VDDD 0.638355f
C240 a_141158_946# VDDD 0.638355f
C241 Reset CK_6 1.00111f
C242 VDDD Bit_0 3.52357f
C243 VCM D_C_7 1.11867f
C244 Set D_C_6 1.1523f
C245 a_109810_n3162# Set 0.070513f
C246 SAR_Asynchronous_Logic_8/D_reset_FF_0.Q SAR_Asynchronous_Logic_8/D_reset_FF_0.nQ 0.374416f
C247 SAR_Asynchronous_Logic_1/D_reset_FF_1.Q VDDD 9.51131f
C248 a_115052_n4460# Bit_6 0.198503f
C249 CK_6 out_6 0.254741f
C250 a_76034_n314# SAR_Asynchronous_Logic_5/D_reset_FF_1.Q 1.72539f
C251 a_79258_n17162# Reset 0.095228f
C252 a_83052_n4460# VDDD 0.821215f
C253 SAR_Asynchronous_Logic_9/D_reset_FF_0.Q Bit_7 6.07e-19
C254 a_140034_n314# VDDD 1.99532f
C255 SAR_Asynchronous_Logic_0/D_reset_FF_1.Q VDDD 9.51131f
C256 SAR_Asynchronous_Logic_6/D_reset_FF_1.Q a_147052_n4460# 1.30266f
C257 VCM Bit_3 2.31579f
C258 CK_7 clks 0.022253f
C259 Reset CK_4 0.479771f
C260 VDDD out_11 0.675109f
C261 a_79258_n17162# SAR_Asynchronous_Logic_7/D_reset_FF_0.Q 0.309485f
C262 a_45158_946# VDDD 0.638355f
C263 a_135602_n3162# Reset 0.095228f
C264 a_111910_n13054# VDDD 0.638355f
C265 a_76034_n314# a_77158_946# 0.051153f
C266 a_97966_n18540# Set 5.24e-19
C267 a_77810_n3162# VDDD 0.638355f
C268 a_16898_n17162# Set 0.03149f
C269 SAR_Asynchronous_Logic_3/D_reset_FF_0.Q Reset 2.18571f
C270 a_83052_n4460# Bit_7 0.198503f
C271 a_70704_n13054# Reset 0.984662f
C272 Reset VCM 18.4582f
C273 VDDD CK_9 2.64399f
C274 Set CK_10 0.509253f
C275 a_70704_n13054# a_73702_n13054# 0.051153f
C276 a_n18842_946# VDDD 0.638355f
C277 SAR_Asynchronous_Logic_10/D_reset_FF_1.Q a_129966_n18540# 1.30266f
C278 a_44034_n314# a_44182_n3162# 1.51e-19
C279 SAR_Asynchronous_Logic_5/D_reset_FF_0.Q Bit_8 6.07e-19
C280 SAR_Asynchronous_Logic_8/D_reset_FF_0.Q a_112898_n17162# 0.097922f
C281 a_44034_n314# VDDD 1.99532f
C282 a_110282_n13054# VDDD 0.638355f
C283 a_76182_n3162# VDDD 0.638355f
C284 CK_6 CK_4 0.296999f
C285 clks CK_3 0.022253f
C286 a_19052_n4460# clks 0.017217f
C287 a_5962_n3162# Set 0.03149f
C288 SAR_Asynchronous_Logic_6/D_reset_FF_0.Q D_C_6 0.160963f
C289 a_136578_946# VDDD 0.638355f
C290 a_70950_946# Set 0.031756f
C291 a_65966_n18540# VDDD 0.821215f
C292 a_15910_n13054# VDDD 0.638355f
C293 a_n24398_n3162# VDDD 0.638355f
C294 SAR_Asynchronous_Logic_0/D_reset_FF_0.Q CK_11 0.052385f
C295 a_n19966_n314# VDDD 1.99532f
C296 a_51052_n4460# Bit_8 0.198503f
C297 Bit_8 CK_8 0.432659f
C298 Set clks 6.68937f
C299 VDDD CK_1 1.15692f
C300 VCM CK_6 0.894295f
C301 Reset Bit_5 0.533611f
C302 SAR_Asynchronous_Logic_9/D_reset_FF_0.Q out_7 0.142346f
C303 SAR_Asynchronous_Logic_7/D_reset_FF_1.Q clks 0.187023f
C304 SAR_Asynchronous_Logic_5/D_reset_FF_0.nQ Reset 0.006269f
C305 a_74678_n17162# Reset 0.03149f
C306 SAR_Asynchronous_Logic_1/D_reset_FF_0.Q Bit_9 6.07e-19
C307 a_n18190_n3162# Reset 0.035956f
C308 a_14282_n13054# VDDD 0.638355f
C309 SAR_Asynchronous_Logic_9/D_reset_FF_0.Q D_C_7 0.160969f
C310 SAR_Asynchronous_Logic_10/D_reset_FF_1.Q Reset 0.825624f
C311 a_n26038_n3162# VDDD 0.638355f
C312 SAR_Asynchronous_Logic_8/D_reset_FF_0.nQ Set 0.114786f
C313 SAR_Asynchronous_Logic_8/D_reset_FF_1.Q a_105702_n13054# 0.309485f
C314 SAR_Asynchronous_Logic_2/D_reset_FF_0.Q Set 1.08303f
C315 a_40578_946# VDDD 0.638355f
C316 SAR_Asynchronous_Logic_5/D_reset_FF_0.Q a_71602_n3162# 0.309485f
C317 Bit_8 CK_2 0.495743f
C318 Reset D_C_5 1.04538f
C319 D_C_11 out_11 0.046364f
C320 Bit_6 clks 0.050875f
C321 VDDD out_1 1.23807f
C322 Set CK_5 0.057025f
C323 a_19052_n4460# Bit_9 0.198503f
C324 a_n19818_n3162# Reset 0.03149f
C325 a_134950_946# VDDD 0.638355f
C326 SAR_Asynchronous_Logic_5/D_reset_FF_1.Q clks 0.187023f
C327 a_1966_n18540# clks 0.017217f
C328 a_136062_n13054# Set 0.03149f
C329 SAR_Asynchronous_Logic_10/D_reset_FF_1.nQ a_134704_n13054# 0.039104f
C330 a_140034_n314# a_140182_n3162# 1.51e-19
C331 a_n23422_946# VDDD 0.638355f
C332 SAR_Asynchronous_Logic_8/D_reset_FF_1.Q a_104062_n13054# 0.097922f
C333 Reset D_C_10 1.69398f
C334 Bit_10 CK_10 0.432659f
C335 Set Bit_9 0.505241f
C336 VDDD Bit_8 3.66321f
C337 SAR_Asynchronous_Logic_6/D_reset_FF_1.Q Reset 0.825624f
C338 SAR_Asynchronous_Logic_5/D_reset_FF_0.Q a_69962_n3162# 0.097922f
C339 a_73050_n17162# Reset 0.035956f
C340 SAR_Asynchronous_Logic_7/D_reset_FF_0.nQ VDDD 0.493779f
C341 SAR_Asynchronous_Logic_5/D_reset_FF_0.Q D_C_8 0.160969f
C342 SAR_Asynchronous_Logic_2/D_reset_FF_1.Q Reset 0.825624f
C343 SAR_Asynchronous_Logic_4/D_reset_FF_0.Q VDDD 4.94322f
C344 D_C_6 Bit_4 0.687474f
C345 clks D_C_4 0.271995f
C346 Bit_8 out_8 0.230932f
C347 D_C_2 CK_2 0.423906f
C348 CK_8 out_2 0.00736f
C349 a_143910_n13054# clks 0.001362f
C350 a_112898_n17162# Set 0.03149f
C351 SAR_Asynchronous_Logic_9/D_reset_FF_0.Q Reset 2.18571f
C352 a_38950_946# VDDD 0.638355f
C353 SAR_Asynchronous_Logic_0/D_reset_FF_0.Q Set 1.23193f
C354 a_141158_946# Reset 0.061452f
C355 SAR_Asynchronous_Logic_1/D_reset_FF_0.Q SAR_Asynchronous_Logic_1/D_reset_FF_0.nQ 0.374416f
C356 Set D_C_1 0.590604f
C357 a_40062_n13054# Set 0.03149f
C358 VCM Bit_5 2.51205f
C359 CK_8 D_C_8 0.607776f
C360 Bit_10 clks 0.050875f
C361 VDDD D_C_2 2.28872f
C362 a_15258_n17162# VDDD 0.638355f
C363 a_70704_n13054# a_74678_n17162# 1.51e-19
C364 SAR_Asynchronous_Logic_1/D_reset_FF_0.Q D_C_9 0.160969f
C365 SAR_Asynchronous_Logic_1/D_reset_FF_1.Q Reset 0.825624f
C366 a_134704_n13054# Set 1.2872f
C367 a_115052_n4460# clks 0.017217f
C368 CK_2 out_2 0.257296f
C369 a_101962_n3162# Set 0.03149f
C370 a_n25050_946# VDDD 0.638355f
C371 SAR_Asynchronous_Logic_8/D_reset_FF_1.Q a_102704_n13054# 1.72539f
C372 SAR_Asynchronous_Logic_4/D_reset_FF_1.Q a_9702_n13054# 0.309485f
C373 a_140034_n314# Reset 0.984662f
C374 a_105702_n13054# VDDD 0.638355f
C375 a_47910_n13054# clks 0.001362f
C376 a_80898_n17162# VDDD 0.638355f
C377 a_71602_n3162# VDDD 0.638355f
C378 SAR_Asynchronous_Logic_0/D_reset_FF_1.Q Reset 0.825624f
C379 Set out_10 0.085924f
C380 CK_8 Bit_2 0.139023f
C381 Reset out_11 0.10371f
C382 VDDD out_2 1.23807f
C383 D_C_6 clks 0.022253f
C384 a_45158_946# Reset 0.061452f
C385 a_111910_n13054# Reset 0.035956f
C386 a_77810_n3162# Reset 0.035956f
C387 SAR_Asynchronous_Logic_2/D_reset_FF_1.nQ a_38704_n13054# 0.039104f
C388 SAR_Asynchronous_Logic_1/D_reset_FF_0.nQ Set 0.114786f
C389 SAR_Asynchronous_Logic_3/D_reset_FF_0.Q D_C_10 0.160969f
C390 CK_5 out_5 0.257296f
C391 SAR_Asynchronous_Logic_4/D_reset_FF_1.Q a_8062_n13054# 0.097922f
C392 a_104062_n13054# VDDD 0.638355f
C393 a_69962_n3162# VDDD 0.638355f
C394 a_38704_n13054# Set 1.2872f
C395 VDDD D_C_8 4.55388f
C396 Reset CK_9 1.00176f
C397 Set D_C_9 1.1523f
C398 VCM D_C_10 1.11867f
C399 SAR_Asynchronous_Logic_10/D_reset_FF_0.Q Set 1.08303f
C400 a_n18842_946# Reset 0.061452f
C401 a_44034_n314# Reset 0.984662f
C402 a_9702_n13054# VDDD 0.638355f
C403 a_110282_n13054# Reset 0.03149f
C404 D_C_8 out_8 0.046364f
C405 clks Bit_4 0.050875f
C406 a_76182_n3162# Reset 0.03149f
C407 a_97966_n18540# clks 0.017217f
C408 a_136578_946# Reset 0.03149f
C409 SAR_Asynchronous_Logic_1/D_reset_FF_0.Q out_9 0.142346f
C410 a_16898_n17162# clks 0.024625f
C411 a_15910_n13054# Reset 0.035956f
C412 a_10678_n17162# VDDD 0.638355f
C413 SAR_Asynchronous_Logic_3/D_reset_FF_0.nQ VDDD 0.493779f
C414 a_n24398_n3162# Reset 0.095228f
C415 a_n19966_n314# Reset 0.984662f
C416 CK_10 clks 0.022253f
C417 Reset CK_1 0.479771f
C418 VCM Bit_0 2.31579f
C419 VDDD Bit_2 3.52357f
C420 a_8062_n13054# VDDD 0.638355f
C421 SAR_Asynchronous_Logic_6/D_reset_FF_1.Q Bit_5 0.76882f
C422 a_8578_946# VDDD 0.638355f
C423 SAR_Asynchronous_Logic_8/D_reset_FF_0.Q VDDD 4.94322f
C424 a_41050_n17162# Set 0.070513f
C425 SAR_Asynchronous_Logic_4/D_reset_FF_1.Q a_6704_n13054# 1.72539f
C426 SAR_Asynchronous_Logic_7/D_reset_FF_1.Q SAR_Asynchronous_Logic_7/D_reset_FF_1.nQ 0.59306f
C427 a_102704_n13054# VDDD 1.99532f
C428 a_14282_n13054# Reset 0.03149f
C429 VDDD CK_11 3.28783f
C430 SAR_Asynchronous_Logic_8/D_reset_FF_1.Q Set 0.877082f
C431 SAR_Asynchronous_Logic_5/D_reset_FF_0.Q Set 1.23193f
C432 a_40578_946# Reset 0.03149f
C433 SAR_Asynchronous_Logic_5/D_reset_FF_1.Q SAR_Asynchronous_Logic_5/D_reset_FF_1.nQ 0.59306f
C434 a_111258_n17162# VDDD 0.638355f
C435 Set out_9 0.085924f
C436 VDDD out_3 1.23807f
C437 Bit_10 out_10 0.230932f
C438 Reset out_1 1.01942f
C439 SAR_Asynchronous_Logic_6/D_reset_FF_1.nQ VDDD 0.684985f
C440 a_134950_946# Reset 0.035956f
C441 a_78798_946# Set 0.03149f
C442 a_9050_n17162# VDDD 0.638355f
C443 SAR_Asynchronous_Logic_0/D_reset_FF_1.Q a_n12948_n4460# 1.30266f
C444 a_n23422_946# Reset 0.03149f
C445 a_51052_n4460# Set 5.24e-19
C446 VCM CK_9 0.894295f
C447 Reset Bit_8 0.54269f
C448 VDDD CK_7 2.64399f
C449 Set CK_8 0.509253f
C450 a_6704_n13054# VDDD 1.99532f
C451 SAR_Asynchronous_Logic_10/D_reset_FF_1.nQ VDDD 0.684985f
C452 SAR_Asynchronous_Logic_7/D_reset_FF_0.nQ Reset 0.006269f
C453 SAR_Asynchronous_Logic_2/D_reset_FF_0.Q clks 0.090182f
C454 SAR_Asynchronous_Logic_9/D_reset_FF_1.Q Set 0.877082f
C455 SAR_Asynchronous_Logic_1/D_reset_FF_0.Q VDDD 4.94322f
C456 SAR_Asynchronous_Logic_4/D_reset_FF_0.Q Reset 1.97263f
C457 SAR_Asynchronous_Logic_4/D_reset_FF_1.Q Set 0.877082f
C458 Bit_7 out_3 2.06776f
C459 SAR_Asynchronous_Logic_10/D_reset_FF_0.Q out_5 0.145264f
C460 SAR_Asynchronous_Logic_6/D_reset_FF_0.nQ Set 0.114786f
C461 a_45810_n3162# Set 0.070513f
C462 a_38950_946# Reset 0.035956f
C463 SAR_Asynchronous_Logic_1/D_reset_FF_1.nQ VDDD 0.684985f
C464 SAR_Asynchronous_Logic_7/D_reset_FF_0.Q SAR_Asynchronous_Logic_7/D_reset_FF_0.nQ 0.374416f
C465 SAR_Asynchronous_Logic_3/D_reset_FF_1.Q a_19052_n4460# 1.30266f
C466 SAR_Asynchronous_Logic_5/D_reset_FF_1.Q a_78798_946# 0.097922f
C467 a_76034_n314# SAR_Asynchronous_Logic_5/D_reset_FF_1.nQ 0.039104f
C468 a_141158_946# SAR_Asynchronous_Logic_6/D_reset_FF_1.Q 0.309485f
C469 Bit_7 CK_7 0.432659f
C470 Set CK_2 0.057025f
C471 Reset D_C_2 1.04538f
C472 Bit_9 clks 0.050875f
C473 VDDD CK_3 1.15692f
C474 D_C_10 Bit_0 0.687474f
C475 a_19052_n4460# VDDD 0.821215f
C476 a_15258_n17162# Reset 0.095228f
C477 SAR_Asynchronous_Logic_9/D_reset_FF_1.Q Bit_6 0.76882f
C478 a_142798_946# VDDD 0.638355f
C479 SAR_Asynchronous_Logic_2/D_reset_FF_1.nQ VDDD 0.684985f
C480 SAR_Asynchronous_Logic_3/D_reset_FF_1.Q Set 0.877082f
C481 D_C_3 out_3 0.010097f
C482 a_n25050_946# Reset 0.035956f
C483 SAR_Asynchronous_Logic_0/D_reset_FF_1.nQ VDDD 0.684985f
C484 a_112898_n17162# clks 0.024625f
C485 CK_11 D_C_11 0.795115f
C486 SAR_Asynchronous_Logic_4/D_reset_FF_1.Q a_1966_n18540# 1.30266f
C487 VDDD Set 72.457504f
C488 a_105702_n13054# Reset 0.061452f
C489 SAR_Asynchronous_Logic_9/D_reset_FF_0.nQ VDDD 0.493779f
C490 a_47258_n17162# SAR_Asynchronous_Logic_2/D_reset_FF_0.Q 0.309485f
C491 a_106678_n17162# VDDD 0.638355f
C492 a_108034_n314# Set 1.2872f
C493 a_71602_n3162# Reset 0.095228f
C494 a_140034_n314# SAR_Asynchronous_Logic_6/D_reset_FF_1.Q 1.72539f
C495 SAR_Asynchronous_Logic_7/D_reset_FF_1.Q VDDD 9.51131f
C496 a_13810_n3162# VDDD 0.638355f
C497 a_33966_n18540# Set 5.24e-19
C498 a_6950_946# Set 0.031756f
C499 VCM out_1 0.282477f
C500 VDDD out_4 1.23807f
C501 CK_10 out_10 0.254741f
C502 clks D_C_1 0.271669f
C503 Bit_7 CK_3 0.495743f
C504 Set out_8 0.085924f
C505 Reset out_2 1.01942f
C506 a_137050_n17162# Set 0.070513f
C507 a_79910_n13054# Set 0.031756f
C508 a_46798_946# VDDD 0.638355f
C509 SAR_Asynchronous_Logic_7/D_reset_FF_0.Q a_80898_n17162# 0.097922f
C510 a_140034_n314# a_141158_946# 0.051153f
C511 Reset D_C_8 1.69398f
C512 VDDD Bit_6 3.66321f
C513 Set Bit_7 0.505241f
C514 a_12182_n3162# VDDD 0.638355f
C515 VCM Bit_8 2.52491f
C516 SAR_Asynchronous_Logic_6/D_reset_FF_0.Q SAR_Asynchronous_Logic_6/D_reset_FF_0.nQ 0.374416f
C517 SAR_Asynchronous_Logic_5/D_reset_FF_1.Q VDDD 9.51131f
C518 a_9702_n13054# Reset 0.061452f
C519 a_1966_n18540# VDDD 0.821215f
C520 a_12034_n314# Set 1.2872f
C521 a_134704_n13054# a_137702_n13054# 0.051153f
C522 a_n17202_946# VDDD 0.638355f
C523 CK_7 out_7 0.254741f
C524 D_C_3 CK_3 0.423906f
C525 a_n19966_n314# a_n19818_n3162# 1.51e-19
C526 SAR_Asynchronous_Logic_9/D_reset_FF_1.Q a_115052_n4460# 1.30266f
C527 a_105050_n17162# VDDD 0.638355f
C528 a_45158_946# SAR_Asynchronous_Logic_1/D_reset_FF_1.Q 0.309485f
C529 a_10678_n17162# Reset 0.03149f
C530 SAR_Asynchronous_Logic_3/D_reset_FF_0.nQ Reset 0.006269f
C531 a_147052_n4460# Set 5.24e-19
C532 D_C_9 clks 0.022253f
C533 VDDD D_C_4 2.2887f
C534 Set D_C_3 0.590372f
C535 CK_7 D_C_7 0.607776f
C536 a_77158_946# VDDD 0.638355f
C537 SAR_Asynchronous_Logic_10/D_reset_FF_0.Q clks 0.090182f
C538 a_143910_n13054# VDDD 0.638355f
C539 a_8578_946# Reset 0.03149f
C540 SAR_Asynchronous_Logic_6/D_reset_FF_0.Q VDDD 4.94322f
C541 SAR_Asynchronous_Logic_8/D_reset_FF_0.Q Reset 1.97263f
C542 SAR_Asynchronous_Logic_5/D_reset_FF_1.Q Bit_7 0.76882f
C543 SAR_Asynchronous_Logic_2/D_reset_FF_0.nQ Set 0.114786f
C544 SAR_Asynchronous_Logic_8/D_reset_FF_1.Q a_97966_n18540# 1.30266f
C545 a_12034_n314# a_12182_n3162# 1.51e-19
C546 a_102704_n13054# Reset 0.984662f
C547 SAR_Asynchronous_Logic_1/D_reset_FF_0.Q a_39602_n3162# 0.309485f
C548 a_44034_n314# SAR_Asynchronous_Logic_1/D_reset_FF_1.Q 1.72539f
C549 CK_11 Reset 0.549075f
C550 D_C_11 Set 1.26739f
C551 VDDD Bit_10 3.75744f
C552 a_141810_n3162# Set 0.070513f
C553 a_76034_n314# VDDD 1.99532f
C554 a_142282_n13054# VDDD 0.638355f
C555 a_111258_n17162# Reset 0.095228f
C556 a_115052_n4460# VDDD 0.821215f
C557 Reset out_3 1.01942f
C558 VCM out_2 0.282477f
C559 clks Bit_1 0.050875f
C560 Set out_7 0.085924f
C561 VDDD out_5 1.23807f
C562 CK_7 Bit_3 0.139023f
C563 SAR_Asynchronous_Logic_10/D_reset_FF_0.Q CK_5 0.060028f
C564 a_n18842_946# SAR_Asynchronous_Logic_0/D_reset_FF_1.Q 0.309485f
C565 SAR_Asynchronous_Logic_8/D_reset_FF_0.Q CK_6 1.02e-19
C566 SAR_Asynchronous_Logic_1/D_reset_FF_0.Q a_37962_n3162# 0.097922f
C567 a_102950_946# Set 0.031756f
C568 a_47910_n13054# VDDD 0.638355f
C569 a_44034_n314# a_45158_946# 0.051153f
C570 SAR_Asynchronous_Logic_4/D_reset_FF_0.nQ VDDD 0.493779f
C571 a_9050_n17162# Reset 0.035956f
C572 VCM D_C_8 1.11867f
C573 VDDD D_C_6 4.55388f
C574 Reset CK_7 1.00176f
C575 Set D_C_7 1.1523f
C576 a_6704_n13054# Reset 0.984662f
C577 SAR_Asynchronous_Logic_7/D_reset_FF_0.Q out_3 0.145264f
C578 SAR_Asynchronous_Logic_8/D_reset_FF_1.Q clks 0.187023f
C579 a_129966_n18540# Set 5.24e-19
C580 a_109810_n3162# VDDD 0.638355f
C581 a_38704_n13054# a_41702_n13054# 0.051153f
C582 a_48898_n17162# Set 0.03149f
C583 a_n19966_n314# SAR_Asynchronous_Logic_0/D_reset_FF_1.Q 1.72539f
C584 SAR_Asynchronous_Logic_1/D_reset_FF_0.Q Reset 2.18571f
C585 a_46282_n13054# VDDD 0.638355f
C586 SAR_Asynchronous_Logic_3/D_reset_FF_0.Q SAR_Asynchronous_Logic_3/D_reset_FF_0.nQ 0.374416f
C587 SAR_Asynchronous_Logic_8/D_reset_FF_0.Q CK_4 0.060028f
C588 SAR_Asynchronous_Logic_7/D_reset_FF_0.Q CK_7 1.02e-19
C589 a_72578_946# VDDD 0.638355f
C590 a_51052_n4460# clks 0.017217f
C591 a_108182_n3162# VDDD 0.638355f
C592 VCM Bit_2 2.31579f
C593 VDDD Bit_4 3.52357f
C594 Reset CK_3 0.479771f
C595 CK_8 clks 0.051836f
C596 a_n19966_n314# a_n18842_946# 0.051153f
C597 CK_9 CK_1 0.296999f
C598 a_37962_n3162# Set 0.03149f
C599 a_108034_n314# a_108182_n3162# 1.51e-19
C600 SAR_Asynchronous_Logic_9/D_reset_FF_1.Q clks 0.187023f
C601 a_97966_n18540# VDDD 0.821215f
C602 SAR_Asynchronous_Logic_1/D_reset_FF_1.Q Bit_8 0.76882f
C603 SAR_Asynchronous_Logic_4/D_reset_FF_1.Q clks 0.187023f
C604 a_16898_n17162# VDDD 0.638355f
C605 a_7602_n3162# VDDD 0.638355f
C606 Set Reset 22.4786f
C607 VDDD CK_10 2.64399f
C608 SAR_Asynchronous_Logic_7/D_reset_FF_0.Q CK_3 0.060028f
C609 SAR_Asynchronous_Logic_9/D_reset_FF_0.nQ Reset 0.006269f
C610 a_106678_n17162# Reset 0.03149f
C611 SAR_Asynchronous_Logic_2/D_reset_FF_0.Q CK_8 1.02e-19
C612 SAR_Asynchronous_Logic_7/D_reset_FF_1.Q Reset 0.825624f
C613 a_13810_n3162# Reset 0.035956f
C614 SAR_Asynchronous_Logic_7/D_reset_FF_1.Q a_73702_n13054# 0.309485f
C615 SAR_Asynchronous_Logic_0/D_reset_FF_0.nQ Set 0.114786f
C616 Set out_6 0.085924f
C617 Bit_9 out_9 0.230932f
C618 CK_9 out_1 0.00736f
C619 Reset out_4 1.01942f
C620 VCM out_3 0.282477f
C621 clks CK_2 0.022253f
C622 a_5962_n3162# VDDD 0.638355f
C623 SAR_Asynchronous_Logic_10/D_reset_FF_0.nQ Set 0.114786f
C624 a_38704_n13054# a_42678_n17162# 1.51e-19
C625 SAR_Asynchronous_Logic_7/D_reset_FF_0.Q Set 1.08303f
C626 a_70950_946# VDDD 0.638355f
C627 SAR_Asynchronous_Logic_3/D_reset_FF_1.Q clks 0.187023f
C628 a_72062_n13054# Set 0.03149f
C629 SAR_Asynchronous_Logic_8/D_reset_FF_1.nQ a_102704_n13054# 0.039104f
C630 a_12182_n3162# Reset 0.03149f
C631 Set CK_6 0.509253f
C632 VCM CK_7 0.894295f
C633 VDDD clks 9.10386f
C634 Reset Bit_6 0.542608f
C635 SAR_Asynchronous_Logic_7/D_reset_FF_1.Q a_72062_n13054# 0.097922f
C636 SAR_Asynchronous_Logic_2/D_reset_FF_0.Q CK_2 0.060028f
C637 a_33966_n18540# clks 0.017217f
C638 SAR_Asynchronous_Logic_5/D_reset_FF_1.Q Reset 0.825624f
C639 SAR_Asynchronous_Logic_4/D_reset_FF_0.Q CK_9 1.02e-19
C640 Bit_6 out_6 0.230932f
C641 CK_1 out_1 0.257296f
C642 CK_6 out_4 0.00736f
C643 a_137702_n13054# VDDD 0.638355f
C644 a_79910_n13054# clks 0.001362f
C645 a_105050_n17162# Reset 0.035956f
C646 SAR_Asynchronous_Logic_8/D_reset_FF_0.nQ VDDD 0.493779f
C647 SAR_Asynchronous_Logic_2/D_reset_FF_0.Q VDDD 4.94322f
C648 a_143258_n17162# SAR_Asynchronous_Logic_10/D_reset_FF_0.Q 0.309485f
C649 VDDD CK_5 1.15692f
C650 Reset D_C_4 1.04531f
C651 Bit_6 CK_6 0.432659f
C652 D_C_9 Bit_1 0.687474f
C653 Set CK_4 0.057025f
C654 Bit_7 clks 0.050875f
C655 a_77158_946# Reset 0.061452f
C656 a_143910_n13054# Reset 0.035956f
C657 a_144898_n17162# Set 0.03149f
C658 SAR_Asynchronous_Logic_6/D_reset_FF_0.Q Reset 2.18544f
C659 SAR_Asynchronous_Logic_4/D_reset_FF_0.Q CK_1 0.060028f
C660 SAR_Asynchronous_Logic_3/D_reset_FF_1.Q Bit_9 0.76882f
C661 SAR_Asynchronous_Logic_3/D_reset_FF_0.Q Set 1.23193f
C662 CK_4 out_4 0.257296f
C663 a_136062_n13054# VDDD 0.638355f
C664 a_70704_n13054# Set 1.2872f
C665 SAR_Asynchronous_Logic_6/D_reset_FF_0.Q out_6 0.142346f
C666 a_47258_n17162# VDDD 0.638355f
C667 Set VCM 13.8031f
C668 Reset Bit_10 0.52845f
C669 VDDD Bit_9 3.66321f
C670 SAR_Asynchronous_Logic_7/D_reset_FF_1.Q a_70704_n13054# 1.72539f
C671 SAR_Asynchronous_Logic_10/D_reset_FF_1.Q SAR_Asynchronous_Logic_10/D_reset_FF_1.nQ 0.59306f
C672 a_76034_n314# Reset 0.984662f
C673 a_41702_n13054# VDDD 0.638355f
C674 a_147052_n4460# clks 0.017217f
C675 a_142282_n13054# Reset 0.03149f
C676 a_133962_n3162# Set 0.03149f
C677 a_134704_n13054# a_138678_n17162# 1.51e-19
C678 clks D_C_3 0.299213f
C679 Reset out_5 1.01942f
C680 Bit_6 CK_4 0.495743f
C681 VCM out_4 0.282477f
C682 D_C_9 out_9 0.046364f
C683 a_129966_n18540# Bit_4 0.198503f
C684 SAR_Asynchronous_Logic_6/D_reset_FF_0.Q CK_6 0.052385f
C685 a_n12948_n4460# Set 5.24e-19
C686 a_112898_n17162# VDDD 0.638355f
C687 a_103602_n3162# VDDD 0.638355f
C688 SAR_Asynchronous_Logic_4/D_reset_FF_0.Q out_1 0.145264f
C689 SAR_Asynchronous_Logic_6/D_reset_FF_1.Q SAR_Asynchronous_Logic_6/D_reset_FF_1.nQ 0.59306f
C690 a_47910_n13054# Reset 0.035956f
C691 SAR_Asynchronous_Logic_4/D_reset_FF_0.nQ Reset 0.006269f
C692 SAR_Asynchronous_Logic_4/D_reset_FF_1.nQ a_6704_n13054# 0.039104f
C693 SAR_Asynchronous_Logic_0/D_reset_FF_0.Q VDDD 4.94409f
C694 VDDD D_C_1 2.2888f
C695 a_40062_n13054# VDDD 0.638355f
C696 VCM Bit_6 2.52491f
C697 Reset D_C_6 1.6946f
C698 Set Bit_5 0.505241f
C699 a_109810_n3162# Reset 0.035956f
C700 SAR_Asynchronous_Logic_5/D_reset_FF_0.nQ Set 0.114786f
C701 a_n18190_n3162# Set 0.070513f
C702 a_134704_n13054# VDDD 1.99532f
C703 D_C_6 out_6 0.046364f
C704 D_C_4 CK_4 0.423854f
C705 a_101962_n3162# VDDD 0.638355f
C706 SAR_Asynchronous_Logic_2/D_reset_FF_0.Q SAR_Asynchronous_Logic_2/D_reset_FF_0.nQ 0.374416f
C707 a_46282_n13054# Reset 0.03149f
C708 a_97966_n18540# Bit_3 0.198503f
C709 SAR_Asynchronous_Logic_10/D_reset_FF_1.Q Set 0.877082f
C710 SAR_Asynchronous_Logic_6/D_reset_FF_0.Q a_135602_n3162# 0.309485f
C711 SAR_Asynchronous_Logic_9/D_reset_FF_0.Q CK_7 0.052385f
C712 a_72578_946# Reset 0.03149f
C713 a_108182_n3162# Reset 0.03149f
C714 CK_11 out_11 0.254741f
C715 Set D_C_5 0.590372f
C716 D_C_7 clks 0.022253f
C717 VDDD out_10 0.62528f
C718 CK_6 D_C_6 0.607776f
C719 a_129966_n18540# clks 0.017217f
C720 a_140034_n314# SAR_Asynchronous_Logic_6/D_reset_FF_1.nQ 0.039104f
C721 a_48898_n17162# clks 0.024625f
C722 a_110798_946# Set 0.03149f
C723 SAR_Asynchronous_Logic_6/D_reset_FF_1.Q a_142798_946# 0.097922f
C724 a_15258_n17162# SAR_Asynchronous_Logic_4/D_reset_FF_0.Q 0.309485f
C725 SAR_Asynchronous_Logic_1/D_reset_FF_0.nQ VDDD 0.493779f
C726 a_42678_n17162# VDDD 0.638355f
C727 a_7602_n3162# Reset 0.095228f
C728 SAR_Asynchronous_Logic_3/D_reset_FF_0.Q Bit_10 6.07e-19
C729 SAR_Asynchronous_Logic_6/D_reset_FF_0.Q a_133962_n3162# 0.097922f
C730 SAR_Asynchronous_Logic_2/D_reset_FF_1.Q SAR_Asynchronous_Logic_2/D_reset_FF_1.nQ 0.59306f
C731 a_38704_n13054# VDDD 1.99532f
C732 Bit_10 VCM 2.85473f
C733 Set D_C_10 1.1523f
C734 VDDD D_C_9 4.55388f
C735 Reset CK_10 1.00176f
C736 SAR_Asynchronous_Logic_6/D_reset_FF_1.Q Set 0.877082f
C737 SAR_Asynchronous_Logic_10/D_reset_FF_0.Q VDDD 4.94322f
C738 a_65966_n18540# Bit_2 0.198503f
C739 SAR_Asynchronous_Logic_5/D_reset_FF_0.Q CK_8 0.052385f
C740 a_73050_n17162# Set 0.070513f
C741 SAR_Asynchronous_Logic_2/D_reset_FF_1.Q Set 0.877082f
C742 SAR_Asynchronous_Logic_2/D_reset_FF_0.Q a_48898_n17162# 0.097922f
C743 CK_6 Bit_4 0.139023f
C744 clks Bit_3 0.050875f
C745 Bit_8 out_2 2.06776f
C746 VCM out_5 0.282477f
C747 SAR_Asynchronous_Logic_1/D_reset_FF_1.Q SAR_Asynchronous_Logic_1/D_reset_FF_1.nQ 0.59306f
C748 a_n12948_n4460# Bit_10 0.198503f
C749 SAR_Asynchronous_Logic_9/D_reset_FF_0.Q Set 1.23193f
C750 SAR_Asynchronous_Logic_5/D_reset_FF_1.nQ VDDD 0.684985f
C751 a_70950_946# Reset 0.035956f
C752 SAR_Asynchronous_Logic_9/D_reset_FF_0.Q SAR_Asynchronous_Logic_9/D_reset_FF_0.nQ 0.374416f
C753 a_143258_n17162# VDDD 0.638355f
C754 SAR_Asynchronous_Logic_0/D_reset_FF_0.Q D_C_11 0.160963f
C755 a_14798_946# Set 0.03149f
C756 Reset clks 3.2435f
C757 VDDD Bit_1 3.52357f
C758 VCM D_C_6 1.11867f
C759 a_33966_n18540# Bit_1 0.198503f
C760 SAR_Asynchronous_Logic_7/D_reset_FF_1.nQ VDDD 0.684985f
C761 SAR_Asynchronous_Logic_1/D_reset_FF_0.Q CK_9 0.052385f
C762 a_41050_n17162# VDDD 0.638355f
C763 SAR_Asynchronous_Logic_1/D_reset_FF_1.Q Set 0.877082f
C764 D_C_2 out_2 0.010097f
C765 Bit_5 out_5 2.06776f
C766 a_83052_n4460# Set 5.24e-19
C767 a_137702_n13054# Reset 0.061452f
C768 SAR_Asynchronous_Logic_7/D_reset_FF_0.Q clks 0.104048f
C769 SAR_Asynchronous_Logic_8/D_reset_FF_0.nQ Reset 0.006269f
C770 a_140034_n314# Set 1.2872f
C771 SAR_Asynchronous_Logic_8/D_reset_FF_1.Q VDDD 9.51131f
C772 SAR_Asynchronous_Logic_5/D_reset_FF_0.Q VDDD 4.94322f
C773 SAR_Asynchronous_Logic_2/D_reset_FF_0.Q Reset 1.97263f
C774 SAR_Asynchronous_Logic_0/D_reset_FF_1.Q SAR_Asynchronous_Logic_0/D_reset_FF_1.nQ 0.59306f
C775 SAR_Asynchronous_Logic_0/D_reset_FF_1.Q Set 0.877082f
C776 VDDD out_9 0.62528f
C777 VCM Bit_4 2.31579f
C778 CK_8 CK_2 0.296999f
C779 CK_6 clks 0.022253f
C780 Set out_11 0.085924f
C781 Reset CK_5 0.479771f
C782 SAR_Asynchronous_Logic_1/D_reset_FF_1.Q a_46798_946# 0.097922f
C783 a_44034_n314# SAR_Asynchronous_Logic_1/D_reset_FF_1.nQ 0.039104f
C784 SAR_Asynchronous_Logic_3/D_reset_FF_0.Q a_7602_n3162# 0.309485f
C785 a_109158_946# SAR_Asynchronous_Logic_9/D_reset_FF_1.Q 0.309485f
C786 SAR_Asynchronous_Logic_5/D_reset_FF_0.Q out_8 0.142346f
C787 a_111910_n13054# Set 0.031756f
C788 a_77810_n3162# Set 0.070513f
C789 a_78798_946# VDDD 0.638355f
C790 a_1966_n18540# Bit_0 0.198503f
C791 SAR_Asynchronous_Logic_3/D_reset_FF_0.Q CK_10 0.052385f
C792 D_C_5 out_5 0.010097f
C793 a_47258_n17162# Reset 0.095228f
C794 a_51052_n4460# VDDD 0.821215f
C795 VDDD CK_8 2.64399f
C796 VCM CK_10 0.894295f
C797 Set CK_9 0.509253f
C798 Reset Bit_9 0.54269f
C799 SAR_Asynchronous_Logic_5/D_reset_FF_1.Q a_83052_n4460# 1.30266f
C800 SAR_Asynchronous_Logic_9/D_reset_FF_1.Q VDDD 9.51131f
C801 a_41702_n13054# Reset 0.061452f
C802 a_44034_n314# Set 1.2872f
C803 a_108034_n314# SAR_Asynchronous_Logic_9/D_reset_FF_1.Q 1.72539f
C804 SAR_Asynchronous_Logic_3/D_reset_FF_0.Q a_5962_n3162# 0.097922f
C805 SAR_Asynchronous_Logic_4/D_reset_FF_1.Q VDDD 9.51131f
C806 clks CK_4 0.022253f
C807 CK_8 out_8 0.254741f
C808 a_144898_n17162# clks 0.024625f
C809 a_138678_n17162# VDDD 0.638355f
C810 SAR_Asynchronous_Logic_6/D_reset_FF_0.nQ VDDD 0.493779f
C811 a_103602_n3162# Reset 0.095228f
C812 a_n19966_n314# SAR_Asynchronous_Logic_0/D_reset_FF_1.nQ 0.039104f
C813 a_65966_n18540# Set 5.24e-19
C814 SAR_Asynchronous_Logic_0/D_reset_FF_1.Q a_n17202_946# 0.097922f
C815 a_45810_n3162# VDDD 0.638355f
C816 a_15910_n13054# Set 0.031756f
C817 SAR_Asynchronous_Logic_0/D_reset_FF_0.Q Reset 2.18538f
C818 SAR_Asynchronous_Logic_7/D_reset_FF_1.Q a_65966_n18540# 1.30266f
C819 a_n19966_n314# Set 1.2872f
C820 a_109158_946# VDDD 0.638355f
C821 Reset D_C_1 1.04568f
C822 Set CK_1 0.057025f
C823 VDDD CK_2 1.15692f
C824 VCM clks 0.775976f
C825 SAR_Asynchronous_Logic_10/D_reset_FF_1.Q Bit_4 0.76882f
C826 a_108034_n314# a_109158_946# 0.051153f
C827 SAR_Asynchronous_Logic_0/D_reset_FF_0.Q SAR_Asynchronous_Logic_0/D_reset_FF_0.nQ 0.374416f
C828 a_134704_n13054# Reset 0.984662f
C829 SAR_Asynchronous_Logic_3/D_reset_FF_1.Q VDDD 9.51131f
C830 a_102704_n13054# a_105702_n13054# 0.051153f
C831 a_n12948_n4460# clks 0.017217f
C832 a_44182_n3162# VDDD 0.638355f
C833 a_n26038_n3162# Set 0.03149f
C834 a_108034_n314# VDDD 1.99532f
C835 a_33966_n18540# VDDD 0.821215f
C836 SAR_Asynchronous_Logic_0/D_reset_FF_1.Q Bit_10 0.76882f
C837 a_13158_946# SAR_Asynchronous_Logic_3/D_reset_FF_1.Q 0.309485f
C838 a_6950_946# VDDD 0.638355f
C839 Reset out_10 0.103985f
C840 Set out_1 1.40903f
C841 D_C_8 Bit_2 0.687474f
C842 VDDD out_8 0.62528f
C843 a_13158_946# VDDD 0.638355f
C844 a_137050_n17162# VDDD 0.638355f
C845 a_134950_946# Set 0.031756f
C846 a_79910_n13054# VDDD 0.638355f
C847 a_42678_n17162# Reset 0.03149f
C848 SAR_Asynchronous_Logic_1/D_reset_FF_0.nQ Reset 0.006269f
C849 out_5 VSSD 5.66625f
C850 out_6 VSSD 2.10284f
C851 out_4 VSSD 5.66608f
C852 out_7 VSSD 2.10284f
C853 out_3 VSSD 5.66608f
C854 out_8 VSSD 2.10284f
C855 out_2 VSSD 5.66608f
C856 out_9 VSSD 2.10284f
C857 out_1 VSSD 5.66608f
C858 out_10 VSSD 1.10284f
C859 out_11 VSSD 2.33873f
C860 CK_5 VSSD 6.71665f
C861 D_C_5 VSSD 7.62926f
C862 Bit_4 VSSD 7.033221f
C863 CK_4 VSSD 6.40415f
C864 D_C_4 VSSD 7.62963f
C865 Bit_3 VSSD 7.032923f
C866 CK_3 VSSD 6.40411f
C867 D_C_3 VSSD 7.62932f
C868 Bit_2 VSSD 7.033162f
C869 CK_2 VSSD 6.40411f
C870 D_C_2 VSSD 7.62926f
C871 Bit_1 VSSD 7.033189f
C872 CK_1 VSSD 6.40445f
C873 D_C_1 VSSD 7.6294f
C874 Bit_0 VSSD 7.033188f
C875 clks VSSD 0.415542p
C876 Bit_5 VSSD 11.69254f
C877 D_C_6 VSSD 13.67399f
C878 CK_6 VSSD 12.72823f
C879 Bit_6 VSSD 11.05792f
C880 D_C_7 VSSD 13.67439f
C881 CK_7 VSSD 12.727929f
C882 Bit_7 VSSD 11.05782f
C883 D_C_8 VSSD 13.67439f
C884 CK_8 VSSD 12.69233f
C885 Bit_8 VSSD 11.057391f
C886 D_C_9 VSSD 13.67476f
C887 CK_9 VSSD 12.72803f
C888 Bit_9 VSSD 11.05782f
C889 D_C_10 VSSD 13.15031f
C890 CK_10 VSSD 12.603164f
C891 VCM VSSD 0.197144p
C892 Bit_10 VSSD 12.02301f
C893 Reset VSSD 0.198239p
C894 Set VSSD 0.281827p
C895 D_C_11 VSSD 13.52816f
C896 CK_11 VSSD 13.07709f
C897 VDDD VSSD 2.972935p
C898 SAR_Asynchronous_Logic_10/D_reset_FF_0.nQ VSSD 0.727272f
C899 a_144898_n17162# VSSD 4.87e-25
C900 SAR_Asynchronous_Logic_10/D_reset_FF_0.Q VSSD 6.567389f
C901 a_143258_n17162# VSSD 4.87e-25
C902 a_138678_n17162# VSSD 4.87e-25
C903 a_137050_n17162# VSSD 4.87e-25
C904 a_129966_n18540# VSSD 2.51378f
C905 SAR_Asynchronous_Logic_8/D_reset_FF_0.nQ VSSD 0.727272f
C906 a_112898_n17162# VSSD 4.87e-25
C907 SAR_Asynchronous_Logic_8/D_reset_FF_0.Q VSSD 6.56713f
C908 a_111258_n17162# VSSD 4.87e-25
C909 a_106678_n17162# VSSD 4.87e-25
C910 a_105050_n17162# VSSD 4.87e-25
C911 a_97966_n18540# VSSD 2.51378f
C912 SAR_Asynchronous_Logic_7/D_reset_FF_0.nQ VSSD 0.727272f
C913 a_80898_n17162# VSSD 4.87e-25
C914 SAR_Asynchronous_Logic_7/D_reset_FF_0.Q VSSD 6.56713f
C915 a_79258_n17162# VSSD 4.87e-25
C916 a_74678_n17162# VSSD 4.87e-25
C917 a_73050_n17162# VSSD 4.87e-25
C918 a_65966_n18540# VSSD 2.51378f
C919 SAR_Asynchronous_Logic_2/D_reset_FF_0.nQ VSSD 0.727272f
C920 a_48898_n17162# VSSD 4.87e-25
C921 SAR_Asynchronous_Logic_2/D_reset_FF_0.Q VSSD 6.56713f
C922 a_47258_n17162# VSSD 4.87e-25
C923 a_42678_n17162# VSSD 4.87e-25
C924 a_41050_n17162# VSSD 4.87e-25
C925 a_33966_n18540# VSSD 2.51378f
C926 SAR_Asynchronous_Logic_4/D_reset_FF_0.nQ VSSD 0.727272f
C927 a_16898_n17162# VSSD 4.87e-25
C928 SAR_Asynchronous_Logic_4/D_reset_FF_0.Q VSSD 6.56713f
C929 a_15258_n17162# VSSD 4.87e-25
C930 a_10678_n17162# VSSD 4.87e-25
C931 a_9050_n17162# VSSD 4.87e-25
C932 a_1966_n18540# VSSD 2.51378f
C933 a_143910_n13054# VSSD 4.87e-25
C934 a_142282_n13054# VSSD 4.87e-25
C935 a_137702_n13054# VSSD 4.87e-25
C936 a_136062_n13054# VSSD 4.87e-25
C937 a_134704_n13054# VSSD 4.42408f
C938 SAR_Asynchronous_Logic_10/D_reset_FF_1.nQ VSSD 0.498036f
C939 SAR_Asynchronous_Logic_10/D_reset_FF_1.Q VSSD 8.117929f
C940 a_111910_n13054# VSSD 4.87e-25
C941 a_110282_n13054# VSSD 4.87e-25
C942 a_105702_n13054# VSSD 4.87e-25
C943 a_104062_n13054# VSSD 4.87e-25
C944 a_102704_n13054# VSSD 4.42408f
C945 SAR_Asynchronous_Logic_8/D_reset_FF_1.nQ VSSD 0.498036f
C946 SAR_Asynchronous_Logic_8/D_reset_FF_1.Q VSSD 8.117929f
C947 a_79910_n13054# VSSD 4.87e-25
C948 a_78282_n13054# VSSD 4.87e-25
C949 a_73702_n13054# VSSD 4.87e-25
C950 a_72062_n13054# VSSD 4.87e-25
C951 a_70704_n13054# VSSD 4.42408f
C952 SAR_Asynchronous_Logic_7/D_reset_FF_1.nQ VSSD 0.498036f
C953 SAR_Asynchronous_Logic_7/D_reset_FF_1.Q VSSD 8.117929f
C954 a_47910_n13054# VSSD 4.87e-25
C955 a_46282_n13054# VSSD 4.87e-25
C956 a_41702_n13054# VSSD 4.87e-25
C957 a_40062_n13054# VSSD 4.87e-25
C958 a_38704_n13054# VSSD 4.42408f
C959 SAR_Asynchronous_Logic_2/D_reset_FF_1.nQ VSSD 0.498036f
C960 SAR_Asynchronous_Logic_2/D_reset_FF_1.Q VSSD 8.117929f
C961 a_15910_n13054# VSSD 4.87e-25
C962 a_14282_n13054# VSSD 4.87e-25
C963 a_9702_n13054# VSSD 4.87e-25
C964 a_8062_n13054# VSSD 4.87e-25
C965 a_6704_n13054# VSSD 4.42408f
C966 SAR_Asynchronous_Logic_4/D_reset_FF_1.nQ VSSD 0.498036f
C967 SAR_Asynchronous_Logic_4/D_reset_FF_1.Q VSSD 8.117929f
C968 a_147052_n4460# VSSD 2.52413f
C969 a_141810_n3162# VSSD 4.87e-25
C970 a_140182_n3162# VSSD 4.87e-25
C971 a_135602_n3162# VSSD 4.87e-25
C972 a_133962_n3162# VSSD 4.87e-25
C973 SAR_Asynchronous_Logic_6/D_reset_FF_0.nQ VSSD 0.727272f
C974 SAR_Asynchronous_Logic_6/D_reset_FF_0.Q VSSD 7.17376f
C975 a_115052_n4460# VSSD 2.51432f
C976 a_109810_n3162# VSSD 4.87e-25
C977 a_108182_n3162# VSSD 4.87e-25
C978 a_103602_n3162# VSSD 4.87e-25
C979 a_101962_n3162# VSSD 4.87e-25
C980 SAR_Asynchronous_Logic_9/D_reset_FF_0.nQ VSSD 0.727272f
C981 SAR_Asynchronous_Logic_9/D_reset_FF_0.Q VSSD 7.17373f
C982 a_83052_n4460# VSSD 2.51432f
C983 a_77810_n3162# VSSD 4.87e-25
C984 a_76182_n3162# VSSD 4.87e-25
C985 a_71602_n3162# VSSD 4.87e-25
C986 a_69962_n3162# VSSD 4.87e-25
C987 SAR_Asynchronous_Logic_5/D_reset_FF_0.nQ VSSD 0.727272f
C988 SAR_Asynchronous_Logic_5/D_reset_FF_0.Q VSSD 7.17373f
C989 a_51052_n4460# VSSD 2.51432f
C990 a_45810_n3162# VSSD 4.87e-25
C991 a_44182_n3162# VSSD 4.87e-25
C992 a_39602_n3162# VSSD 4.87e-25
C993 a_37962_n3162# VSSD 4.87e-25
C994 SAR_Asynchronous_Logic_1/D_reset_FF_0.nQ VSSD 0.727272f
C995 SAR_Asynchronous_Logic_1/D_reset_FF_0.Q VSSD 7.17373f
C996 a_19052_n4460# VSSD 2.51432f
C997 a_13810_n3162# VSSD 4.87e-25
C998 a_12182_n3162# VSSD 4.87e-25
C999 a_7602_n3162# VSSD 4.87e-25
C1000 a_5962_n3162# VSSD 4.87e-25
C1001 SAR_Asynchronous_Logic_3/D_reset_FF_0.nQ VSSD 0.727272f
C1002 SAR_Asynchronous_Logic_3/D_reset_FF_0.Q VSSD 7.17373f
C1003 a_n12948_n4460# VSSD 2.51432f
C1004 a_n18190_n3162# VSSD 4.87e-25
C1005 a_n19818_n3162# VSSD 4.87e-25
C1006 a_n24398_n3162# VSSD 4.87e-25
C1007 a_n26038_n3162# VSSD 4.87e-25
C1008 SAR_Asynchronous_Logic_0/D_reset_FF_0.nQ VSSD 0.727272f
C1009 SAR_Asynchronous_Logic_0/D_reset_FF_0.Q VSSD 7.17168f
C1010 SAR_Asynchronous_Logic_6/D_reset_FF_1.nQ VSSD 0.498036f
C1011 a_142798_946# VSSD 4.87e-25
C1012 SAR_Asynchronous_Logic_6/D_reset_FF_1.Q VSSD 8.126909f
C1013 a_141158_946# VSSD 4.87e-25
C1014 a_140034_n314# VSSD 4.42408f
C1015 a_136578_946# VSSD 4.87e-25
C1016 a_134950_946# VSSD 4.87e-25
C1017 SAR_Asynchronous_Logic_9/D_reset_FF_1.nQ VSSD 0.498036f
C1018 a_110798_946# VSSD 4.87e-25
C1019 SAR_Asynchronous_Logic_9/D_reset_FF_1.Q VSSD 8.117929f
C1020 a_109158_946# VSSD 4.87e-25
C1021 a_108034_n314# VSSD 4.42408f
C1022 a_104578_946# VSSD 4.87e-25
C1023 a_102950_946# VSSD 4.87e-25
C1024 SAR_Asynchronous_Logic_5/D_reset_FF_1.nQ VSSD 0.498036f
C1025 a_78798_946# VSSD 4.87e-25
C1026 SAR_Asynchronous_Logic_5/D_reset_FF_1.Q VSSD 8.117929f
C1027 a_77158_946# VSSD 4.87e-25
C1028 a_76034_n314# VSSD 4.42408f
C1029 a_72578_946# VSSD 4.87e-25
C1030 a_70950_946# VSSD 4.87e-25
C1031 SAR_Asynchronous_Logic_1/D_reset_FF_1.nQ VSSD 0.498036f
C1032 a_46798_946# VSSD 4.87e-25
C1033 SAR_Asynchronous_Logic_1/D_reset_FF_1.Q VSSD 8.117929f
C1034 a_45158_946# VSSD 4.87e-25
C1035 a_44034_n314# VSSD 4.42408f
C1036 a_40578_946# VSSD 4.87e-25
C1037 a_38950_946# VSSD 4.87e-25
C1038 SAR_Asynchronous_Logic_3/D_reset_FF_1.nQ VSSD 0.498036f
C1039 a_14798_946# VSSD 4.87e-25
C1040 SAR_Asynchronous_Logic_3/D_reset_FF_1.Q VSSD 8.117929f
C1041 a_13158_946# VSSD 4.87e-25
C1042 a_12034_n314# VSSD 4.42408f
C1043 a_8578_946# VSSD 4.87e-25
C1044 a_6950_946# VSSD 4.87e-25
C1045 SAR_Asynchronous_Logic_0/D_reset_FF_1.nQ VSSD 0.498036f
C1046 a_n17202_946# VSSD 4.87e-25
C1047 SAR_Asynchronous_Logic_0/D_reset_FF_1.Q VSSD 8.117929f
C1048 a_n18842_946# VSSD 4.87e-25
C1049 a_n19966_n314# VSSD 4.42408f
C1050 a_n23422_946# VSSD 4.87e-25
C1051 a_n25050_946# VSSD 4.87e-25
C1052 D_C_9.t1 VSSD 0.173415f
C1053 D_C_9.t0 VSSD 0.064966f
C1054 D_C_9.n0 VSSD 1.94866f
C1055 D_C_11.t0 VSSD 0.143256f
C1056 D_C_11.t1 VSSD 0.053668f
C1057 D_C_11.n0 VSSD 1.61022f
C1058 CK_10.t1 VSSD 0.004357f
C1059 CK_10.t0 VSSD 0.010279f
C1060 CK_10.n0 VSSD 0.7267f
C1061 D_C_1.t1 VSSD 0.153273f
C1062 D_C_1.t0 VSSD 0.057419f
C1063 D_C_1.n0 VSSD 1.04216f
C1064 a_110798_n314.t0 VSSD 0.143873f
C1065 a_110798_n314.t3 VSSD 0.04397f
C1066 a_110798_n314.t1 VSSD 0.043846f
C1067 a_110798_n314.n0 VSSD 0.280111f
C1068 a_110798_n314.t4 VSSD 0.491242f
C1069 a_110798_n314.n1 VSSD 0.534715f
C1070 a_110798_n314.n2 VSSD 1.07819f
C1071 a_110798_n314.t2 VSSD 0.384053f
C1072 CK_9.t1 VSSD 0.00708f
C1073 CK_9.t0 VSSD 0.016703f
C1074 CK_9.n0 VSSD 1.18089f
C1075 a_2012_n13060.t1 VSSD 0.18478f
C1076 a_2012_n13060.t0 VSSD 0.131493f
C1077 a_2012_n13060.t3 VSSD 0.244385f
C1078 a_2012_n13060.n0 VSSD 0.779228f
C1079 a_2012_n13060.n1 VSSD 1.38905f
C1080 a_2012_n13060.t2 VSSD 0.171066f
C1081 Bit_8.t3 VSSD 0.274799f
C1082 Bit_8.t0 VSSD 0.131286f
C1083 Bit_8.t2 VSSD 0.141817f
C1084 Bit_8.n0 VSSD 1.1122f
C1085 Bit_8.t1 VSSD 0.092214f
C1086 Bit_8.n1 VSSD 0.359588f
C1087 Bit_8.n2 VSSD 3.85044f
C1088 a_100790_n4422.t2 VSSD 0.143873f
C1089 a_100790_n4422.t1 VSSD 0.043846f
C1090 a_100790_n4422.t4 VSSD 0.04397f
C1091 a_100790_n4422.n0 VSSD 0.280111f
C1092 a_100790_n4422.t3 VSSD 0.491305f
C1093 a_100790_n4422.n1 VSSD 0.534653f
C1094 a_100790_n4422.n2 VSSD 1.07817f
C1095 a_100790_n4422.t0 VSSD 0.384075f
C1096 Bit_6.t2 VSSD 0.274799f
C1097 Bit_6.t3 VSSD 0.131286f
C1098 Bit_6.t0 VSSD 0.141817f
C1099 Bit_6.n0 VSSD 1.1122f
C1100 Bit_6.t1 VSSD 0.092214f
C1101 Bit_6.n1 VSSD 0.359588f
C1102 Bit_6.n2 VSSD 3.85002f
C1103 CK_6.t1 VSSD 0.00708f
C1104 CK_6.t0 VSSD 0.016703f
C1105 CK_6.n0 VSSD 1.18119f
C1106 a_72066_n18422.n0 VSSD 0.986138f
C1107 a_72066_n18422.t4 VSSD 0.035769f
C1108 a_72066_n18422.t5 VSSD 0.0164f
C1109 a_72066_n18422.n1 VSSD 0.173748f
C1110 a_72066_n18422.t2 VSSD 0.250558f
C1111 a_72066_n18422.t0 VSSD 0.085552f
C1112 a_72066_n18422.t3 VSSD 0.085552f
C1113 a_72066_n18422.n2 VSSD 0.878151f
C1114 a_72066_n18422.t1 VSSD 0.288131f
C1115 D_C_7.t1 VSSD 0.173415f
C1116 D_C_7.t0 VSSD 0.064966f
C1117 D_C_7.n0 VSSD 1.94903f
C1118 a_n17202_n314.t2 VSSD 0.143873f
C1119 a_n17202_n314.t4 VSSD 0.04397f
C1120 a_n17202_n314.t0 VSSD 0.043846f
C1121 a_n17202_n314.n0 VSSD 0.280111f
C1122 a_n17202_n314.t3 VSSD 0.491242f
C1123 a_n17202_n314.n1 VSSD 0.534715f
C1124 a_n17202_n314.n2 VSSD 1.07819f
C1125 a_n17202_n314.t1 VSSD 0.384053f
C1126 a_104066_n18422.n0 VSSD 0.986161f
C1127 a_104066_n18422.t4 VSSD 0.035769f
C1128 a_104066_n18422.t5 VSSD 0.0164f
C1129 a_104066_n18422.n1 VSSD 0.173748f
C1130 a_104066_n18422.t3 VSSD 0.28816f
C1131 a_104066_n18422.t1 VSSD 0.085552f
C1132 a_104066_n18422.n2 VSSD 0.878122f
C1133 a_104066_n18422.t2 VSSD 0.085552f
C1134 a_104066_n18422.t0 VSSD 0.250536f
C1135 Bit_1.t2 VSSD 0.312254f
C1136 Bit_1.t3 VSSD 0.161147f
C1137 Bit_1.t1 VSSD 0.149179f
C1138 Bit_1.n0 VSSD 1.26379f
C1139 Bit_1.t0 VSSD 0.104782f
C1140 Bit_1.n1 VSSD 0.4086f
C1141 Bit_1.n2 VSSD 2.41691f
C1142 a_66012_n13060.t1 VSSD 0.18478f
C1143 a_66012_n13060.t0 VSSD 0.131493f
C1144 a_66012_n13060.t3 VSSD 0.244385f
C1145 a_66012_n13060.n0 VSSD 0.779228f
C1146 a_66012_n13060.n1 VSSD 1.38905f
C1147 a_66012_n13060.t2 VSSD 0.171066f
C1148 a_68604_n3162.t2 VSSD 0.074342f
C1149 a_68604_n3162.t3 VSSD 0.23008f
C1150 a_68604_n3162.t1 VSSD 0.06831f
C1151 a_68604_n3162.n0 VSSD 0.749612f
C1152 a_68604_n3162.t4 VSSD 0.02856f
C1153 a_68604_n3162.t5 VSSD 0.013095f
C1154 a_68604_n3162.n1 VSSD 0.140216f
C1155 a_68604_n3162.n2 VSSD 0.351631f
C1156 a_68604_n3162.n3 VSSD 0.548758f
C1157 a_68604_n3162.t0 VSSD 0.195396f
C1158 a_76918_n14314.t3 VSSD 0.04467f
C1159 a_76918_n14314.t2 VSSD 0.044796f
C1160 a_76918_n14314.n0 VSSD 0.285375f
C1161 a_76918_n14314.t4 VSSD 0.393761f
C1162 a_76918_n14314.t0 VSSD 0.146586f
C1163 a_76918_n14314.n1 VSSD 1.13115f
C1164 a_76918_n14314.n2 VSSD 0.55313f
C1165 a_76918_n14314.t1 VSSD 0.500537f
C1166 a_68790_n4422.t1 VSSD 0.143873f
C1167 a_68790_n4422.t0 VSSD 0.043846f
C1168 a_68790_n4422.t3 VSSD 0.04397f
C1169 a_68790_n4422.n0 VSSD 0.280111f
C1170 a_68790_n4422.t4 VSSD 0.491305f
C1171 a_68790_n4422.n1 VSSD 0.534653f
C1172 a_68790_n4422.n2 VSSD 1.07817f
C1173 a_68790_n4422.t2 VSSD 0.384075f
C1174 a_38950_n314.n0 VSSD 1.4589f
C1175 a_38950_n314.t0 VSSD 0.075381f
C1176 a_38950_n314.t3 VSSD 0.075169f
C1177 a_38950_n314.n1 VSSD 0.480219f
C1178 a_38950_n314.t6 VSSD 0.095963f
C1179 a_38950_n314.t5 VSSD 0.044581f
C1180 a_38950_n314.t2 VSSD 0.658502f
C1181 a_38950_n314.t4 VSSD 0.246654f
C1182 a_38950_n314.n2 VSSD 2.44953f
C1183 a_38950_n314.n3 VSSD 0.872922f
C1184 a_38950_n314.t1 VSSD 0.84218f
C1185 a_73342_n4422.n0 VSSD 1.4589f
C1186 a_73342_n4422.t4 VSSD 0.075169f
C1187 a_73342_n4422.t1 VSSD 0.075381f
C1188 a_73342_n4422.n1 VSSD 0.480219f
C1189 a_73342_n4422.t5 VSSD 0.095963f
C1190 a_73342_n4422.t6 VSSD 0.044581f
C1191 a_73342_n4422.t2 VSSD 0.658513f
C1192 a_73342_n4422.t3 VSSD 0.246654f
C1193 a_73342_n4422.n2 VSSD 2.44952f
C1194 a_73342_n4422.n3 VSSD 0.872815f
C1195 a_73342_n4422.t0 VSSD 0.842287f
C1196 a_78798_n314.t2 VSSD 0.143873f
C1197 a_78798_n314.t4 VSSD 0.04397f
C1198 a_78798_n314.t1 VSSD 0.043846f
C1199 a_78798_n314.n0 VSSD 0.280111f
C1200 a_78798_n314.t3 VSSD 0.491242f
C1201 a_78798_n314.n1 VSSD 0.534715f
C1202 a_78798_n314.n2 VSSD 1.07819f
C1203 a_78798_n314.t0 VSSD 0.384053f
C1204 a_n27278_n82.t1 VSSD 0.198092f
C1205 a_n27278_n82.t5 VSSD 0.1503f
C1206 a_n27278_n82.t2 VSSD 0.111361f
C1207 a_n27278_n82.t3 VSSD 0.210813f
C1208 a_n27278_n82.n0 VSSD 2.80378f
C1209 a_n27278_n82.t4 VSSD 0.113403f
C1210 a_n27278_n82.n1 VSSD 1.56811f
C1211 a_n27278_n82.n2 VSSD 1.46985f
C1212 a_n27278_n82.n3 VSSD 1.46632f
C1213 a_n27278_n82.t0 VSSD 0.407979f
C1214 a_130012_n13060.t1 VSSD 0.18478f
C1215 a_130012_n13060.t2 VSSD 0.131493f
C1216 a_130012_n13060.t3 VSSD 0.244385f
C1217 a_130012_n13060.n0 VSSD 0.779228f
C1218 a_130012_n13060.n1 VSSD 1.38905f
C1219 a_130012_n13060.t0 VSSD 0.171066f
C1220 a_736_n13850.n0 VSSD 8.2746f
C1221 a_736_n13850.n1 VSSD 4.39794f
C1222 a_736_n13850.t5 VSSD 0.030514f
C1223 a_736_n13850.t7 VSSD 0.071986f
C1224 a_736_n13850.n2 VSSD 0.235314f
C1225 a_736_n13850.t3 VSSD 0.12518f
C1226 a_736_n13850.t4 VSSD 0.09841f
C1227 a_736_n13850.t2 VSSD 0.097438f
C1228 a_736_n13850.n3 VSSD 2.56472f
C1229 a_736_n13850.t6 VSSD 0.270804f
C1230 a_736_n13850.t0 VSSD 0.115882f
C1231 a_736_n13850.t1 VSSD 0.317217f
C1232 a_82854_1076.t1 VSSD 0.184779f
C1233 a_82854_1076.t2 VSSD 0.131493f
C1234 a_82854_1076.t3 VSSD 0.244385f
C1235 a_82854_1076.n0 VSSD 0.779228f
C1236 a_82854_1076.n1 VSSD 1.38904f
C1237 a_82854_1076.t0 VSSD 0.171071f
C1238 a_100722_n3300.t5 VSSD 0.150297f
C1239 a_100722_n3300.t2 VSSD 0.111359f
C1240 a_100722_n3300.t4 VSSD 0.210813f
C1241 a_100722_n3300.n0 VSSD 2.80378f
C1242 a_100722_n3300.t3 VSSD 0.113401f
C1243 a_100722_n3300.n1 VSSD 1.56811f
C1244 a_100722_n3300.n2 VSSD 1.46986f
C1245 a_100722_n3300.t1 VSSD 0.198092f
C1246 a_100722_n3300.n3 VSSD 1.4663f
C1247 a_100722_n3300.t0 VSSD 0.407992f
C1248 a_140918_n14314.t0 VSSD 0.04467f
C1249 a_140918_n14314.t2 VSSD 0.044796f
C1250 a_140918_n14314.n0 VSSD 0.285375f
C1251 a_140918_n14314.t3 VSSD 0.393761f
C1252 a_140918_n14314.t4 VSSD 0.146586f
C1253 a_140918_n14314.n1 VSSD 1.13115f
C1254 a_140918_n14314.n2 VSSD 0.55313f
C1255 a_140918_n14314.t1 VSSD 0.500537f
C1256 a_130110_n80.n0 VSSD 8.2746f
C1257 a_130110_n80.n1 VSSD 4.39821f
C1258 a_130110_n80.t6 VSSD 0.030513f
C1259 a_130110_n80.t3 VSSD 0.071986f
C1260 a_130110_n80.n2 VSSD 0.235316f
C1261 a_130110_n80.t2 VSSD 0.125181f
C1262 a_130110_n80.t4 VSSD 0.098408f
C1263 a_130110_n80.t5 VSSD 0.097436f
C1264 a_130110_n80.n3 VSSD 2.56472f
C1265 a_130110_n80.t7 VSSD 0.270804f
C1266 a_130110_n80.t0 VSSD 0.115882f
C1267 a_130110_n80.t1 VSSD 0.316938f
C1268 a_134822_n13946.n0 VSSD 1.29292f
C1269 a_134822_n13946.t2 VSSD 0.038175f
C1270 a_134822_n13946.t5 VSSD 0.090059f
C1271 a_134822_n13946.n1 VSSD 0.298371f
C1272 a_134822_n13946.t1 VSSD 0.147144f
C1273 a_134822_n13946.t7 VSSD 0.1636f
C1274 a_134822_n13946.t6 VSSD 0.130517f
C1275 a_134822_n13946.n2 VSSD 2.29806f
C1276 a_134822_n13946.t4 VSSD 0.128165f
C1277 a_134822_n13946.n3 VSSD 1.28395f
C1278 a_134822_n13946.t3 VSSD 0.088694f
C1279 a_134822_n13946.n4 VSSD 1.24258f
C1280 a_134822_n13946.t0 VSSD 0.397759f
C1281 a_16898_n18422.t4 VSSD 0.143873f
C1282 a_16898_n18422.t2 VSSD 0.04397f
C1283 a_16898_n18422.t0 VSSD 0.043846f
C1284 a_16898_n18422.n0 VSSD 0.280111f
C1285 a_16898_n18422.t3 VSSD 0.491242f
C1286 a_16898_n18422.n1 VSSD 0.534715f
C1287 a_16898_n18422.n2 VSSD 1.07819f
C1288 a_16898_n18422.t1 VSSD 0.384053f
C1289 Bit_0.t3 VSSD 0.312254f
C1290 Bit_0.t2 VSSD 0.161147f
C1291 Bit_0.t0 VSSD 0.149179f
C1292 Bit_0.n0 VSSD 1.26379f
C1293 Bit_0.t1 VSSD 0.104782f
C1294 Bit_0.n1 VSSD 0.4086f
C1295 Bit_0.n2 VSSD 2.41691f
C1296 a_736_n13096.n0 VSSD 7.24543f
C1297 a_736_n13096.n1 VSSD 4.09045f
C1298 a_736_n13096.t5 VSSD 0.02929f
C1299 a_736_n13096.t7 VSSD 0.069099f
C1300 a_736_n13096.n2 VSSD 0.260362f
C1301 a_736_n13096.t2 VSSD 0.13356f
C1302 a_736_n13096.t4 VSSD 0.367163f
C1303 a_736_n13096.t6 VSSD 0.077939f
C1304 a_736_n13096.t3 VSSD 0.088896f
C1305 a_736_n13096.n3 VSSD 2.7214f
C1306 a_736_n13096.t0 VSSD 0.111234f
C1307 a_736_n13096.t1 VSSD 0.305184f
C1308 SAR_Asynchronous_Logic_8/D_reset_FF_0.Q.n0 VSSD 1.06897f
C1309 SAR_Asynchronous_Logic_8/D_reset_FF_0.Q.t1 VSSD 0.051002f
C1310 SAR_Asynchronous_Logic_8/D_reset_FF_0.Q.t0 VSSD 0.050858f
C1311 SAR_Asynchronous_Logic_8/D_reset_FF_0.Q.n1 VSSD 0.32491f
C1312 SAR_Asynchronous_Logic_8/D_reset_FF_0.Q.t2 VSSD 0.569808f
C1313 SAR_Asynchronous_Logic_8/D_reset_FF_0.Q.t5 VSSD 0.064927f
C1314 SAR_Asynchronous_Logic_8/D_reset_FF_0.Q.t6 VSSD 0.030163f
C1315 SAR_Asynchronous_Logic_8/D_reset_FF_0.Q.n2 VSSD 0.216789f
C1316 SAR_Asynchronous_Logic_8/D_reset_FF_0.Q.t3 VSSD 0.026338f
C1317 SAR_Asynchronous_Logic_8/D_reset_FF_0.Q.t4 VSSD 0.062135f
C1318 SAR_Asynchronous_Logic_8/D_reset_FF_0.Q.n3 VSSD 0.20285f
C1319 SAR_Asynchronous_Logic_8/D_reset_FF_0.Q.n4 VSSD 0.734634f
C1320 a_114854_1076.t2 VSSD 0.184779f
C1321 a_114854_1076.t1 VSSD 0.131493f
C1322 a_114854_1076.t3 VSSD 0.244385f
C1323 a_114854_1076.n0 VSSD 0.779228f
C1324 a_114854_1076.n1 VSSD 1.38904f
C1325 a_114854_1076.t0 VSSD 0.171071f
C1326 a_18854_1076.t0 VSSD 0.184779f
C1327 a_18854_1076.t1 VSSD 0.131493f
C1328 a_18854_1076.t3 VSSD 0.244385f
C1329 a_18854_1076.n0 VSSD 0.779228f
C1330 a_18854_1076.n1 VSSD 1.38904f
C1331 a_18854_1076.t2 VSSD 0.171071f
C1332 D_C_8.t0 VSSD 0.173415f
C1333 D_C_8.t1 VSSD 0.064966f
C1334 D_C_8.n0 VSSD 1.94903f
C1335 a_n28098_n82.n0 VSSD 1.29327f
C1336 a_n28098_n82.t5 VSSD 0.038174f
C1337 a_n28098_n82.t4 VSSD 0.090059f
C1338 a_n28098_n82.n1 VSSD 0.298372f
C1339 a_n28098_n82.t1 VSSD 0.147143f
C1340 a_n28098_n82.t6 VSSD 0.1636f
C1341 a_n28098_n82.t3 VSSD 0.130517f
C1342 a_n28098_n82.n2 VSSD 2.29806f
C1343 a_n28098_n82.t2 VSSD 0.128166f
C1344 a_n28098_n82.n3 VSSD 1.28395f
C1345 a_n28098_n82.t7 VSSD 0.088697f
C1346 a_n28098_n82.n4 VSSD 1.24258f
C1347 a_n28098_n82.t0 VSSD 0.397411f
C1348 a_2110_n80.n0 VSSD 8.2746f
C1349 a_2110_n80.n1 VSSD 4.39821f
C1350 a_2110_n80.t7 VSSD 0.030513f
C1351 a_2110_n80.t6 VSSD 0.071986f
C1352 a_2110_n80.n2 VSSD 0.235316f
C1353 a_2110_n80.t2 VSSD 0.125181f
C1354 a_2110_n80.t4 VSSD 0.098408f
C1355 a_2110_n80.t5 VSSD 0.097436f
C1356 a_2110_n80.n3 VSSD 2.56472f
C1357 a_2110_n80.t3 VSSD 0.270804f
C1358 a_2110_n80.t1 VSSD 0.115882f
C1359 a_2110_n80.t0 VSSD 0.316938f
C1360 a_11442_n14314.n0 VSSD 1.4589f
C1361 a_11442_n14314.t4 VSSD 0.075169f
C1362 a_11442_n14314.t1 VSSD 0.075381f
C1363 a_11442_n14314.n1 VSSD 0.480219f
C1364 a_11442_n14314.t5 VSSD 0.095963f
C1365 a_11442_n14314.t6 VSSD 0.044581f
C1366 a_11442_n14314.t2 VSSD 0.658513f
C1367 a_11442_n14314.t3 VSSD 0.246654f
C1368 a_11442_n14314.n2 VSSD 2.44952f
C1369 a_11442_n14314.n3 VSSD 0.872815f
C1370 a_11442_n14314.t0 VSSD 0.842287f
C1371 D_C_6.t0 VSSD 0.173415f
C1372 D_C_6.t1 VSSD 0.064966f
C1373 D_C_6.n0 VSSD 1.94903f
C1374 a_131902_n82.n0 VSSD 1.29327f
C1375 a_131902_n82.t7 VSSD 0.038174f
C1376 a_131902_n82.t4 VSSD 0.090059f
C1377 a_131902_n82.n1 VSSD 0.298372f
C1378 a_131902_n82.t1 VSSD 0.147143f
C1379 a_131902_n82.t6 VSSD 0.1636f
C1380 a_131902_n82.t3 VSSD 0.130517f
C1381 a_131902_n82.n2 VSSD 2.29806f
C1382 a_131902_n82.t5 VSSD 0.128166f
C1383 a_131902_n82.n3 VSSD 1.28395f
C1384 a_131902_n82.t2 VSSD 0.088697f
C1385 a_131902_n82.n4 VSSD 1.24258f
C1386 a_131902_n82.t0 VSSD 0.397411f
C1387 a_n27396_n3162.t2 VSSD 0.074342f
C1388 a_n27396_n3162.t3 VSSD 0.23008f
C1389 a_n27396_n3162.t1 VSSD 0.06831f
C1390 a_n27396_n3162.n0 VSSD 0.749612f
C1391 a_n27396_n3162.t4 VSSD 0.02856f
C1392 a_n27396_n3162.t5 VSSD 0.013095f
C1393 a_n27396_n3162.n1 VSSD 0.140216f
C1394 a_n27396_n3162.n2 VSSD 0.351631f
C1395 a_n27396_n3162.n3 VSSD 0.548758f
C1396 a_n27396_n3162.t0 VSSD 0.195396f
C1397 a_101966_n314.n0 VSSD 1.62008f
C1398 a_101966_n314.t5 VSSD 0.058764f
C1399 a_101966_n314.t4 VSSD 0.026943f
C1400 a_101966_n314.n1 VSSD 0.285443f
C1401 a_101966_n314.t3 VSSD 0.411632f
C1402 a_101966_n314.t1 VSSD 0.14055f
C1403 a_101966_n314.t2 VSSD 0.14055f
C1404 a_101966_n314.n2 VSSD 1.44268f
C1405 a_101966_n314.t0 VSSD 0.473359f
C1406 a_104578_n314.t1 VSSD 0.146586f
C1407 a_104578_n314.t3 VSSD 0.044796f
C1408 a_104578_n314.t2 VSSD 0.04467f
C1409 a_104578_n314.n0 VSSD 0.285375f
C1410 a_104578_n314.t4 VSSD 0.500473f
C1411 a_104578_n314.n1 VSSD 0.553195f
C1412 a_104578_n314.n2 VSSD 1.1312f
C1413 a_104578_n314.t0 VSSD 0.393702f
C1414 Bit_2.t1 VSSD 0.312254f
C1415 Bit_2.t3 VSSD 0.161147f
C1416 Bit_2.t0 VSSD 0.149179f
C1417 Bit_2.n0 VSSD 1.26379f
C1418 Bit_2.t2 VSSD 0.104782f
C1419 Bit_2.n1 VSSD 0.4086f
C1420 Bit_2.n2 VSSD 2.41693f
C1421 a_142798_n314.t2 VSSD 0.143873f
C1422 a_142798_n314.t3 VSSD 0.04397f
C1423 a_142798_n314.t0 VSSD 0.043846f
C1424 a_142798_n314.n0 VSSD 0.280111f
C1425 a_142798_n314.t4 VSSD 0.491242f
C1426 a_142798_n314.n1 VSSD 0.534715f
C1427 a_142798_n314.n2 VSSD 1.07819f
C1428 a_142798_n314.t1 VSSD 0.384053f
C1429 a_132722_n82.t0 VSSD 0.198092f
C1430 a_132722_n82.t5 VSSD 0.1503f
C1431 a_132722_n82.t4 VSSD 0.111361f
C1432 a_132722_n82.t2 VSSD 0.210813f
C1433 a_132722_n82.n0 VSSD 2.80378f
C1434 a_132722_n82.t3 VSSD 0.113403f
C1435 a_132722_n82.n1 VSSD 1.56811f
C1436 a_132722_n82.n2 VSSD 1.46985f
C1437 a_132722_n82.n3 VSSD 1.46632f
C1438 a_132722_n82.t1 VSSD 0.407979f
C1439 a_128736_n13096.n0 VSSD 7.24543f
C1440 a_128736_n13096.n1 VSSD 4.09045f
C1441 a_128736_n13096.t3 VSSD 0.02929f
C1442 a_128736_n13096.t5 VSSD 0.069099f
C1443 a_128736_n13096.n2 VSSD 0.260362f
C1444 a_128736_n13096.t2 VSSD 0.13356f
C1445 a_128736_n13096.t6 VSSD 0.367163f
C1446 a_128736_n13096.t7 VSSD 0.077939f
C1447 a_128736_n13096.t4 VSSD 0.088896f
C1448 a_128736_n13096.n3 VSSD 2.7214f
C1449 a_128736_n13096.t1 VSSD 0.111234f
C1450 a_128736_n13096.t0 VSSD 0.305184f
C1451 a_96736_n13850.n0 VSSD 8.2746f
C1452 a_96736_n13850.n1 VSSD 4.39794f
C1453 a_96736_n13850.t3 VSSD 0.030514f
C1454 a_96736_n13850.t4 VSSD 0.071986f
C1455 a_96736_n13850.n2 VSSD 0.235314f
C1456 a_96736_n13850.t6 VSSD 0.12518f
C1457 a_96736_n13850.t7 VSSD 0.09841f
C1458 a_96736_n13850.t5 VSSD 0.097438f
C1459 a_96736_n13850.n3 VSSD 2.56472f
C1460 a_96736_n13850.t2 VSSD 0.270804f
C1461 a_96736_n13850.t1 VSSD 0.115882f
C1462 a_96736_n13850.t0 VSSD 0.317217f
C1463 a_9342_n4422.n0 VSSD 1.4589f
C1464 a_9342_n4422.t4 VSSD 0.075169f
C1465 a_9342_n4422.t0 VSSD 0.075381f
C1466 a_9342_n4422.n1 VSSD 0.480219f
C1467 a_9342_n4422.t5 VSSD 0.095963f
C1468 a_9342_n4422.t6 VSSD 0.044581f
C1469 a_9342_n4422.t2 VSSD 0.658513f
C1470 a_9342_n4422.t3 VSSD 0.246654f
C1471 a_9342_n4422.n2 VSSD 2.44952f
C1472 a_9342_n4422.n3 VSSD 0.872815f
C1473 a_9342_n4422.t1 VSSD 0.842287f
C1474 CK_11.t1 VSSD 0.008986f
C1475 CK_11.t0 VSSD 0.0212f
C1476 CK_11.n0 VSSD 1.49882f
C1477 a_3902_n82.n0 VSSD 1.29327f
C1478 a_3902_n82.t7 VSSD 0.038174f
C1479 a_3902_n82.t5 VSSD 0.090059f
C1480 a_3902_n82.n1 VSSD 0.298372f
C1481 a_3902_n82.t1 VSSD 0.147143f
C1482 a_3902_n82.t3 VSSD 0.1636f
C1483 a_3902_n82.t4 VSSD 0.130517f
C1484 a_3902_n82.n2 VSSD 2.29806f
C1485 a_3902_n82.t6 VSSD 0.128166f
C1486 a_3902_n82.n3 VSSD 1.28395f
C1487 a_3902_n82.t2 VSSD 0.088697f
C1488 a_3902_n82.n4 VSSD 1.24258f
C1489 a_3902_n82.t0 VSSD 0.397411f
C1490 a_138678_n18422.t2 VSSD 0.043351f
C1491 a_138678_n18422.t0 VSSD 0.043229f
C1492 a_138678_n18422.n0 VSSD 0.276169f
C1493 a_138678_n18422.t4 VSSD 0.381052f
C1494 a_138678_n18422.t3 VSSD 0.141857f
C1495 a_138678_n18422.n1 VSSD 1.09466f
C1496 a_138678_n18422.n2 VSSD 0.53535f
C1497 a_138678_n18422.t1 VSSD 0.484329f
C1498 D_C_5.t0 VSSD 0.153273f
C1499 D_C_5.t1 VSSD 0.057419f
C1500 D_C_5.n0 VSSD 1.04233f
C1501 a_140732_n13054.n0 VSSD 1.62015f
C1502 a_140732_n13054.t4 VSSD 0.058764f
C1503 a_140732_n13054.t5 VSSD 0.026943f
C1504 a_140732_n13054.n1 VSSD 0.285443f
C1505 a_140732_n13054.t2 VSSD 0.473397f
C1506 a_140732_n13054.t0 VSSD 0.14055f
C1507 a_140732_n13054.n2 VSSD 1.44264f
C1508 a_140732_n13054.t3 VSSD 0.14055f
C1509 a_140732_n13054.t1 VSSD 0.41157f
C1510 a_134822_n13192.t2 VSSD 0.150297f
C1511 a_134822_n13192.t5 VSSD 0.111359f
C1512 a_134822_n13192.t3 VSSD 0.210813f
C1513 a_134822_n13192.n0 VSSD 2.80378f
C1514 a_134822_n13192.t4 VSSD 0.113401f
C1515 a_134822_n13192.n1 VSSD 1.56811f
C1516 a_134822_n13192.n2 VSSD 1.46986f
C1517 a_134822_n13192.t1 VSSD 0.198092f
C1518 a_134822_n13192.n3 VSSD 1.4663f
C1519 a_134822_n13192.t0 VSSD 0.407992f
C1520 a_64736_n13850.n0 VSSD 8.2746f
C1521 a_64736_n13850.n1 VSSD 4.39794f
C1522 a_64736_n13850.t4 VSSD 0.030514f
C1523 a_64736_n13850.t5 VSSD 0.071986f
C1524 a_64736_n13850.n2 VSSD 0.235314f
C1525 a_64736_n13850.t3 VSSD 0.12518f
C1526 a_64736_n13850.t6 VSSD 0.09841f
C1527 a_64736_n13850.t2 VSSD 0.097438f
C1528 a_64736_n13850.n3 VSSD 2.56472f
C1529 a_64736_n13850.t7 VSSD 0.270804f
C1530 a_64736_n13850.t0 VSSD 0.115882f
C1531 a_64736_n13850.t1 VSSD 0.317217f
C1532 a_14134_n18422.t3 VSSD 0.195425f
C1533 a_14134_n18422.t0 VSSD 0.074342f
C1534 a_14134_n18422.n0 VSSD 0.548729f
C1535 a_14134_n18422.t4 VSSD 0.02856f
C1536 a_14134_n18422.t5 VSSD 0.013095f
C1537 a_14134_n18422.n1 VSSD 0.140208f
C1538 a_14134_n18422.n2 VSSD 0.351639f
C1539 a_14134_n18422.t2 VSSD 0.06831f
C1540 a_14134_n18422.n3 VSSD 0.74963f
C1541 a_14134_n18422.t1 VSSD 0.230062f
C1542 a_40066_n18422.n0 VSSD 0.986161f
C1543 a_40066_n18422.t4 VSSD 0.035769f
C1544 a_40066_n18422.t5 VSSD 0.0164f
C1545 a_40066_n18422.n1 VSSD 0.173748f
C1546 a_40066_n18422.t3 VSSD 0.28816f
C1547 a_40066_n18422.t1 VSSD 0.085552f
C1548 a_40066_n18422.n2 VSSD 0.878122f
C1549 a_40066_n18422.t2 VSSD 0.085552f
C1550 a_40066_n18422.t0 VSSD 0.250536f
C1551 a_70890_n14314.t2 VSSD 0.143873f
C1552 a_70890_n14314.t0 VSSD 0.043846f
C1553 a_70890_n14314.t3 VSSD 0.04397f
C1554 a_70890_n14314.n0 VSSD 0.280111f
C1555 a_70890_n14314.t4 VSSD 0.491305f
C1556 a_70890_n14314.n1 VSSD 0.534653f
C1557 a_70890_n14314.n2 VSSD 1.07817f
C1558 a_70890_n14314.t1 VSSD 0.384075f
C1559 a_73050_n18422.n0 VSSD 1.4589f
C1560 a_73050_n18422.t3 VSSD 0.246654f
C1561 a_73050_n18422.t5 VSSD 0.095963f
C1562 a_73050_n18422.t6 VSSD 0.044581f
C1563 a_73050_n18422.t2 VSSD 0.075381f
C1564 a_73050_n18422.t4 VSSD 0.075169f
C1565 a_73050_n18422.n1 VSSD 0.480219f
C1566 a_73050_n18422.t1 VSSD 0.84218f
C1567 a_73050_n18422.n2 VSSD 0.872922f
C1568 a_73050_n18422.n3 VSSD 2.44962f
C1569 a_73050_n18422.t0 VSSD 0.658416f
C1570 a_69966_n314.n0 VSSD 1.62012f
C1571 a_69966_n314.t4 VSSD 0.058764f
C1572 a_69966_n314.t5 VSSD 0.026943f
C1573 a_69966_n314.n1 VSSD 0.285443f
C1574 a_69966_n314.t2 VSSD 0.473406f
C1575 a_69966_n314.t1 VSSD 0.14055f
C1576 a_69966_n314.n2 VSSD 1.44263f
C1577 a_69966_n314.t3 VSSD 0.14055f
C1578 a_69966_n314.t0 VSSD 0.411594f
C1579 a_72578_n314.t1 VSSD 0.044796f
C1580 a_72578_n314.t0 VSSD 0.04467f
C1581 a_72578_n314.n0 VSSD 0.285375f
C1582 a_72578_n314.t4 VSSD 0.393754f
C1583 a_72578_n314.t3 VSSD 0.146586f
C1584 a_72578_n314.n1 VSSD 1.13115f
C1585 a_72578_n314.n2 VSSD 0.553195f
C1586 a_72578_n314.t2 VSSD 0.500473f
C1587 a_10678_n18422.t0 VSSD 0.043351f
C1588 a_10678_n18422.t2 VSSD 0.043229f
C1589 a_10678_n18422.n0 VSSD 0.276169f
C1590 a_10678_n18422.t4 VSSD 0.381052f
C1591 a_10678_n18422.t3 VSSD 0.141857f
C1592 a_10678_n18422.n1 VSSD 1.09466f
C1593 a_10678_n18422.n2 VSSD 0.53535f
C1594 a_10678_n18422.t1 VSSD 0.484329f
C1595 a_6002_n18190.n0 VSSD 1.29327f
C1596 a_6002_n18190.t4 VSSD 0.038174f
C1597 a_6002_n18190.t6 VSSD 0.090059f
C1598 a_6002_n18190.n1 VSSD 0.298372f
C1599 a_6002_n18190.t1 VSSD 0.147143f
C1600 a_6002_n18190.t7 VSSD 0.1636f
C1601 a_6002_n18190.t5 VSSD 0.130517f
C1602 a_6002_n18190.n2 VSSD 2.29806f
C1603 a_6002_n18190.t2 VSSD 0.128166f
C1604 a_6002_n18190.n3 VSSD 1.28395f
C1605 a_6002_n18190.t3 VSSD 0.088697f
C1606 a_6002_n18190.n4 VSSD 1.24258f
C1607 a_6002_n18190.t0 VSSD 0.397411f
C1608 a_132604_n3162.t3 VSSD 0.074342f
C1609 a_132604_n3162.t2 VSSD 0.23008f
C1610 a_132604_n3162.t0 VSSD 0.06831f
C1611 a_132604_n3162.n0 VSSD 0.749612f
C1612 a_132604_n3162.t4 VSSD 0.02856f
C1613 a_132604_n3162.t5 VSSD 0.013095f
C1614 a_132604_n3162.n1 VSSD 0.140216f
C1615 a_132604_n3162.n2 VSSD 0.351631f
C1616 a_132604_n3162.n3 VSSD 0.548758f
C1617 a_132604_n3162.t1 VSSD 0.195396f
C1618 a_102890_n14314.t0 VSSD 0.143873f
C1619 a_102890_n14314.t1 VSSD 0.043846f
C1620 a_102890_n14314.t3 VSSD 0.04397f
C1621 a_102890_n14314.n0 VSSD 0.280111f
C1622 a_102890_n14314.t4 VSSD 0.491305f
C1623 a_102890_n14314.n1 VSSD 0.534653f
C1624 a_102890_n14314.n2 VSSD 1.07817f
C1625 a_102890_n14314.t2 VSSD 0.384075f
C1626 a_42632_n3162.n0 VSSD 0.986143f
C1627 a_42632_n3162.t5 VSSD 0.035769f
C1628 a_42632_n3162.t4 VSSD 0.0164f
C1629 a_42632_n3162.n1 VSSD 0.173748f
C1630 a_42632_n3162.t3 VSSD 0.250554f
C1631 a_42632_n3162.t1 VSSD 0.085552f
C1632 a_42632_n3162.t2 VSSD 0.085552f
C1633 a_42632_n3162.n2 VSSD 0.878169f
C1634 a_42632_n3162.t0 VSSD 0.288113f
C1635 SAR_Asynchronous_Logic_1/D_reset_FF_0.Q.n0 VSSD 1.54881f
C1636 SAR_Asynchronous_Logic_1/D_reset_FF_0.Q.t3 VSSD 0.094079f
C1637 SAR_Asynchronous_Logic_1/D_reset_FF_0.Q.t4 VSSD 0.043705f
C1638 SAR_Asynchronous_Logic_1/D_reset_FF_0.Q.n1 VSSD 0.314123f
C1639 SAR_Asynchronous_Logic_1/D_reset_FF_0.Q.t2 VSSD 0.073692f
C1640 SAR_Asynchronous_Logic_1/D_reset_FF_0.Q.t1 VSSD 0.073901f
C1641 SAR_Asynchronous_Logic_1/D_reset_FF_0.Q.n2 VSSD 0.470788f
C1642 SAR_Asynchronous_Logic_1/D_reset_FF_0.Q.t0 VSSD 0.825745f
C1643 SAR_Asynchronous_Logic_1/D_reset_FF_0.Q.t5 VSSD 0.038164f
C1644 SAR_Asynchronous_Logic_1/D_reset_FF_0.Q.t6 VSSD 0.090033f
C1645 SAR_Asynchronous_Logic_1/D_reset_FF_0.Q.n3 VSSD 0.293925f
C1646 SAR_Asynchronous_Logic_1/D_reset_FF_0.Q.n4 VSSD 1.06447f
C1647 a_34012_n13060.t2 VSSD 0.18478f
C1648 a_34012_n13060.t1 VSSD 0.131493f
C1649 a_34012_n13060.t3 VSSD 0.244385f
C1650 a_34012_n13060.n0 VSSD 0.779228f
C1651 a_34012_n13060.n1 VSSD 1.38905f
C1652 a_34012_n13060.t0 VSSD 0.171066f
C1653 a_74678_n18422.t0 VSSD 0.043351f
C1654 a_74678_n18422.t3 VSSD 0.043229f
C1655 a_74678_n18422.n0 VSSD 0.276169f
C1656 a_74678_n18422.t2 VSSD 0.381052f
C1657 a_74678_n18422.t4 VSSD 0.141857f
C1658 a_74678_n18422.n1 VSSD 1.09466f
C1659 a_74678_n18422.n2 VSSD 0.53535f
C1660 a_74678_n18422.t1 VSSD 0.484329f
C1661 D_C_3.t0 VSSD 0.153273f
C1662 D_C_3.t1 VSSD 0.057419f
C1663 D_C_3.n0 VSSD 1.04227f
C1664 a_35902_n82.n0 VSSD 1.29327f
C1665 a_35902_n82.t4 VSSD 0.038174f
C1666 a_35902_n82.t3 VSSD 0.090059f
C1667 a_35902_n82.n1 VSSD 0.298372f
C1668 a_35902_n82.t1 VSSD 0.147143f
C1669 a_35902_n82.t2 VSSD 0.1636f
C1670 a_35902_n82.t5 VSSD 0.130517f
C1671 a_35902_n82.n2 VSSD 2.29806f
C1672 a_35902_n82.t7 VSSD 0.128166f
C1673 a_35902_n82.n3 VSSD 1.28395f
C1674 a_35902_n82.t6 VSSD 0.088697f
C1675 a_35902_n82.n4 VSSD 1.24258f
C1676 a_35902_n82.t0 VSSD 0.397411f
C1677 a_46134_n18422.t3 VSSD 0.195425f
C1678 a_46134_n18422.t1 VSSD 0.074342f
C1679 a_46134_n18422.n0 VSSD 0.548729f
C1680 a_46134_n18422.t4 VSSD 0.02856f
C1681 a_46134_n18422.t5 VSSD 0.013095f
C1682 a_46134_n18422.n1 VSSD 0.140208f
C1683 a_46134_n18422.n2 VSSD 0.351639f
C1684 a_46134_n18422.t2 VSSD 0.06831f
C1685 a_46134_n18422.n3 VSSD 0.74963f
C1686 a_46134_n18422.t0 VSSD 0.230062f
C1687 a_106632_n3162.n0 VSSD 0.986176f
C1688 a_106632_n3162.t5 VSSD 0.035769f
C1689 a_106632_n3162.t4 VSSD 0.0164f
C1690 a_106632_n3162.n1 VSSD 0.173748f
C1691 a_106632_n3162.t3 VSSD 0.288155f
C1692 a_106632_n3162.t1 VSSD 0.085552f
C1693 a_106632_n3162.n2 VSSD 0.878128f
C1694 a_106632_n3162.t2 VSSD 0.085552f
C1695 a_106632_n3162.t0 VSSD 0.250521f
C1696 a_74818_n4422.t3 VSSD 0.141857f
C1697 a_74818_n4422.t4 VSSD 0.043229f
C1698 a_74818_n4422.t1 VSSD 0.043351f
C1699 a_74818_n4422.n0 VSSD 0.276169f
C1700 a_74818_n4422.t2 VSSD 0.48439f
C1701 a_74818_n4422.n1 VSSD 0.535288f
C1702 a_74818_n4422.n2 VSSD 1.09469f
C1703 a_74818_n4422.t0 VSSD 0.381025f
C1704 a_35002_n80.n0 VSSD 7.24543f
C1705 a_35002_n80.n1 VSSD 4.09072f
C1706 a_35002_n80.t7 VSSD 0.133561f
C1707 a_35002_n80.t4 VSSD 0.367163f
C1708 a_35002_n80.t2 VSSD 0.077933f
C1709 a_35002_n80.t3 VSSD 0.088897f
C1710 a_35002_n80.n2 VSSD 2.7214f
C1711 a_35002_n80.t1 VSSD 0.111234f
C1712 a_35002_n80.t6 VSSD 0.029289f
C1713 a_35002_n80.t5 VSSD 0.069099f
C1714 a_35002_n80.n3 VSSD 0.26036f
C1715 a_35002_n80.t0 VSSD 0.304917f
C1716 a_38822_n18190.t1 VSSD 0.198092f
C1717 a_38822_n18190.t3 VSSD 0.1503f
C1718 a_38822_n18190.t2 VSSD 0.111361f
C1719 a_38822_n18190.t4 VSSD 0.210813f
C1720 a_38822_n18190.n0 VSSD 2.80378f
C1721 a_38822_n18190.t5 VSSD 0.113403f
C1722 a_38822_n18190.n1 VSSD 1.56811f
C1723 a_38822_n18190.n2 VSSD 1.46985f
C1724 a_38822_n18190.n3 VSSD 1.46632f
C1725 a_38822_n18190.t0 VSSD 0.407979f
C1726 a_137342_n4422.n0 VSSD 1.4589f
C1727 a_137342_n4422.t1 VSSD 0.246654f
C1728 a_137342_n4422.t2 VSSD 0.075169f
C1729 a_137342_n4422.t4 VSSD 0.075381f
C1730 a_137342_n4422.n1 VSSD 0.480219f
C1731 a_137342_n4422.t3 VSSD 0.842287f
C1732 a_137342_n4422.n2 VSSD 0.872815f
C1733 a_137342_n4422.t5 VSSD 0.095963f
C1734 a_137342_n4422.t6 VSSD 0.044581f
C1735 a_137342_n4422.n3 VSSD 2.44958f
C1736 a_137342_n4422.t0 VSSD 0.658454f
C1737 a_38890_n14314.t1 VSSD 0.143873f
C1738 a_38890_n14314.t0 VSSD 0.043846f
C1739 a_38890_n14314.t4 VSSD 0.04397f
C1740 a_38890_n14314.n0 VSSD 0.280111f
C1741 a_38890_n14314.t3 VSSD 0.491305f
C1742 a_38890_n14314.n1 VSSD 0.534653f
C1743 a_38890_n14314.n2 VSSD 1.07817f
C1744 a_38890_n14314.t2 VSSD 0.384075f
C1745 a_106678_n18422.t2 VSSD 0.043351f
C1746 a_106678_n18422.t3 VSSD 0.043229f
C1747 a_106678_n18422.n0 VSSD 0.276169f
C1748 a_106678_n18422.t4 VSSD 0.381052f
C1749 a_106678_n18422.t0 VSSD 0.141857f
C1750 a_106678_n18422.n1 VSSD 1.09466f
C1751 a_106678_n18422.n2 VSSD 0.53535f
C1752 a_106678_n18422.t1 VSSD 0.484329f
C1753 SAR_Asynchronous_Logic_6/D_reset_FF_0.Q.n0 VSSD 1.54881f
C1754 SAR_Asynchronous_Logic_6/D_reset_FF_0.Q.t3 VSSD 0.094079f
C1755 SAR_Asynchronous_Logic_6/D_reset_FF_0.Q.t4 VSSD 0.043705f
C1756 SAR_Asynchronous_Logic_6/D_reset_FF_0.Q.n1 VSSD 0.314123f
C1757 SAR_Asynchronous_Logic_6/D_reset_FF_0.Q.t1 VSSD 0.073692f
C1758 SAR_Asynchronous_Logic_6/D_reset_FF_0.Q.t0 VSSD 0.073901f
C1759 SAR_Asynchronous_Logic_6/D_reset_FF_0.Q.n2 VSSD 0.470788f
C1760 SAR_Asynchronous_Logic_6/D_reset_FF_0.Q.t2 VSSD 0.825745f
C1761 SAR_Asynchronous_Logic_6/D_reset_FF_0.Q.t5 VSSD 0.038164f
C1762 SAR_Asynchronous_Logic_6/D_reset_FF_0.Q.t6 VSSD 0.090033f
C1763 SAR_Asynchronous_Logic_6/D_reset_FF_0.Q.n3 VSSD 0.293925f
C1764 SAR_Asynchronous_Logic_6/D_reset_FF_0.Q.n4 VSSD 1.06447f
C1765 D_C_4.t1 VSSD 0.153273f
C1766 D_C_4.t0 VSSD 0.057419f
C1767 D_C_4.n0 VSSD 1.04208f
C1768 a_108732_n13054.n0 VSSD 1.62009f
C1769 a_108732_n13054.t4 VSSD 0.058764f
C1770 a_108732_n13054.t5 VSSD 0.026943f
C1771 a_108732_n13054.n1 VSSD 0.285443f
C1772 a_108732_n13054.t3 VSSD 0.411624f
C1773 a_108732_n13054.t1 VSSD 0.14055f
C1774 a_108732_n13054.t2 VSSD 0.14055f
C1775 a_108732_n13054.n2 VSSD 1.44271f
C1776 a_108732_n13054.t0 VSSD 0.473328f
C1777 a_68722_n82.t1 VSSD 0.198092f
C1778 a_68722_n82.t3 VSSD 0.1503f
C1779 a_68722_n82.t2 VSSD 0.111361f
C1780 a_68722_n82.t5 VSSD 0.210813f
C1781 a_68722_n82.n0 VSSD 2.80378f
C1782 a_68722_n82.t4 VSSD 0.113403f
C1783 a_68722_n82.n1 VSSD 1.56811f
C1784 a_68722_n82.n2 VSSD 1.46985f
C1785 a_68722_n82.n3 VSSD 1.46632f
C1786 a_68722_n82.t0 VSSD 0.407979f
C1787 a_138818_n4422.t2 VSSD 0.043229f
C1788 a_138818_n4422.t1 VSSD 0.043351f
C1789 a_138818_n4422.n0 VSSD 0.276169f
C1790 a_138818_n4422.t3 VSSD 0.381059f
C1791 a_138818_n4422.t4 VSSD 0.141857f
C1792 a_138818_n4422.n1 VSSD 1.09466f
C1793 a_138818_n4422.n2 VSSD 0.535288f
C1794 a_138818_n4422.t0 VSSD 0.48439f
C1795 a_138632_n3162.n0 VSSD 0.986143f
C1796 a_138632_n3162.t5 VSSD 0.035769f
C1797 a_138632_n3162.t4 VSSD 0.0164f
C1798 a_138632_n3162.n1 VSSD 0.173748f
C1799 a_138632_n3162.t2 VSSD 0.250554f
C1800 a_138632_n3162.t0 VSSD 0.085552f
C1801 a_138632_n3162.t3 VSSD 0.085552f
C1802 a_138632_n3162.n2 VSSD 0.878169f
C1803 a_138632_n3162.t1 VSSD 0.288113f
C1804 a_44918_n14314.t3 VSSD 0.146586f
C1805 a_44918_n14314.t4 VSSD 0.04467f
C1806 a_44918_n14314.t1 VSSD 0.044796f
C1807 a_44918_n14314.n0 VSSD 0.285375f
C1808 a_44918_n14314.t2 VSSD 0.500537f
C1809 a_44918_n14314.n1 VSSD 0.55313f
C1810 a_44918_n14314.n2 VSSD 1.13118f
C1811 a_44918_n14314.t0 VSSD 0.393726f
C1812 SAR_Asynchronous_Logic_2/D_reset_FF_1.Q.n0 VSSD 1.0216f
C1813 SAR_Asynchronous_Logic_2/D_reset_FF_1.Q.t12 VSSD 0.062055f
C1814 SAR_Asynchronous_Logic_2/D_reset_FF_1.Q.t9 VSSD 0.028828f
C1815 SAR_Asynchronous_Logic_2/D_reset_FF_1.Q.n1 VSSD 0.207197f
C1816 SAR_Asynchronous_Logic_2/D_reset_FF_1.Q.t4 VSSD 0.048608f
C1817 SAR_Asynchronous_Logic_2/D_reset_FF_1.Q.t3 VSSD 0.048745f
C1818 SAR_Asynchronous_Logic_2/D_reset_FF_1.Q.n2 VSSD 0.310534f
C1819 SAR_Asynchronous_Logic_2/D_reset_FF_1.Q.t2 VSSD 0.544665f
C1820 SAR_Asynchronous_Logic_2/D_reset_FF_1.Q.t10 VSSD 0.025173f
C1821 SAR_Asynchronous_Logic_2/D_reset_FF_1.Q.t11 VSSD 0.059386f
C1822 SAR_Asynchronous_Logic_2/D_reset_FF_1.Q.n3 VSSD 0.193874f
C1823 SAR_Asynchronous_Logic_2/D_reset_FF_1.Q.n4 VSSD 0.70213f
C1824 SAR_Asynchronous_Logic_2/D_reset_FF_1.Q.t8 VSSD 0.425781f
C1825 SAR_Asynchronous_Logic_2/D_reset_FF_1.Q.t7 VSSD 0.159509f
C1826 SAR_Asynchronous_Logic_2/D_reset_FF_1.Q.n5 VSSD 1.43147f
C1827 SAR_Asynchronous_Logic_2/D_reset_FF_1.Q.t0 VSSD 0.425932f
C1828 SAR_Asynchronous_Logic_2/D_reset_FF_1.Q.t5 VSSD 0.162054f
C1829 SAR_Asynchronous_Logic_2/D_reset_FF_1.Q.n6 VSSD 1.31163f
C1830 SAR_Asynchronous_Logic_2/D_reset_FF_1.Q.t1 VSSD 0.425987f
C1831 SAR_Asynchronous_Logic_2/D_reset_FF_1.Q.t6 VSSD 0.162054f
C1832 SAR_Asynchronous_Logic_2/D_reset_FF_1.Q.n7 VSSD 1.2847f
C1833 SAR_Asynchronous_Logic_2/D_reset_FF_1.Q.n8 VSSD 1.12616f
C1834 SAR_Asynchronous_Logic_2/D_reset_FF_1.Q.n9 VSSD 1.20247f
C1835 a_36604_n3162.t3 VSSD 0.074342f
C1836 a_36604_n3162.t2 VSSD 0.23008f
C1837 a_36604_n3162.t0 VSSD 0.06831f
C1838 a_36604_n3162.n0 VSSD 0.749612f
C1839 a_36604_n3162.t4 VSSD 0.02856f
C1840 a_36604_n3162.t5 VSSD 0.013095f
C1841 a_36604_n3162.n1 VSSD 0.140216f
C1842 a_36604_n3162.n2 VSSD 0.351631f
C1843 a_36604_n3162.n3 VSSD 0.548758f
C1844 a_36604_n3162.t1 VSSD 0.195396f
C1845 a_n13146_1076.t1 VSSD 0.184779f
C1846 a_n13146_1076.t0 VSSD 0.131493f
C1847 a_n13146_1076.t3 VSSD 0.244385f
C1848 a_n13146_1076.n0 VSSD 0.779228f
C1849 a_n13146_1076.n1 VSSD 1.38904f
C1850 a_n13146_1076.t2 VSSD 0.171071f
C1851 a_n28998_n80.n0 VSSD 7.24543f
C1852 a_n28998_n80.n1 VSSD 4.09072f
C1853 a_n28998_n80.t7 VSSD 0.133561f
C1854 a_n28998_n80.t2 VSSD 0.367163f
C1855 a_n28998_n80.t6 VSSD 0.077933f
C1856 a_n28998_n80.t3 VSSD 0.088897f
C1857 a_n28998_n80.n2 VSSD 2.7214f
C1858 a_n28998_n80.t1 VSSD 0.111234f
C1859 a_n28998_n80.t5 VSSD 0.029289f
C1860 a_n28998_n80.t4 VSSD 0.069099f
C1861 a_n28998_n80.n3 VSSD 0.26036f
C1862 a_n28998_n80.t0 VSSD 0.304917f
C1863 a_100722_n4054.n0 VSSD 1.29292f
C1864 a_100722_n4054.t3 VSSD 0.038175f
C1865 a_100722_n4054.t5 VSSD 0.090059f
C1866 a_100722_n4054.n1 VSSD 0.298371f
C1867 a_100722_n4054.t1 VSSD 0.147144f
C1868 a_100722_n4054.t6 VSSD 0.1636f
C1869 a_100722_n4054.t2 VSSD 0.130517f
C1870 a_100722_n4054.n2 VSSD 2.29806f
C1871 a_100722_n4054.t4 VSSD 0.128165f
C1872 a_100722_n4054.n3 VSSD 1.28395f
C1873 a_100722_n4054.t7 VSSD 0.088694f
C1874 a_100722_n4054.n4 VSSD 1.24258f
C1875 a_100722_n4054.t0 VSSD 0.397759f
C1876 CK_8.t0 VSSD 0.00708f
C1877 CK_8.t1 VSSD 0.016703f
C1878 CK_8.n0 VSSD 1.18089f
C1879 a_5966_n314.n0 VSSD 1.62008f
C1880 a_5966_n314.t4 VSSD 0.058764f
C1881 a_5966_n314.t5 VSSD 0.026943f
C1882 a_5966_n314.n1 VSSD 0.285443f
C1883 a_5966_n314.t1 VSSD 0.411632f
C1884 a_5966_n314.t3 VSSD 0.14055f
C1885 a_5966_n314.t2 VSSD 0.14055f
C1886 a_5966_n314.n2 VSSD 1.44268f
C1887 a_5966_n314.t0 VSSD 0.473359f
C1888 D_C_10.t0 VSSD 0.135716f
C1889 D_C_10.t1 VSSD 0.050843f
C1890 D_C_10.n0 VSSD 1.52493f
C1891 a_32736_n13096.n0 VSSD 7.24543f
C1892 a_32736_n13096.n1 VSSD 4.09045f
C1893 a_32736_n13096.t6 VSSD 0.02929f
C1894 a_32736_n13096.t7 VSSD 0.069099f
C1895 a_32736_n13096.n2 VSSD 0.260362f
C1896 a_32736_n13096.t5 VSSD 0.13356f
C1897 a_32736_n13096.t3 VSSD 0.367163f
C1898 a_32736_n13096.t4 VSSD 0.077939f
C1899 a_32736_n13096.t2 VSSD 0.088896f
C1900 a_32736_n13096.n3 VSSD 2.7214f
C1901 a_32736_n13096.t1 VSSD 0.111234f
C1902 a_32736_n13096.t0 VSSD 0.305184f
C1903 a_32736_n13850.n0 VSSD 8.2746f
C1904 a_32736_n13850.n1 VSSD 4.39794f
C1905 a_32736_n13850.t7 VSSD 0.030514f
C1906 a_32736_n13850.t2 VSSD 0.071986f
C1907 a_32736_n13850.n2 VSSD 0.235314f
C1908 a_32736_n13850.t6 VSSD 0.12518f
C1909 a_32736_n13850.t3 VSSD 0.09841f
C1910 a_32736_n13850.t5 VSSD 0.097438f
C1911 a_32736_n13850.n3 VSSD 2.56472f
C1912 a_32736_n13850.t4 VSSD 0.270804f
C1913 a_32736_n13850.t1 VSSD 0.115882f
C1914 a_32736_n13850.t0 VSSD 0.317217f
C1915 SAR_Asynchronous_Logic_6/D_reset_FF_1.Q.n0 VSSD 1.02167f
C1916 SAR_Asynchronous_Logic_6/D_reset_FF_1.Q.t6 VSSD 0.425788f
C1917 SAR_Asynchronous_Logic_6/D_reset_FF_1.Q.t3 VSSD 0.159509f
C1918 SAR_Asynchronous_Logic_6/D_reset_FF_1.Q.n1 VSSD 1.43146f
C1919 SAR_Asynchronous_Logic_6/D_reset_FF_1.Q.t5 VSSD 0.425995f
C1920 SAR_Asynchronous_Logic_6/D_reset_FF_1.Q.t0 VSSD 0.162054f
C1921 SAR_Asynchronous_Logic_6/D_reset_FF_1.Q.n2 VSSD 1.31157f
C1922 SAR_Asynchronous_Logic_6/D_reset_FF_1.Q.t4 VSSD 0.425957f
C1923 SAR_Asynchronous_Logic_6/D_reset_FF_1.Q.t1 VSSD 0.162054f
C1924 SAR_Asynchronous_Logic_6/D_reset_FF_1.Q.n3 VSSD 1.28473f
C1925 SAR_Asynchronous_Logic_6/D_reset_FF_1.Q.n4 VSSD 1.12617f
C1926 SAR_Asynchronous_Logic_6/D_reset_FF_1.Q.n5 VSSD 1.20247f
C1927 SAR_Asynchronous_Logic_6/D_reset_FF_1.Q.t8 VSSD 0.048745f
C1928 SAR_Asynchronous_Logic_6/D_reset_FF_1.Q.t2 VSSD 0.048608f
C1929 SAR_Asynchronous_Logic_6/D_reset_FF_1.Q.n6 VSSD 0.310534f
C1930 SAR_Asynchronous_Logic_6/D_reset_FF_1.Q.t7 VSSD 0.544596f
C1931 SAR_Asynchronous_Logic_6/D_reset_FF_1.Q.t9 VSSD 0.062055f
C1932 SAR_Asynchronous_Logic_6/D_reset_FF_1.Q.t11 VSSD 0.028828f
C1933 SAR_Asynchronous_Logic_6/D_reset_FF_1.Q.n7 VSSD 0.207197f
C1934 SAR_Asynchronous_Logic_6/D_reset_FF_1.Q.t12 VSSD 0.025172f
C1935 SAR_Asynchronous_Logic_6/D_reset_FF_1.Q.t10 VSSD 0.059386f
C1936 SAR_Asynchronous_Logic_6/D_reset_FF_1.Q.n8 VSSD 0.193875f
C1937 SAR_Asynchronous_Logic_6/D_reset_FF_1.Q.n9 VSSD 0.702129f
C1938 a_n26034_n314.n0 VSSD 1.62008f
C1939 a_n26034_n314.t4 VSSD 0.058764f
C1940 a_n26034_n314.t5 VSSD 0.026943f
C1941 a_n26034_n314.n1 VSSD 0.285443f
C1942 a_n26034_n314.t3 VSSD 0.411632f
C1943 a_n26034_n314.t1 VSSD 0.14055f
C1944 a_n26034_n314.t0 VSSD 0.14055f
C1945 a_n26034_n314.n2 VSSD 1.44268f
C1946 a_n26034_n314.t2 VSSD 0.473359f
C1947 a_136578_n314.t1 VSSD 0.044796f
C1948 a_136578_n314.t4 VSSD 0.04467f
C1949 a_136578_n314.n0 VSSD 0.285375f
C1950 a_136578_n314.t2 VSSD 0.393754f
C1951 a_136578_n314.t3 VSSD 0.146586f
C1952 a_136578_n314.n1 VSSD 1.13115f
C1953 a_136578_n314.n2 VSSD 0.553195f
C1954 a_136578_n314.t0 VSSD 0.500473f
C1955 Bit_9.t3 VSSD 0.274799f
C1956 Bit_9.t2 VSSD 0.131286f
C1957 Bit_9.t0 VSSD 0.141817f
C1958 Bit_9.n0 VSSD 1.1122f
C1959 Bit_9.t1 VSSD 0.092214f
C1960 Bit_9.n1 VSSD 0.359588f
C1961 Bit_9.n2 VSSD 3.85002f
C1962 a_3002_n80.n0 VSSD 7.24543f
C1963 a_3002_n80.n1 VSSD 4.09072f
C1964 a_3002_n80.t2 VSSD 0.133561f
C1965 a_3002_n80.t6 VSSD 0.367163f
C1966 a_3002_n80.t3 VSSD 0.077933f
C1967 a_3002_n80.t4 VSSD 0.088897f
C1968 a_3002_n80.n2 VSSD 2.7214f
C1969 a_3002_n80.t1 VSSD 0.111234f
C1970 a_3002_n80.t7 VSSD 0.029289f
C1971 a_3002_n80.t5 VSSD 0.069099f
C1972 a_3002_n80.n3 VSSD 0.26036f
C1973 a_3002_n80.t0 VSSD 0.304917f
C1974 a_42678_n18422.t1 VSSD 0.043351f
C1975 a_42678_n18422.t2 VSSD 0.043229f
C1976 a_42678_n18422.n0 VSSD 0.276169f
C1977 a_42678_n18422.t3 VSSD 0.381052f
C1978 a_42678_n18422.t4 VSSD 0.141857f
C1979 a_42678_n18422.n1 VSSD 1.09466f
C1980 a_42678_n18422.n2 VSSD 0.53535f
C1981 a_42678_n18422.t0 VSSD 0.484329f
C1982 a_41050_n18422.n0 VSSD 1.4589f
C1983 a_41050_n18422.t2 VSSD 0.075381f
C1984 a_41050_n18422.t4 VSSD 0.075169f
C1985 a_41050_n18422.n1 VSSD 0.480219f
C1986 a_41050_n18422.t6 VSSD 0.095963f
C1987 a_41050_n18422.t5 VSSD 0.044581f
C1988 a_41050_n18422.t3 VSSD 0.658502f
C1989 a_41050_n18422.t0 VSSD 0.246654f
C1990 a_41050_n18422.n2 VSSD 2.44953f
C1991 a_41050_n18422.n3 VSSD 0.872922f
C1992 a_41050_n18422.t1 VSSD 0.84218f
C1993 SAR_Asynchronous_Logic_9/D_reset_FF_0.Q.n0 VSSD 1.54881f
C1994 SAR_Asynchronous_Logic_9/D_reset_FF_0.Q.t3 VSSD 0.094079f
C1995 SAR_Asynchronous_Logic_9/D_reset_FF_0.Q.t6 VSSD 0.043705f
C1996 SAR_Asynchronous_Logic_9/D_reset_FF_0.Q.n1 VSSD 0.314123f
C1997 SAR_Asynchronous_Logic_9/D_reset_FF_0.Q.t0 VSSD 0.073692f
C1998 SAR_Asynchronous_Logic_9/D_reset_FF_0.Q.t1 VSSD 0.073901f
C1999 SAR_Asynchronous_Logic_9/D_reset_FF_0.Q.n2 VSSD 0.470788f
C2000 SAR_Asynchronous_Logic_9/D_reset_FF_0.Q.t2 VSSD 0.825745f
C2001 SAR_Asynchronous_Logic_9/D_reset_FF_0.Q.t4 VSSD 0.038164f
C2002 SAR_Asynchronous_Logic_9/D_reset_FF_0.Q.t5 VSSD 0.090033f
C2003 SAR_Asynchronous_Logic_9/D_reset_FF_0.Q.n3 VSSD 0.293925f
C2004 SAR_Asynchronous_Logic_9/D_reset_FF_0.Q.n4 VSSD 1.06447f
C2005 a_100604_n3162.t2 VSSD 0.074342f
C2006 a_100604_n3162.t3 VSSD 0.23008f
C2007 a_100604_n3162.t0 VSSD 0.06831f
C2008 a_100604_n3162.n0 VSSD 0.749612f
C2009 a_100604_n3162.t5 VSSD 0.02856f
C2010 a_100604_n3162.t4 VSSD 0.013095f
C2011 a_100604_n3162.n1 VSSD 0.140216f
C2012 a_100604_n3162.n2 VSSD 0.351631f
C2013 a_100604_n3162.n3 VSSD 0.548758f
C2014 a_100604_n3162.t1 VSSD 0.195396f
C2015 a_36790_n4422.t0 VSSD 0.143873f
C2016 a_36790_n4422.t2 VSSD 0.043846f
C2017 a_36790_n4422.t3 VSSD 0.04397f
C2018 a_36790_n4422.n0 VSSD 0.280111f
C2019 a_36790_n4422.t4 VSSD 0.491305f
C2020 a_36790_n4422.n1 VSSD 0.534653f
C2021 a_36790_n4422.n2 VSSD 1.07817f
C2022 a_36790_n4422.t1 VSSD 0.384075f
C2023 VCM.t5 VSSD 0.163605f
C2024 VCM.t17 VSSD 0.062237f
C2025 VCM.n0 VSSD 1.10158f
C2026 VCM.t14 VSSD 0.163602f
C2027 VCM.t11 VSSD 0.062237f
C2028 VCM.n1 VSSD 0.844034f
C2029 VCM.n2 VSSD 8.8075f
C2030 VCM.t12 VSSD 0.163605f
C2031 VCM.t15 VSSD 0.062237f
C2032 VCM.n3 VSSD 0.999439f
C2033 VCM.n4 VSSD 7.57573f
C2034 VCM.t9 VSSD 0.163602f
C2035 VCM.t10 VSSD 0.062237f
C2036 VCM.n5 VSSD 0.844034f
C2037 VCM.n6 VSSD 7.20797f
C2038 VCM.t21 VSSD 0.163605f
C2039 VCM.t8 VSSD 0.062237f
C2040 VCM.n7 VSSD 0.999439f
C2041 VCM.n8 VSSD 7.57573f
C2042 VCM.t3 VSSD 0.163602f
C2043 VCM.t20 VSSD 0.062237f
C2044 VCM.n9 VSSD 0.844034f
C2045 VCM.n10 VSSD 7.20797f
C2046 VCM.t16 VSSD 0.163605f
C2047 VCM.t4 VSSD 0.062237f
C2048 VCM.n11 VSSD 0.999439f
C2049 VCM.n12 VSSD 7.57573f
C2050 VCM.t13 VSSD 0.163602f
C2051 VCM.t0 VSSD 0.062237f
C2052 VCM.n13 VSSD 0.844034f
C2053 VCM.n14 VSSD 7.20797f
C2054 VCM.t19 VSSD 0.163605f
C2055 VCM.t6 VSSD 0.062237f
C2056 VCM.n15 VSSD 0.999439f
C2057 VCM.n16 VSSD 7.57573f
C2058 VCM.t1 VSSD 0.163602f
C2059 VCM.t2 VSSD 0.062237f
C2060 VCM.n17 VSSD 0.844034f
C2061 VCM.n18 VSSD 7.20797f
C2062 VCM.t7 VSSD 0.163605f
C2063 VCM.t18 VSSD 0.062237f
C2064 VCM.n19 VSSD 0.999439f
C2065 VCM.n20 VSSD 9.28765f
C2066 Bit_10.t1 VSSD 0.188717f
C2067 Bit_10.t0 VSSD 0.09016f
C2068 Bit_10.t3 VSSD 0.097392f
C2069 Bit_10.n0 VSSD 0.7638f
C2070 Bit_10.t2 VSSD 0.063327f
C2071 Bit_10.n1 VSSD 0.246946f
C2072 Bit_10.n2 VSSD 2.64415f
C2073 a_n29890_n80.n0 VSSD 8.2746f
C2074 a_n29890_n80.n1 VSSD 4.39821f
C2075 a_n29890_n80.t5 VSSD 0.030513f
C2076 a_n29890_n80.t4 VSSD 0.071986f
C2077 a_n29890_n80.n2 VSSD 0.235316f
C2078 a_n29890_n80.t2 VSSD 0.125181f
C2079 a_n29890_n80.t6 VSSD 0.098408f
C2080 a_n29890_n80.t7 VSSD 0.097436f
C2081 a_n29890_n80.n3 VSSD 2.56472f
C2082 a_n29890_n80.t3 VSSD 0.270804f
C2083 a_n29890_n80.t1 VSSD 0.115882f
C2084 a_n29890_n80.t0 VSSD 0.316938f
C2085 a_48898_n18422.t3 VSSD 0.04397f
C2086 a_48898_n18422.t0 VSSD 0.043846f
C2087 a_48898_n18422.n0 VSSD 0.280111f
C2088 a_48898_n18422.t4 VSSD 0.384103f
C2089 a_48898_n18422.t1 VSSD 0.143873f
C2090 a_48898_n18422.n1 VSSD 1.07814f
C2091 a_48898_n18422.n2 VSSD 0.534715f
C2092 a_48898_n18422.t2 VSSD 0.491242f
C2093 SAR_Asynchronous_Logic_2/D_reset_FF_0.Q.n0 VSSD 1.06897f
C2094 SAR_Asynchronous_Logic_2/D_reset_FF_0.Q.t2 VSSD 0.051002f
C2095 SAR_Asynchronous_Logic_2/D_reset_FF_0.Q.t0 VSSD 0.050858f
C2096 SAR_Asynchronous_Logic_2/D_reset_FF_0.Q.n1 VSSD 0.32491f
C2097 SAR_Asynchronous_Logic_2/D_reset_FF_0.Q.t1 VSSD 0.569808f
C2098 SAR_Asynchronous_Logic_2/D_reset_FF_0.Q.t6 VSSD 0.064927f
C2099 SAR_Asynchronous_Logic_2/D_reset_FF_0.Q.t3 VSSD 0.030163f
C2100 SAR_Asynchronous_Logic_2/D_reset_FF_0.Q.n2 VSSD 0.216789f
C2101 SAR_Asynchronous_Logic_2/D_reset_FF_0.Q.t4 VSSD 0.026338f
C2102 SAR_Asynchronous_Logic_2/D_reset_FF_0.Q.t5 VSSD 0.062135f
C2103 SAR_Asynchronous_Logic_2/D_reset_FF_0.Q.n3 VSSD 0.20285f
C2104 SAR_Asynchronous_Logic_2/D_reset_FF_0.Q.n4 VSSD 0.734634f
C2105 a_n27278_n3300.t4 VSSD 0.150297f
C2106 a_n27278_n3300.t3 VSSD 0.111359f
C2107 a_n27278_n3300.t5 VSSD 0.210813f
C2108 a_n27278_n3300.n0 VSSD 2.80378f
C2109 a_n27278_n3300.t2 VSSD 0.113401f
C2110 a_n27278_n3300.n1 VSSD 1.56811f
C2111 a_n27278_n3300.n2 VSSD 1.46986f
C2112 a_n27278_n3300.t1 VSSD 0.198092f
C2113 a_n27278_n3300.n3 VSSD 1.4663f
C2114 a_n27278_n3300.t0 VSSD 0.407992f
C2115 a_8578_n314.t1 VSSD 0.146586f
C2116 a_8578_n314.t4 VSSD 0.044796f
C2117 a_8578_n314.t2 VSSD 0.04467f
C2118 a_8578_n314.n0 VSSD 0.285375f
C2119 a_8578_n314.t3 VSSD 0.500473f
C2120 a_8578_n314.n1 VSSD 0.553195f
C2121 a_8578_n314.n2 VSSD 1.1312f
C2122 a_8578_n314.t0 VSSD 0.393702f
C2123 a_6950_n314.n0 VSSD 1.4589f
C2124 a_6950_n314.t2 VSSD 0.075381f
C2125 a_6950_n314.t4 VSSD 0.075169f
C2126 a_6950_n314.n1 VSSD 0.480219f
C2127 a_6950_n314.t6 VSSD 0.095963f
C2128 a_6950_n314.t5 VSSD 0.044581f
C2129 a_6950_n314.t3 VSSD 0.658502f
C2130 a_6950_n314.t0 VSSD 0.246654f
C2131 a_6950_n314.n2 VSSD 2.44953f
C2132 a_6950_n314.n3 VSSD 0.872922f
C2133 a_6950_n314.t1 VSSD 0.84218f
C2134 a_14798_n314.t2 VSSD 0.143873f
C2135 a_14798_n314.t4 VSSD 0.04397f
C2136 a_14798_n314.t1 VSSD 0.043846f
C2137 a_14798_n314.n0 VSSD 0.280111f
C2138 a_14798_n314.t3 VSSD 0.491242f
C2139 a_14798_n314.n1 VSSD 0.534715f
C2140 a_14798_n314.n2 VSSD 1.07819f
C2141 a_14798_n314.t0 VSSD 0.384053f
C2142 a_4722_n82.t0 VSSD 0.198092f
C2143 a_4722_n82.t3 VSSD 0.1503f
C2144 a_4722_n82.t5 VSSD 0.111361f
C2145 a_4722_n82.t2 VSSD 0.210813f
C2146 a_4722_n82.n0 VSSD 2.80378f
C2147 a_4722_n82.t4 VSSD 0.113403f
C2148 a_4722_n82.n1 VSSD 1.56811f
C2149 a_4722_n82.n2 VSSD 1.46985f
C2150 a_4722_n82.n3 VSSD 1.46632f
C2151 a_4722_n82.t1 VSSD 0.407979f
C2152 SAR_Asynchronous_Logic_4/D_reset_FF_0.Q.n0 VSSD 1.06897f
C2153 SAR_Asynchronous_Logic_4/D_reset_FF_0.Q.t2 VSSD 0.051002f
C2154 SAR_Asynchronous_Logic_4/D_reset_FF_0.Q.t0 VSSD 0.050858f
C2155 SAR_Asynchronous_Logic_4/D_reset_FF_0.Q.n1 VSSD 0.32491f
C2156 SAR_Asynchronous_Logic_4/D_reset_FF_0.Q.t1 VSSD 0.569808f
C2157 SAR_Asynchronous_Logic_4/D_reset_FF_0.Q.t5 VSSD 0.064927f
C2158 SAR_Asynchronous_Logic_4/D_reset_FF_0.Q.t6 VSSD 0.030163f
C2159 SAR_Asynchronous_Logic_4/D_reset_FF_0.Q.n2 VSSD 0.216789f
C2160 SAR_Asynchronous_Logic_4/D_reset_FF_0.Q.t3 VSSD 0.026338f
C2161 SAR_Asynchronous_Logic_4/D_reset_FF_0.Q.t4 VSSD 0.062135f
C2162 SAR_Asynchronous_Logic_4/D_reset_FF_0.Q.n3 VSSD 0.20285f
C2163 SAR_Asynchronous_Logic_4/D_reset_FF_0.Q.n4 VSSD 0.734634f
C2164 SAR_Asynchronous_Logic_5/D_reset_FF_0.Q.n0 VSSD 1.54881f
C2165 SAR_Asynchronous_Logic_5/D_reset_FF_0.Q.t4 VSSD 0.094079f
C2166 SAR_Asynchronous_Logic_5/D_reset_FF_0.Q.t6 VSSD 0.043705f
C2167 SAR_Asynchronous_Logic_5/D_reset_FF_0.Q.n1 VSSD 0.314123f
C2168 SAR_Asynchronous_Logic_5/D_reset_FF_0.Q.t0 VSSD 0.073692f
C2169 SAR_Asynchronous_Logic_5/D_reset_FF_0.Q.t2 VSSD 0.073901f
C2170 SAR_Asynchronous_Logic_5/D_reset_FF_0.Q.n2 VSSD 0.470788f
C2171 SAR_Asynchronous_Logic_5/D_reset_FF_0.Q.t1 VSSD 0.825745f
C2172 SAR_Asynchronous_Logic_5/D_reset_FF_0.Q.t3 VSSD 0.038164f
C2173 SAR_Asynchronous_Logic_5/D_reset_FF_0.Q.t5 VSSD 0.090033f
C2174 SAR_Asynchronous_Logic_5/D_reset_FF_0.Q.n3 VSSD 0.293925f
C2175 SAR_Asynchronous_Logic_5/D_reset_FF_0.Q.n4 VSSD 1.06447f
C2176 Bit_7.t1 VSSD 0.274799f
C2177 Bit_7.t2 VSSD 0.131286f
C2178 Bit_7.t3 VSSD 0.141817f
C2179 Bit_7.n0 VSSD 1.1122f
C2180 Bit_7.t0 VSSD 0.092214f
C2181 Bit_7.n1 VSSD 0.359588f
C2182 Bit_7.n2 VSSD 3.85002f
C2183 a_6890_n14314.t1 VSSD 0.143873f
C2184 a_6890_n14314.t0 VSSD 0.043846f
C2185 a_6890_n14314.t4 VSSD 0.04397f
C2186 a_6890_n14314.n0 VSSD 0.280111f
C2187 a_6890_n14314.t3 VSSD 0.491305f
C2188 a_6890_n14314.n1 VSSD 0.534653f
C2189 a_6890_n14314.n2 VSSD 1.07817f
C2190 a_6890_n14314.t2 VSSD 0.384075f
C2191 CK_7.t1 VSSD 0.00708f
C2192 CK_7.t0 VSSD 0.016703f
C2193 CK_7.n0 VSSD 1.18099f
C2194 a_9050_n18422.n0 VSSD 1.4589f
C2195 a_9050_n18422.t3 VSSD 0.246654f
C2196 a_9050_n18422.t5 VSSD 0.095963f
C2197 a_9050_n18422.t6 VSSD 0.044581f
C2198 a_9050_n18422.t2 VSSD 0.075381f
C2199 a_9050_n18422.t4 VSSD 0.075169f
C2200 a_9050_n18422.n1 VSSD 0.480219f
C2201 a_9050_n18422.t1 VSSD 0.84218f
C2202 a_9050_n18422.n2 VSSD 0.872922f
C2203 a_9050_n18422.n3 VSSD 2.44962f
C2204 a_9050_n18422.t0 VSSD 0.658416f
C2205 a_134002_n18190.n0 VSSD 1.29327f
C2206 a_134002_n18190.t4 VSSD 0.038174f
C2207 a_134002_n18190.t5 VSSD 0.090059f
C2208 a_134002_n18190.n1 VSSD 0.298372f
C2209 a_134002_n18190.t1 VSSD 0.147143f
C2210 a_134002_n18190.t3 VSSD 0.1636f
C2211 a_134002_n18190.t2 VSSD 0.130517f
C2212 a_134002_n18190.n2 VSSD 2.29806f
C2213 a_134002_n18190.t6 VSSD 0.128166f
C2214 a_134002_n18190.n3 VSSD 1.28395f
C2215 a_134002_n18190.t7 VSSD 0.088697f
C2216 a_134002_n18190.n4 VSSD 1.24258f
C2217 a_134002_n18190.t0 VSSD 0.397411f
C2218 a_132790_n4422.t1 VSSD 0.143873f
C2219 a_132790_n4422.t0 VSSD 0.043846f
C2220 a_132790_n4422.t4 VSSD 0.04397f
C2221 a_132790_n4422.n0 VSSD 0.280111f
C2222 a_132790_n4422.t3 VSSD 0.491305f
C2223 a_132790_n4422.n1 VSSD 0.534653f
C2224 a_132790_n4422.n2 VSSD 1.07817f
C2225 a_132790_n4422.t2 VSSD 0.384075f
C2226 Bit_5.t0 VSSD 0.271488f
C2227 Bit_5.t1 VSSD 0.129704f
C2228 Bit_5.t3 VSSD 0.140108f
C2229 Bit_5.n0 VSSD 1.0988f
C2230 Bit_5.t2 VSSD 0.091103f
C2231 Bit_5.n1 VSSD 0.355256f
C2232 Bit_5.n2 VSSD 3.80364f
C2233 a_4604_n3162.t3 VSSD 0.074342f
C2234 a_4604_n3162.t2 VSSD 0.23008f
C2235 a_4604_n3162.t0 VSSD 0.06831f
C2236 a_4604_n3162.n0 VSSD 0.749612f
C2237 a_4604_n3162.t4 VSSD 0.02856f
C2238 a_4604_n3162.t5 VSSD 0.013095f
C2239 a_4604_n3162.n1 VSSD 0.140216f
C2240 a_4604_n3162.n2 VSSD 0.351631f
C2241 a_4604_n3162.n3 VSSD 0.548758f
C2242 a_4604_n3162.t1 VSSD 0.195396f
C2243 a_4722_n4054.n0 VSSD 1.29292f
C2244 a_4722_n4054.t3 VSSD 0.038175f
C2245 a_4722_n4054.t5 VSSD 0.090059f
C2246 a_4722_n4054.n1 VSSD 0.298371f
C2247 a_4722_n4054.t1 VSSD 0.147144f
C2248 a_4722_n4054.t2 VSSD 0.1636f
C2249 a_4722_n4054.t4 VSSD 0.130517f
C2250 a_4722_n4054.n2 VSSD 2.29806f
C2251 a_4722_n4054.t6 VSSD 0.128165f
C2252 a_4722_n4054.n3 VSSD 1.28395f
C2253 a_4722_n4054.t7 VSSD 0.088694f
C2254 a_4722_n4054.n4 VSSD 1.24258f
C2255 a_4722_n4054.t0 VSSD 0.397759f
C2256 a_37966_n314.n0 VSSD 1.62008f
C2257 a_37966_n314.t5 VSSD 0.058764f
C2258 a_37966_n314.t4 VSSD 0.026943f
C2259 a_37966_n314.n1 VSSD 0.285443f
C2260 a_37966_n314.t3 VSSD 0.411632f
C2261 a_37966_n314.t0 VSSD 0.14055f
C2262 a_37966_n314.t2 VSSD 0.14055f
C2263 a_37966_n314.n2 VSSD 1.44268f
C2264 a_37966_n314.t1 VSSD 0.473359f
C2265 a_40578_n314.t0 VSSD 0.044796f
C2266 a_40578_n314.t3 VSSD 0.04467f
C2267 a_40578_n314.n0 VSSD 0.285375f
C2268 a_40578_n314.t2 VSSD 0.393754f
C2269 a_40578_n314.t4 VSSD 0.146586f
C2270 a_40578_n314.n1 VSSD 1.13115f
C2271 a_40578_n314.n2 VSSD 0.553195f
C2272 a_40578_n314.t1 VSSD 0.500473f
C2273 a_36722_n82.t1 VSSD 0.198092f
C2274 a_36722_n82.t5 VSSD 0.1503f
C2275 a_36722_n82.t4 VSSD 0.111361f
C2276 a_36722_n82.t3 VSSD 0.210813f
C2277 a_36722_n82.n0 VSSD 2.80378f
C2278 a_36722_n82.t2 VSSD 0.113403f
C2279 a_36722_n82.n1 VSSD 1.56811f
C2280 a_36722_n82.n2 VSSD 1.46985f
C2281 a_36722_n82.n3 VSSD 1.46632f
C2282 a_36722_n82.t0 VSSD 0.407979f
C2283 a_100722_n82.t1 VSSD 0.198092f
C2284 a_100722_n82.t3 VSSD 0.1503f
C2285 a_100722_n82.t2 VSSD 0.111361f
C2286 a_100722_n82.t5 VSSD 0.210813f
C2287 a_100722_n82.n0 VSSD 2.80378f
C2288 a_100722_n82.t4 VSSD 0.113403f
C2289 a_100722_n82.n1 VSSD 1.56811f
C2290 a_100722_n82.n2 VSSD 1.46985f
C2291 a_100722_n82.n3 VSSD 1.46632f
C2292 a_100722_n82.t0 VSSD 0.407979f
C2293 SAR_Asynchronous_Logic_10/D_reset_FF_1.Q.n0 VSSD 1.0216f
C2294 SAR_Asynchronous_Logic_10/D_reset_FF_1.Q.t9 VSSD 0.062055f
C2295 SAR_Asynchronous_Logic_10/D_reset_FF_1.Q.t10 VSSD 0.028828f
C2296 SAR_Asynchronous_Logic_10/D_reset_FF_1.Q.n1 VSSD 0.207197f
C2297 SAR_Asynchronous_Logic_10/D_reset_FF_1.Q.t5 VSSD 0.048608f
C2298 SAR_Asynchronous_Logic_10/D_reset_FF_1.Q.t3 VSSD 0.048745f
C2299 SAR_Asynchronous_Logic_10/D_reset_FF_1.Q.n2 VSSD 0.310534f
C2300 SAR_Asynchronous_Logic_10/D_reset_FF_1.Q.t4 VSSD 0.544665f
C2301 SAR_Asynchronous_Logic_10/D_reset_FF_1.Q.t11 VSSD 0.025173f
C2302 SAR_Asynchronous_Logic_10/D_reset_FF_1.Q.t12 VSSD 0.059386f
C2303 SAR_Asynchronous_Logic_10/D_reset_FF_1.Q.n3 VSSD 0.193874f
C2304 SAR_Asynchronous_Logic_10/D_reset_FF_1.Q.n4 VSSD 0.70213f
C2305 SAR_Asynchronous_Logic_10/D_reset_FF_1.Q.t6 VSSD 0.425781f
C2306 SAR_Asynchronous_Logic_10/D_reset_FF_1.Q.t7 VSSD 0.159509f
C2307 SAR_Asynchronous_Logic_10/D_reset_FF_1.Q.n5 VSSD 1.43147f
C2308 SAR_Asynchronous_Logic_10/D_reset_FF_1.Q.t1 VSSD 0.425932f
C2309 SAR_Asynchronous_Logic_10/D_reset_FF_1.Q.t0 VSSD 0.162054f
C2310 SAR_Asynchronous_Logic_10/D_reset_FF_1.Q.n6 VSSD 1.31163f
C2311 SAR_Asynchronous_Logic_10/D_reset_FF_1.Q.t2 VSSD 0.425987f
C2312 SAR_Asynchronous_Logic_10/D_reset_FF_1.Q.t8 VSSD 0.162054f
C2313 SAR_Asynchronous_Logic_10/D_reset_FF_1.Q.n7 VSSD 1.2847f
C2314 SAR_Asynchronous_Logic_10/D_reset_FF_1.Q.n8 VSSD 1.12616f
C2315 SAR_Asynchronous_Logic_10/D_reset_FF_1.Q.n9 VSSD 1.20247f
C2316 a_128736_n13850.n0 VSSD 8.2746f
C2317 a_128736_n13850.n1 VSSD 4.39794f
C2318 a_128736_n13850.t6 VSSD 0.030514f
C2319 a_128736_n13850.t7 VSSD 0.071986f
C2320 a_128736_n13850.n2 VSSD 0.235314f
C2321 a_128736_n13850.t4 VSSD 0.12518f
C2322 a_128736_n13850.t3 VSSD 0.09841f
C2323 a_128736_n13850.t2 VSSD 0.097438f
C2324 a_128736_n13850.n3 VSSD 2.56472f
C2325 a_128736_n13850.t5 VSSD 0.270804f
C2326 a_128736_n13850.t0 VSSD 0.115882f
C2327 a_128736_n13850.t1 VSSD 0.317217f
C2328 a_38002_n18190.n0 VSSD 1.29327f
C2329 a_38002_n18190.t2 VSSD 0.038174f
C2330 a_38002_n18190.t3 VSSD 0.090059f
C2331 a_38002_n18190.n1 VSSD 0.298372f
C2332 a_38002_n18190.t1 VSSD 0.147143f
C2333 a_38002_n18190.t6 VSSD 0.1636f
C2334 a_38002_n18190.t7 VSSD 0.130517f
C2335 a_38002_n18190.n2 VSSD 2.29806f
C2336 a_38002_n18190.t5 VSSD 0.128166f
C2337 a_38002_n18190.n3 VSSD 1.28395f
C2338 a_38002_n18190.t4 VSSD 0.088697f
C2339 a_38002_n18190.n4 VSSD 1.24258f
C2340 a_38002_n18190.t0 VSSD 0.397411f
C2341 a_142134_n18422.t2 VSSD 0.195425f
C2342 a_142134_n18422.t1 VSSD 0.074342f
C2343 a_142134_n18422.n0 VSSD 0.548729f
C2344 a_142134_n18422.t4 VSSD 0.02856f
C2345 a_142134_n18422.t5 VSSD 0.013095f
C2346 a_142134_n18422.n1 VSSD 0.140208f
C2347 a_142134_n18422.n2 VSSD 0.351639f
C2348 a_142134_n18422.t3 VSSD 0.06831f
C2349 a_142134_n18422.n3 VSSD 0.74963f
C2350 a_142134_n18422.t0 VSSD 0.230062f
C2351 a_134822_n18190.t0 VSSD 0.198092f
C2352 a_134822_n18190.t4 VSSD 0.1503f
C2353 a_134822_n18190.t3 VSSD 0.111361f
C2354 a_134822_n18190.t2 VSSD 0.210813f
C2355 a_134822_n18190.n0 VSSD 2.80378f
C2356 a_134822_n18190.t5 VSSD 0.113403f
C2357 a_134822_n18190.n1 VSSD 1.56811f
C2358 a_134822_n18190.n2 VSSD 1.46985f
C2359 a_134822_n18190.n3 VSSD 1.46632f
C2360 a_134822_n18190.t1 VSSD 0.407979f
C2361 SAR_Asynchronous_Logic_9/D_reset_FF_1.Q.n0 VSSD 1.02167f
C2362 SAR_Asynchronous_Logic_9/D_reset_FF_1.Q.t6 VSSD 0.425788f
C2363 SAR_Asynchronous_Logic_9/D_reset_FF_1.Q.t2 VSSD 0.159509f
C2364 SAR_Asynchronous_Logic_9/D_reset_FF_1.Q.n1 VSSD 1.43146f
C2365 SAR_Asynchronous_Logic_9/D_reset_FF_1.Q.t3 VSSD 0.425995f
C2366 SAR_Asynchronous_Logic_9/D_reset_FF_1.Q.t7 VSSD 0.162054f
C2367 SAR_Asynchronous_Logic_9/D_reset_FF_1.Q.n2 VSSD 1.31157f
C2368 SAR_Asynchronous_Logic_9/D_reset_FF_1.Q.t4 VSSD 0.425995f
C2369 SAR_Asynchronous_Logic_9/D_reset_FF_1.Q.t8 VSSD 0.162054f
C2370 SAR_Asynchronous_Logic_9/D_reset_FF_1.Q.n3 VSSD 1.28469f
C2371 SAR_Asynchronous_Logic_9/D_reset_FF_1.Q.n4 VSSD 1.12616f
C2372 SAR_Asynchronous_Logic_9/D_reset_FF_1.Q.n5 VSSD 1.20247f
C2373 SAR_Asynchronous_Logic_9/D_reset_FF_1.Q.t0 VSSD 0.048745f
C2374 SAR_Asynchronous_Logic_9/D_reset_FF_1.Q.t5 VSSD 0.048608f
C2375 SAR_Asynchronous_Logic_9/D_reset_FF_1.Q.n6 VSSD 0.310534f
C2376 SAR_Asynchronous_Logic_9/D_reset_FF_1.Q.t1 VSSD 0.544596f
C2377 SAR_Asynchronous_Logic_9/D_reset_FF_1.Q.t12 VSSD 0.062055f
C2378 SAR_Asynchronous_Logic_9/D_reset_FF_1.Q.t11 VSSD 0.028828f
C2379 SAR_Asynchronous_Logic_9/D_reset_FF_1.Q.n7 VSSD 0.207197f
C2380 SAR_Asynchronous_Logic_9/D_reset_FF_1.Q.t10 VSSD 0.025172f
C2381 SAR_Asynchronous_Logic_9/D_reset_FF_1.Q.t9 VSSD 0.059386f
C2382 SAR_Asynchronous_Logic_9/D_reset_FF_1.Q.n8 VSSD 0.193875f
C2383 SAR_Asynchronous_Logic_9/D_reset_FF_1.Q.n9 VSSD 0.702129f
C2384 a_70822_n13192.t5 VSSD 0.150297f
C2385 a_70822_n13192.t3 VSSD 0.111359f
C2386 a_70822_n13192.t2 VSSD 0.210813f
C2387 a_70822_n13192.n0 VSSD 2.80378f
C2388 a_70822_n13192.t4 VSSD 0.113401f
C2389 a_70822_n13192.n1 VSSD 1.56811f
C2390 a_70822_n13192.n2 VSSD 1.46986f
C2391 a_70822_n13192.t1 VSSD 0.198092f
C2392 a_70822_n13192.n3 VSSD 1.4663f
C2393 a_70822_n13192.t0 VSSD 0.407992f
C2394 a_134890_n14314.t0 VSSD 0.043846f
C2395 a_134890_n14314.t3 VSSD 0.04397f
C2396 a_134890_n14314.n0 VSSD 0.280111f
C2397 a_134890_n14314.t4 VSSD 0.38411f
C2398 a_134890_n14314.t1 VSSD 0.143873f
C2399 a_134890_n14314.n1 VSSD 1.07813f
C2400 a_134890_n14314.n2 VSSD 0.534653f
C2401 a_134890_n14314.t2 VSSD 0.491305f
C2402 a_137050_n18422.n0 VSSD 1.4589f
C2403 a_137050_n18422.t0 VSSD 0.075381f
C2404 a_137050_n18422.t4 VSSD 0.075169f
C2405 a_137050_n18422.n1 VSSD 0.480219f
C2406 a_137050_n18422.t5 VSSD 0.095963f
C2407 a_137050_n18422.t6 VSSD 0.044581f
C2408 a_137050_n18422.t2 VSSD 0.658502f
C2409 a_137050_n18422.t3 VSSD 0.246654f
C2410 a_137050_n18422.n2 VSSD 2.44953f
C2411 a_137050_n18422.n3 VSSD 0.872922f
C2412 a_137050_n18422.t1 VSSD 0.84218f
C2413 a_136066_n18422.n0 VSSD 0.986138f
C2414 a_136066_n18422.t5 VSSD 0.035769f
C2415 a_136066_n18422.t4 VSSD 0.0164f
C2416 a_136066_n18422.n1 VSSD 0.173748f
C2417 a_136066_n18422.t3 VSSD 0.250558f
C2418 a_136066_n18422.t2 VSSD 0.085552f
C2419 a_136066_n18422.t0 VSSD 0.085552f
C2420 a_136066_n18422.n2 VSSD 0.878151f
C2421 a_136066_n18422.t1 VSSD 0.288131f
C2422 a_n25050_n314.n0 VSSD 1.4589f
C2423 a_n25050_n314.t1 VSSD 0.075381f
C2424 a_n25050_n314.t4 VSSD 0.075169f
C2425 a_n25050_n314.n1 VSSD 0.480219f
C2426 a_n25050_n314.t6 VSSD 0.095963f
C2427 a_n25050_n314.t5 VSSD 0.044581f
C2428 a_n25050_n314.t3 VSSD 0.658502f
C2429 a_n25050_n314.t2 VSSD 0.246654f
C2430 a_n25050_n314.n2 VSSD 2.44953f
C2431 a_n25050_n314.n3 VSSD 0.872922f
C2432 a_n25050_n314.t0 VSSD 0.84218f
C2433 a_43442_n14314.n0 VSSD 1.4589f
C2434 a_43442_n14314.t3 VSSD 0.246654f
C2435 a_43442_n14314.t4 VSSD 0.075169f
C2436 a_43442_n14314.t1 VSSD 0.075381f
C2437 a_43442_n14314.n1 VSSD 0.480219f
C2438 a_43442_n14314.t2 VSSD 0.842287f
C2439 a_43442_n14314.n2 VSSD 0.872815f
C2440 a_43442_n14314.t6 VSSD 0.095963f
C2441 a_43442_n14314.t5 VSSD 0.044581f
C2442 a_43442_n14314.n3 VSSD 2.44958f
C2443 a_43442_n14314.t0 VSSD 0.658454f
C2444 a_38822_n13946.n0 VSSD 1.29292f
C2445 a_38822_n13946.t6 VSSD 0.038175f
C2446 a_38822_n13946.t7 VSSD 0.090059f
C2447 a_38822_n13946.n1 VSSD 0.298371f
C2448 a_38822_n13946.t0 VSSD 0.147144f
C2449 a_38822_n13946.t5 VSSD 0.1636f
C2450 a_38822_n13946.t2 VSSD 0.130517f
C2451 a_38822_n13946.n2 VSSD 2.29806f
C2452 a_38822_n13946.t4 VSSD 0.128165f
C2453 a_38822_n13946.n3 VSSD 1.28395f
C2454 a_38822_n13946.t3 VSSD 0.088694f
C2455 a_38822_n13946.n4 VSSD 1.24258f
C2456 a_38822_n13946.t1 VSSD 0.397759f
C2457 a_102822_n13192.t5 VSSD 0.150297f
C2458 a_102822_n13192.t3 VSSD 0.111359f
C2459 a_102822_n13192.t2 VSSD 0.210813f
C2460 a_102822_n13192.n0 VSSD 2.80378f
C2461 a_102822_n13192.t4 VSSD 0.113401f
C2462 a_102822_n13192.n1 VSSD 1.56811f
C2463 a_102822_n13192.n2 VSSD 1.46986f
C2464 a_102822_n13192.t1 VSSD 0.198092f
C2465 a_102822_n13192.n3 VSSD 1.4663f
C2466 a_102822_n13192.t0 VSSD 0.407992f
C2467 SAR_Asynchronous_Logic_3/D_reset_FF_0.Q.n0 VSSD 1.54881f
C2468 SAR_Asynchronous_Logic_3/D_reset_FF_0.Q.t6 VSSD 0.094079f
C2469 SAR_Asynchronous_Logic_3/D_reset_FF_0.Q.t3 VSSD 0.043705f
C2470 SAR_Asynchronous_Logic_3/D_reset_FF_0.Q.n1 VSSD 0.314123f
C2471 SAR_Asynchronous_Logic_3/D_reset_FF_0.Q.t0 VSSD 0.073692f
C2472 SAR_Asynchronous_Logic_3/D_reset_FF_0.Q.t2 VSSD 0.073901f
C2473 SAR_Asynchronous_Logic_3/D_reset_FF_0.Q.n2 VSSD 0.470788f
C2474 SAR_Asynchronous_Logic_3/D_reset_FF_0.Q.t1 VSSD 0.825745f
C2475 SAR_Asynchronous_Logic_3/D_reset_FF_0.Q.t4 VSSD 0.038164f
C2476 SAR_Asynchronous_Logic_3/D_reset_FF_0.Q.t5 VSSD 0.090033f
C2477 SAR_Asynchronous_Logic_3/D_reset_FF_0.Q.n3 VSSD 0.293925f
C2478 SAR_Asynchronous_Logic_3/D_reset_FF_0.Q.n4 VSSD 1.06447f
C2479 a_102950_n314.n0 VSSD 1.4589f
C2480 a_102950_n314.t2 VSSD 0.246654f
C2481 a_102950_n314.t5 VSSD 0.095963f
C2482 a_102950_n314.t6 VSSD 0.044581f
C2483 a_102950_n314.t1 VSSD 0.075381f
C2484 a_102950_n314.t4 VSSD 0.075169f
C2485 a_102950_n314.n1 VSSD 0.480219f
C2486 a_102950_n314.t3 VSSD 0.84218f
C2487 a_102950_n314.n2 VSSD 0.872922f
C2488 a_102950_n314.n3 VSSD 2.44962f
C2489 a_102950_n314.t0 VSSD 0.658416f
C2490 a_99902_n82.n0 VSSD 1.29327f
C2491 a_99902_n82.t5 VSSD 0.038174f
C2492 a_99902_n82.t3 VSSD 0.090059f
C2493 a_99902_n82.n1 VSSD 0.298372f
C2494 a_99902_n82.t1 VSSD 0.147143f
C2495 a_99902_n82.t7 VSSD 0.1636f
C2496 a_99902_n82.t2 VSSD 0.130517f
C2497 a_99902_n82.n2 VSSD 2.29806f
C2498 a_99902_n82.t4 VSSD 0.128166f
C2499 a_99902_n82.n3 VSSD 1.28395f
C2500 a_99902_n82.t6 VSSD 0.088697f
C2501 a_99902_n82.n4 VSSD 1.24258f
C2502 a_99902_n82.t0 VSSD 0.397411f
C2503 a_75442_n14314.n0 VSSD 1.4589f
C2504 a_75442_n14314.t4 VSSD 0.075169f
C2505 a_75442_n14314.t2 VSSD 0.075381f
C2506 a_75442_n14314.n1 VSSD 0.480219f
C2507 a_75442_n14314.t5 VSSD 0.095963f
C2508 a_75442_n14314.t6 VSSD 0.044581f
C2509 a_75442_n14314.t3 VSSD 0.658513f
C2510 a_75442_n14314.t0 VSSD 0.246654f
C2511 a_75442_n14314.n2 VSSD 2.44952f
C2512 a_75442_n14314.n3 VSSD 0.872815f
C2513 a_75442_n14314.t1 VSSD 0.842287f
C2514 a_76732_n13054.n0 VSSD 1.62015f
C2515 a_76732_n13054.t5 VSSD 0.058764f
C2516 a_76732_n13054.t4 VSSD 0.026943f
C2517 a_76732_n13054.n1 VSSD 0.285443f
C2518 a_76732_n13054.t2 VSSD 0.473397f
C2519 a_76732_n13054.t1 VSSD 0.14055f
C2520 a_76732_n13054.n2 VSSD 1.44264f
C2521 a_76732_n13054.t3 VSSD 0.14055f
C2522 a_76732_n13054.t0 VSSD 0.41157f
C2523 Bit_3.t1 VSSD 0.312254f
C2524 Bit_3.t2 VSSD 0.161147f
C2525 Bit_3.t3 VSSD 0.149179f
C2526 Bit_3.n0 VSSD 1.26379f
C2527 Bit_3.t0 VSSD 0.104782f
C2528 Bit_3.n1 VSSD 0.4086f
C2529 Bit_3.n2 VSSD 2.41717f
C2530 SAR_Asynchronous_Logic_0/D_reset_FF_1.Q.n0 VSSD 1.02167f
C2531 SAR_Asynchronous_Logic_0/D_reset_FF_1.Q.t4 VSSD 0.42575f
C2532 SAR_Asynchronous_Logic_0/D_reset_FF_1.Q.t1 VSSD 0.159509f
C2533 SAR_Asynchronous_Logic_0/D_reset_FF_1.Q.n1 VSSD 1.4315f
C2534 SAR_Asynchronous_Logic_0/D_reset_FF_1.Q.t5 VSSD 0.425995f
C2535 SAR_Asynchronous_Logic_0/D_reset_FF_1.Q.t2 VSSD 0.162054f
C2536 SAR_Asynchronous_Logic_0/D_reset_FF_1.Q.n2 VSSD 1.31157f
C2537 SAR_Asynchronous_Logic_0/D_reset_FF_1.Q.t8 VSSD 0.425995f
C2538 SAR_Asynchronous_Logic_0/D_reset_FF_1.Q.t3 VSSD 0.162054f
C2539 SAR_Asynchronous_Logic_0/D_reset_FF_1.Q.n3 VSSD 1.28469f
C2540 SAR_Asynchronous_Logic_0/D_reset_FF_1.Q.n4 VSSD 1.12616f
C2541 SAR_Asynchronous_Logic_0/D_reset_FF_1.Q.n5 VSSD 1.20247f
C2542 SAR_Asynchronous_Logic_0/D_reset_FF_1.Q.t6 VSSD 0.048745f
C2543 SAR_Asynchronous_Logic_0/D_reset_FF_1.Q.t0 VSSD 0.048608f
C2544 SAR_Asynchronous_Logic_0/D_reset_FF_1.Q.n6 VSSD 0.310534f
C2545 SAR_Asynchronous_Logic_0/D_reset_FF_1.Q.t7 VSSD 0.544596f
C2546 SAR_Asynchronous_Logic_0/D_reset_FF_1.Q.t10 VSSD 0.062055f
C2547 SAR_Asynchronous_Logic_0/D_reset_FF_1.Q.t12 VSSD 0.028828f
C2548 SAR_Asynchronous_Logic_0/D_reset_FF_1.Q.n7 VSSD 0.207197f
C2549 SAR_Asynchronous_Logic_0/D_reset_FF_1.Q.t11 VSSD 0.025172f
C2550 SAR_Asynchronous_Logic_0/D_reset_FF_1.Q.t9 VSSD 0.059386f
C2551 SAR_Asynchronous_Logic_0/D_reset_FF_1.Q.n8 VSSD 0.193875f
C2552 SAR_Asynchronous_Logic_0/D_reset_FF_1.Q.n9 VSSD 0.702129f
C2553 SAR_Asynchronous_Logic_7/D_reset_FF_1.Q.n0 VSSD 1.0216f
C2554 SAR_Asynchronous_Logic_7/D_reset_FF_1.Q.t10 VSSD 0.062055f
C2555 SAR_Asynchronous_Logic_7/D_reset_FF_1.Q.t11 VSSD 0.028828f
C2556 SAR_Asynchronous_Logic_7/D_reset_FF_1.Q.n1 VSSD 0.207197f
C2557 SAR_Asynchronous_Logic_7/D_reset_FF_1.Q.t2 VSSD 0.048608f
C2558 SAR_Asynchronous_Logic_7/D_reset_FF_1.Q.t7 VSSD 0.048745f
C2559 SAR_Asynchronous_Logic_7/D_reset_FF_1.Q.n2 VSSD 0.310534f
C2560 SAR_Asynchronous_Logic_7/D_reset_FF_1.Q.t6 VSSD 0.544665f
C2561 SAR_Asynchronous_Logic_7/D_reset_FF_1.Q.t12 VSSD 0.025173f
C2562 SAR_Asynchronous_Logic_7/D_reset_FF_1.Q.t9 VSSD 0.059386f
C2563 SAR_Asynchronous_Logic_7/D_reset_FF_1.Q.n3 VSSD 0.193874f
C2564 SAR_Asynchronous_Logic_7/D_reset_FF_1.Q.n4 VSSD 0.702129f
C2565 SAR_Asynchronous_Logic_7/D_reset_FF_1.Q.t8 VSSD 0.425781f
C2566 SAR_Asynchronous_Logic_7/D_reset_FF_1.Q.t4 VSSD 0.159509f
C2567 SAR_Asynchronous_Logic_7/D_reset_FF_1.Q.n5 VSSD 1.43147f
C2568 SAR_Asynchronous_Logic_7/D_reset_FF_1.Q.t5 VSSD 0.425987f
C2569 SAR_Asynchronous_Logic_7/D_reset_FF_1.Q.t0 VSSD 0.162054f
C2570 SAR_Asynchronous_Logic_7/D_reset_FF_1.Q.n6 VSSD 1.31158f
C2571 SAR_Asynchronous_Logic_7/D_reset_FF_1.Q.t3 VSSD 0.425932f
C2572 SAR_Asynchronous_Logic_7/D_reset_FF_1.Q.t1 VSSD 0.162054f
C2573 SAR_Asynchronous_Logic_7/D_reset_FF_1.Q.n7 VSSD 1.28475f
C2574 SAR_Asynchronous_Logic_7/D_reset_FF_1.Q.n8 VSSD 1.12616f
C2575 SAR_Asynchronous_Logic_7/D_reset_FF_1.Q.n9 VSSD 1.20247f
C2576 Bit_4.t2 VSSD 0.312254f
C2577 Bit_4.t1 VSSD 0.161147f
C2578 Bit_4.t0 VSSD 0.149179f
C2579 Bit_4.n0 VSSD 1.26379f
C2580 Bit_4.t3 VSSD 0.104782f
C2581 Bit_4.n1 VSSD 0.4086f
C2582 Bit_4.n2 VSSD 2.41687f
C2583 SAR_Asynchronous_Logic_10/D_reset_FF_0.Q.n0 VSSD 1.06897f
C2584 SAR_Asynchronous_Logic_10/D_reset_FF_0.Q.t2 VSSD 0.051002f
C2585 SAR_Asynchronous_Logic_10/D_reset_FF_0.Q.t0 VSSD 0.050858f
C2586 SAR_Asynchronous_Logic_10/D_reset_FF_0.Q.n1 VSSD 0.32491f
C2587 SAR_Asynchronous_Logic_10/D_reset_FF_0.Q.t1 VSSD 0.569808f
C2588 SAR_Asynchronous_Logic_10/D_reset_FF_0.Q.t3 VSSD 0.064927f
C2589 SAR_Asynchronous_Logic_10/D_reset_FF_0.Q.t4 VSSD 0.030163f
C2590 SAR_Asynchronous_Logic_10/D_reset_FF_0.Q.n2 VSSD 0.216789f
C2591 SAR_Asynchronous_Logic_10/D_reset_FF_0.Q.t5 VSSD 0.026338f
C2592 SAR_Asynchronous_Logic_10/D_reset_FF_0.Q.t6 VSSD 0.062135f
C2593 SAR_Asynchronous_Logic_10/D_reset_FF_0.Q.n3 VSSD 0.20285f
C2594 SAR_Asynchronous_Logic_10/D_reset_FF_0.Q.n4 VSSD 0.734634f
C2595 a_74632_n3162.n0 VSSD 0.986143f
C2596 a_74632_n3162.t4 VSSD 0.035769f
C2597 a_74632_n3162.t5 VSSD 0.0164f
C2598 a_74632_n3162.n1 VSSD 0.173748f
C2599 a_74632_n3162.t3 VSSD 0.250554f
C2600 a_74632_n3162.t1 VSSD 0.085552f
C2601 a_74632_n3162.t2 VSSD 0.085552f
C2602 a_74632_n3162.n2 VSSD 0.878169f
C2603 a_74632_n3162.t0 VSSD 0.288113f
C2604 a_36722_n3300.t3 VSSD 0.150297f
C2605 a_36722_n3300.t4 VSSD 0.111359f
C2606 a_36722_n3300.t2 VSSD 0.210813f
C2607 a_36722_n3300.n0 VSSD 2.80378f
C2608 a_36722_n3300.t5 VSSD 0.113401f
C2609 a_36722_n3300.n1 VSSD 1.56811f
C2610 a_36722_n3300.n2 VSSD 1.46986f
C2611 a_36722_n3300.t1 VSSD 0.198092f
C2612 a_36722_n3300.n3 VSSD 1.4663f
C2613 a_36722_n3300.t0 VSSD 0.407992f
C2614 a_36722_n4054.n0 VSSD 1.29292f
C2615 a_36722_n4054.t7 VSSD 0.038175f
C2616 a_36722_n4054.t2 VSSD 0.090059f
C2617 a_36722_n4054.n1 VSSD 0.298371f
C2618 a_36722_n4054.t1 VSSD 0.147144f
C2619 a_36722_n4054.t5 VSSD 0.1636f
C2620 a_36722_n4054.t3 VSSD 0.130517f
C2621 a_36722_n4054.n2 VSSD 2.29806f
C2622 a_36722_n4054.t4 VSSD 0.128165f
C2623 a_36722_n4054.n3 VSSD 1.28395f
C2624 a_36722_n4054.t6 VSSD 0.088694f
C2625 a_36722_n4054.n4 VSSD 1.24258f
C2626 a_36722_n4054.t0 VSSD 0.397759f
C2627 a_98012_n13060.t2 VSSD 0.18478f
C2628 a_98012_n13060.t1 VSSD 0.131493f
C2629 a_98012_n13060.t3 VSSD 0.244385f
C2630 a_98012_n13060.n0 VSSD 0.779228f
C2631 a_98012_n13060.n1 VSSD 1.38905f
C2632 a_98012_n13060.t0 VSSD 0.171066f
C2633 SAR_Asynchronous_Logic_8/D_reset_FF_1.Q.n0 VSSD 1.0216f
C2634 SAR_Asynchronous_Logic_8/D_reset_FF_1.Q.t9 VSSD 0.062055f
C2635 SAR_Asynchronous_Logic_8/D_reset_FF_1.Q.t10 VSSD 0.028828f
C2636 SAR_Asynchronous_Logic_8/D_reset_FF_1.Q.n1 VSSD 0.207197f
C2637 SAR_Asynchronous_Logic_8/D_reset_FF_1.Q.t5 VSSD 0.048608f
C2638 SAR_Asynchronous_Logic_8/D_reset_FF_1.Q.t3 VSSD 0.048745f
C2639 SAR_Asynchronous_Logic_8/D_reset_FF_1.Q.n2 VSSD 0.310534f
C2640 SAR_Asynchronous_Logic_8/D_reset_FF_1.Q.t4 VSSD 0.544665f
C2641 SAR_Asynchronous_Logic_8/D_reset_FF_1.Q.t11 VSSD 0.025173f
C2642 SAR_Asynchronous_Logic_8/D_reset_FF_1.Q.t12 VSSD 0.059386f
C2643 SAR_Asynchronous_Logic_8/D_reset_FF_1.Q.n3 VSSD 0.193874f
C2644 SAR_Asynchronous_Logic_8/D_reset_FF_1.Q.n4 VSSD 0.70213f
C2645 SAR_Asynchronous_Logic_8/D_reset_FF_1.Q.t2 VSSD 0.425781f
C2646 SAR_Asynchronous_Logic_8/D_reset_FF_1.Q.t8 VSSD 0.159509f
C2647 SAR_Asynchronous_Logic_8/D_reset_FF_1.Q.n5 VSSD 1.43147f
C2648 SAR_Asynchronous_Logic_8/D_reset_FF_1.Q.t0 VSSD 0.425932f
C2649 SAR_Asynchronous_Logic_8/D_reset_FF_1.Q.t7 VSSD 0.162054f
C2650 SAR_Asynchronous_Logic_8/D_reset_FF_1.Q.n6 VSSD 1.31163f
C2651 SAR_Asynchronous_Logic_8/D_reset_FF_1.Q.t1 VSSD 0.425987f
C2652 SAR_Asynchronous_Logic_8/D_reset_FF_1.Q.t6 VSSD 0.162054f
C2653 SAR_Asynchronous_Logic_8/D_reset_FF_1.Q.n7 VSSD 1.2847f
C2654 SAR_Asynchronous_Logic_8/D_reset_FF_1.Q.n8 VSSD 1.12616f
C2655 SAR_Asynchronous_Logic_8/D_reset_FF_1.Q.n9 VSSD 1.20247f
C2656 a_67002_n80.n0 VSSD 7.24543f
C2657 a_67002_n80.n1 VSSD 4.09072f
C2658 a_67002_n80.t4 VSSD 0.133561f
C2659 a_67002_n80.t3 VSSD 0.367163f
C2660 a_67002_n80.t7 VSSD 0.077933f
C2661 a_67002_n80.t5 VSSD 0.088897f
C2662 a_67002_n80.n2 VSSD 2.7214f
C2663 a_67002_n80.t1 VSSD 0.111234f
C2664 a_67002_n80.t2 VSSD 0.029289f
C2665 a_67002_n80.t6 VSSD 0.069099f
C2666 a_67002_n80.n3 VSSD 0.26036f
C2667 a_67002_n80.t0 VSSD 0.304917f
C2668 a_66110_n80.n0 VSSD 8.2746f
C2669 a_66110_n80.n1 VSSD 4.39821f
C2670 a_66110_n80.t2 VSSD 0.030513f
C2671 a_66110_n80.t5 VSSD 0.071986f
C2672 a_66110_n80.n2 VSSD 0.235316f
C2673 a_66110_n80.t4 VSSD 0.125181f
C2674 a_66110_n80.t6 VSSD 0.098408f
C2675 a_66110_n80.t3 VSSD 0.097436f
C2676 a_66110_n80.n3 VSSD 2.56472f
C2677 a_66110_n80.t7 VSSD 0.270804f
C2678 a_66110_n80.t1 VSSD 0.115882f
C2679 a_66110_n80.t0 VSSD 0.316938f
C2680 a_70822_n18190.t1 VSSD 0.198092f
C2681 a_70822_n18190.t3 VSSD 0.1503f
C2682 a_70822_n18190.t2 VSSD 0.111361f
C2683 a_70822_n18190.t4 VSSD 0.210813f
C2684 a_70822_n18190.n0 VSSD 2.80378f
C2685 a_70822_n18190.t5 VSSD 0.113403f
C2686 a_70822_n18190.n1 VSSD 1.56811f
C2687 a_70822_n18190.n2 VSSD 1.46985f
C2688 a_70822_n18190.n3 VSSD 1.46632f
C2689 a_70822_n18190.t0 VSSD 0.407979f
C2690 clks.n0 VSSD 0.011722f
C2691 clks.n1 VSSD 0.052088f
C2692 clks.n2 VSSD 0.004184f
C2693 clks.t18 VSSD 6.93e-19
C2694 clks.t0 VSSD 0.001634f
C2695 clks.n3 VSSD 0.089889f
C2696 clks.t8 VSSD 6.93e-19
C2697 clks.t12 VSSD 0.001634f
C2698 clks.n4 VSSD 0.119597f
C2699 clks.n5 VSSD 1.38941f
C2700 clks.t9 VSSD 6.93e-19
C2701 clks.t13 VSSD 0.001634f
C2702 clks.n6 VSSD 0.038921f
C2703 clks.t4 VSSD 6.93e-19
C2704 clks.t7 VSSD 0.001634f
C2705 clks.n7 VSSD 0.215893f
C2706 clks.t11 VSSD 6.93e-19
C2707 clks.t15 VSSD 0.001634f
C2708 clks.n8 VSSD 0.182931f
C2709 clks.t19 VSSD 6.93e-19
C2710 clks.t1 VSSD 0.001634f
C2711 clks.n9 VSSD 0.231675f
C2712 clks.n10 VSSD 2.26702f
C2713 clks.n11 VSSD 1.5569f
C2714 clks.t21 VSSD 6.93e-19
C2715 clks.t5 VSSD 0.001634f
C2716 clks.n12 VSSD 0.438066f
C2717 clks.n13 VSSD 1.7835f
C2718 clks.n14 VSSD 1.35483f
C2719 clks.n15 VSSD 0.743857f
C2720 clks.n16 VSSD 0.454059f
C2721 clks.t20 VSSD 6.93e-19
C2722 clks.t2 VSSD 0.001634f
C2723 clks.n17 VSSD 0.201999f
C2724 clks.n18 VSSD 1.52151f
C2725 clks.t3 VSSD 6.93e-19
C2726 clks.t6 VSSD 0.001634f
C2727 clks.n19 VSSD 0.38658f
C2728 clks.n20 VSSD 1.4943f
C2729 clks.t10 VSSD 6.93e-19
C2730 clks.t14 VSSD 0.001634f
C2731 clks.n21 VSSD 0.306788f
C2732 clks.n22 VSSD 1.68558f
C2733 clks.t16 VSSD 6.93e-19
C2734 clks.t17 VSSD 0.001634f
C2735 clks.n23 VSSD 0.586057f
C2736 clks.n24 VSSD 1.66639f
C2737 clks.n25 VSSD 0.145511f
C2738 clks.n26 VSSD 0.005906f
C2739 clks.n27 VSSD 0.004184f
C2740 clks.n28 VSSD 0.004638f
C2741 clks.n29 VSSD 0.004638f
C2742 clks.n30 VSSD 0.004638f
C2743 clks.n31 VSSD 0.004184f
C2744 clks.n32 VSSD 0.005845f
C2745 a_68722_n3300.t4 VSSD 0.150297f
C2746 a_68722_n3300.t5 VSSD 0.111359f
C2747 a_68722_n3300.t3 VSSD 0.210813f
C2748 a_68722_n3300.n0 VSSD 2.80378f
C2749 a_68722_n3300.t2 VSSD 0.113401f
C2750 a_68722_n3300.n1 VSSD 1.56811f
C2751 a_68722_n3300.n2 VSSD 1.46986f
C2752 a_68722_n3300.t1 VSSD 0.198092f
C2753 a_68722_n3300.n3 VSSD 1.4663f
C2754 a_68722_n3300.t0 VSSD 0.407992f
C2755 a_68722_n4054.n0 VSSD 1.29292f
C2756 a_68722_n4054.t5 VSSD 0.038175f
C2757 a_68722_n4054.t2 VSSD 0.090059f
C2758 a_68722_n4054.n1 VSSD 0.298371f
C2759 a_68722_n4054.t0 VSSD 0.147144f
C2760 a_68722_n4054.t7 VSSD 0.1636f
C2761 a_68722_n4054.t4 VSSD 0.130517f
C2762 a_68722_n4054.n2 VSSD 2.29806f
C2763 a_68722_n4054.t6 VSSD 0.128165f
C2764 a_68722_n4054.n3 VSSD 1.28395f
C2765 a_68722_n4054.t3 VSSD 0.088694f
C2766 a_68722_n4054.n4 VSSD 1.24258f
C2767 a_68722_n4054.t1 VSSD 0.397759f
C2768 a_46798_n314.t3 VSSD 0.04397f
C2769 a_46798_n314.t1 VSSD 0.043846f
C2770 a_46798_n314.n0 VSSD 0.280111f
C2771 a_46798_n314.t4 VSSD 0.384103f
C2772 a_46798_n314.t0 VSSD 0.143873f
C2773 a_46798_n314.n1 VSSD 1.07814f
C2774 a_46798_n314.n2 VSSD 0.534715f
C2775 a_46798_n314.t2 VSSD 0.491242f
C2776 a_144898_n18422.t1 VSSD 0.143873f
C2777 a_144898_n18422.t4 VSSD 0.04397f
C2778 a_144898_n18422.t0 VSSD 0.043846f
C2779 a_144898_n18422.n0 VSSD 0.280111f
C2780 a_144898_n18422.t3 VSSD 0.491242f
C2781 a_144898_n18422.n1 VSSD 0.534715f
C2782 a_144898_n18422.n2 VSSD 1.07819f
C2783 a_144898_n18422.t2 VSSD 0.384053f
C2784 SAR_Asynchronous_Logic_3/D_reset_FF_1.Q.n0 VSSD 1.02167f
C2785 SAR_Asynchronous_Logic_3/D_reset_FF_1.Q.t5 VSSD 0.425788f
C2786 SAR_Asynchronous_Logic_3/D_reset_FF_1.Q.t8 VSSD 0.159509f
C2787 SAR_Asynchronous_Logic_3/D_reset_FF_1.Q.n1 VSSD 1.43146f
C2788 SAR_Asynchronous_Logic_3/D_reset_FF_1.Q.t7 VSSD 0.425995f
C2789 SAR_Asynchronous_Logic_3/D_reset_FF_1.Q.t4 VSSD 0.162054f
C2790 SAR_Asynchronous_Logic_3/D_reset_FF_1.Q.n2 VSSD 1.31157f
C2791 SAR_Asynchronous_Logic_3/D_reset_FF_1.Q.t6 VSSD 0.425995f
C2792 SAR_Asynchronous_Logic_3/D_reset_FF_1.Q.t3 VSSD 0.162054f
C2793 SAR_Asynchronous_Logic_3/D_reset_FF_1.Q.n3 VSSD 1.28469f
C2794 SAR_Asynchronous_Logic_3/D_reset_FF_1.Q.n4 VSSD 1.12616f
C2795 SAR_Asynchronous_Logic_3/D_reset_FF_1.Q.n5 VSSD 1.20247f
C2796 SAR_Asynchronous_Logic_3/D_reset_FF_1.Q.t0 VSSD 0.048745f
C2797 SAR_Asynchronous_Logic_3/D_reset_FF_1.Q.t2 VSSD 0.048608f
C2798 SAR_Asynchronous_Logic_3/D_reset_FF_1.Q.n6 VSSD 0.310534f
C2799 SAR_Asynchronous_Logic_3/D_reset_FF_1.Q.t1 VSSD 0.544596f
C2800 SAR_Asynchronous_Logic_3/D_reset_FF_1.Q.t9 VSSD 0.062055f
C2801 SAR_Asynchronous_Logic_3/D_reset_FF_1.Q.t11 VSSD 0.028828f
C2802 SAR_Asynchronous_Logic_3/D_reset_FF_1.Q.n7 VSSD 0.207197f
C2803 SAR_Asynchronous_Logic_3/D_reset_FF_1.Q.t12 VSSD 0.025172f
C2804 SAR_Asynchronous_Logic_3/D_reset_FF_1.Q.t10 VSSD 0.059386f
C2805 SAR_Asynchronous_Logic_3/D_reset_FF_1.Q.n8 VSSD 0.193875f
C2806 SAR_Asynchronous_Logic_3/D_reset_FF_1.Q.n9 VSSD 0.702129f
C2807 SAR_Asynchronous_Logic_1/D_reset_FF_1.Q.n0 VSSD 1.02167f
C2808 SAR_Asynchronous_Logic_1/D_reset_FF_1.Q.t4 VSSD 0.425788f
C2809 SAR_Asynchronous_Logic_1/D_reset_FF_1.Q.t3 VSSD 0.159509f
C2810 SAR_Asynchronous_Logic_1/D_reset_FF_1.Q.n1 VSSD 1.43146f
C2811 SAR_Asynchronous_Logic_1/D_reset_FF_1.Q.t2 VSSD 0.425995f
C2812 SAR_Asynchronous_Logic_1/D_reset_FF_1.Q.t8 VSSD 0.162054f
C2813 SAR_Asynchronous_Logic_1/D_reset_FF_1.Q.n2 VSSD 1.31157f
C2814 SAR_Asynchronous_Logic_1/D_reset_FF_1.Q.t1 VSSD 0.425957f
C2815 SAR_Asynchronous_Logic_1/D_reset_FF_1.Q.t7 VSSD 0.162054f
C2816 SAR_Asynchronous_Logic_1/D_reset_FF_1.Q.n3 VSSD 1.28473f
C2817 SAR_Asynchronous_Logic_1/D_reset_FF_1.Q.n4 VSSD 1.12617f
C2818 SAR_Asynchronous_Logic_1/D_reset_FF_1.Q.n5 VSSD 1.20247f
C2819 SAR_Asynchronous_Logic_1/D_reset_FF_1.Q.t5 VSSD 0.048745f
C2820 SAR_Asynchronous_Logic_1/D_reset_FF_1.Q.t0 VSSD 0.048608f
C2821 SAR_Asynchronous_Logic_1/D_reset_FF_1.Q.n6 VSSD 0.310534f
C2822 SAR_Asynchronous_Logic_1/D_reset_FF_1.Q.t6 VSSD 0.544596f
C2823 SAR_Asynchronous_Logic_1/D_reset_FF_1.Q.t10 VSSD 0.062055f
C2824 SAR_Asynchronous_Logic_1/D_reset_FF_1.Q.t9 VSSD 0.028828f
C2825 SAR_Asynchronous_Logic_1/D_reset_FF_1.Q.n7 VSSD 0.207197f
C2826 SAR_Asynchronous_Logic_1/D_reset_FF_1.Q.t12 VSSD 0.025172f
C2827 SAR_Asynchronous_Logic_1/D_reset_FF_1.Q.t11 VSSD 0.059386f
C2828 SAR_Asynchronous_Logic_1/D_reset_FF_1.Q.n8 VSSD 0.193875f
C2829 SAR_Asynchronous_Logic_1/D_reset_FF_1.Q.n9 VSSD 0.702129f
C2830 a_50854_1076.t1 VSSD 0.184779f
C2831 a_50854_1076.t2 VSSD 0.131493f
C2832 a_50854_1076.t3 VSSD 0.244385f
C2833 a_50854_1076.n0 VSSD 0.779228f
C2834 a_50854_1076.n1 VSSD 1.38904f
C2835 a_50854_1076.t0 VSSD 0.171071f
C2836 a_34110_n80.n0 VSSD 8.2746f
C2837 a_34110_n80.n1 VSSD 4.39821f
C2838 a_34110_n80.t5 VSSD 0.030513f
C2839 a_34110_n80.t4 VSSD 0.071986f
C2840 a_34110_n80.n2 VSSD 0.235316f
C2841 a_34110_n80.t7 VSSD 0.125181f
C2842 a_34110_n80.t2 VSSD 0.098408f
C2843 a_34110_n80.t6 VSSD 0.097436f
C2844 a_34110_n80.n3 VSSD 2.56472f
C2845 a_34110_n80.t3 VSSD 0.270804f
C2846 a_34110_n80.t1 VSSD 0.115882f
C2847 a_34110_n80.t0 VSSD 0.316938f
C2848 a_105050_n18422.n0 VSSD 1.4589f
C2849 a_105050_n18422.t0 VSSD 0.246654f
C2850 a_105050_n18422.t5 VSSD 0.095963f
C2851 a_105050_n18422.t6 VSSD 0.044581f
C2852 a_105050_n18422.t3 VSSD 0.075381f
C2853 a_105050_n18422.t4 VSSD 0.075169f
C2854 a_105050_n18422.n1 VSSD 0.480219f
C2855 a_105050_n18422.t2 VSSD 0.84218f
C2856 a_105050_n18422.n2 VSSD 0.872922f
C2857 a_105050_n18422.n3 VSSD 2.44962f
C2858 a_105050_n18422.t1 VSSD 0.658416f
C2859 a_80898_n18422.t2 VSSD 0.143873f
C2860 a_80898_n18422.t3 VSSD 0.04397f
C2861 a_80898_n18422.t0 VSSD 0.043846f
C2862 a_80898_n18422.n0 VSSD 0.280111f
C2863 a_80898_n18422.t4 VSSD 0.491242f
C2864 a_80898_n18422.n1 VSSD 0.534715f
C2865 a_80898_n18422.n2 VSSD 1.07819f
C2866 a_80898_n18422.t1 VSSD 0.384053f
C2867 a_70002_n18190.n0 VSSD 1.29327f
C2868 a_70002_n18190.t3 VSSD 0.038174f
C2869 a_70002_n18190.t4 VSSD 0.090059f
C2870 a_70002_n18190.n1 VSSD 0.298372f
C2871 a_70002_n18190.t1 VSSD 0.147143f
C2872 a_70002_n18190.t2 VSSD 0.1636f
C2873 a_70002_n18190.t5 VSSD 0.130517f
C2874 a_70002_n18190.n2 VSSD 2.29806f
C2875 a_70002_n18190.t7 VSSD 0.128166f
C2876 a_70002_n18190.n3 VSSD 1.28395f
C2877 a_70002_n18190.t6 VSSD 0.088697f
C2878 a_70002_n18190.n4 VSSD 1.24258f
C2879 a_70002_n18190.t0 VSSD 0.397411f
C2880 a_70822_n13946.n0 VSSD 1.29292f
C2881 a_70822_n13946.t2 VSSD 0.038175f
C2882 a_70822_n13946.t4 VSSD 0.090059f
C2883 a_70822_n13946.n1 VSSD 0.298371f
C2884 a_70822_n13946.t1 VSSD 0.147144f
C2885 a_70822_n13946.t6 VSSD 0.1636f
C2886 a_70822_n13946.t5 VSSD 0.130517f
C2887 a_70822_n13946.n2 VSSD 2.29806f
C2888 a_70822_n13946.t7 VSSD 0.128165f
C2889 a_70822_n13946.n3 VSSD 1.28395f
C2890 a_70822_n13946.t3 VSSD 0.088694f
C2891 a_70822_n13946.n4 VSSD 1.24258f
C2892 a_70822_n13946.t0 VSSD 0.397759f
C2893 a_64736_n13096.n0 VSSD 7.24543f
C2894 a_64736_n13096.n1 VSSD 4.09045f
C2895 a_64736_n13096.t2 VSSD 0.02929f
C2896 a_64736_n13096.t3 VSSD 0.069099f
C2897 a_64736_n13096.n2 VSSD 0.260362f
C2898 a_64736_n13096.t7 VSSD 0.13356f
C2899 a_64736_n13096.t5 VSSD 0.367163f
C2900 a_64736_n13096.t6 VSSD 0.077939f
C2901 a_64736_n13096.t4 VSSD 0.088896f
C2902 a_64736_n13096.n3 VSSD 2.7214f
C2903 a_64736_n13096.t0 VSSD 0.111234f
C2904 a_64736_n13096.t1 VSSD 0.305184f
C2905 a_139442_n14314.n0 VSSD 1.4589f
C2906 a_139442_n14314.t3 VSSD 0.075169f
C2907 a_139442_n14314.t1 VSSD 0.075381f
C2908 a_139442_n14314.n1 VSSD 0.480219f
C2909 a_139442_n14314.t5 VSSD 0.095963f
C2910 a_139442_n14314.t6 VSSD 0.044581f
C2911 a_139442_n14314.t2 VSSD 0.658513f
C2912 a_139442_n14314.t4 VSSD 0.246654f
C2913 a_139442_n14314.n2 VSSD 2.44952f
C2914 a_139442_n14314.n3 VSSD 0.872815f
C2915 a_139442_n14314.t0 VSSD 0.842287f
C2916 a_102822_n18190.t1 VSSD 0.198092f
C2917 a_102822_n18190.t3 VSSD 0.1503f
C2918 a_102822_n18190.t2 VSSD 0.111361f
C2919 a_102822_n18190.t4 VSSD 0.210813f
C2920 a_102822_n18190.n0 VSSD 2.80378f
C2921 a_102822_n18190.t5 VSSD 0.113403f
C2922 a_102822_n18190.n1 VSSD 1.56811f
C2923 a_102822_n18190.n2 VSSD 1.46985f
C2924 a_102822_n18190.n3 VSSD 1.46632f
C2925 a_102822_n18190.t0 VSSD 0.407979f
C2926 a_146854_1076.t0 VSSD 0.184779f
C2927 a_146854_1076.t1 VSSD 0.131493f
C2928 a_146854_1076.t3 VSSD 0.244385f
C2929 a_146854_1076.n0 VSSD 0.779228f
C2930 a_146854_1076.n1 VSSD 1.38904f
C2931 a_146854_1076.t2 VSSD 0.171071f
C2932 a_131002_n80.n0 VSSD 7.24543f
C2933 a_131002_n80.n1 VSSD 4.09072f
C2934 a_131002_n80.t3 VSSD 0.133561f
C2935 a_131002_n80.t2 VSSD 0.367163f
C2936 a_131002_n80.t5 VSSD 0.077933f
C2937 a_131002_n80.t7 VSSD 0.088897f
C2938 a_131002_n80.n2 VSSD 2.7214f
C2939 a_131002_n80.t1 VSSD 0.111234f
C2940 a_131002_n80.t6 VSSD 0.029289f
C2941 a_131002_n80.t4 VSSD 0.069099f
C2942 a_131002_n80.n3 VSSD 0.26036f
C2943 a_131002_n80.t0 VSSD 0.304917f
C2944 a_132722_n3300.t4 VSSD 0.150297f
C2945 a_132722_n3300.t5 VSSD 0.111359f
C2946 a_132722_n3300.t3 VSSD 0.210813f
C2947 a_132722_n3300.n0 VSSD 2.80378f
C2948 a_132722_n3300.t2 VSSD 0.113401f
C2949 a_132722_n3300.n1 VSSD 1.56811f
C2950 a_132722_n3300.n2 VSSD 1.46986f
C2951 a_132722_n3300.t1 VSSD 0.198092f
C2952 a_132722_n3300.n3 VSSD 1.4663f
C2953 a_132722_n3300.t0 VSSD 0.407992f
C2954 a_132722_n4054.n0 VSSD 1.29292f
C2955 a_132722_n4054.t6 VSSD 0.038175f
C2956 a_132722_n4054.t2 VSSD 0.090059f
C2957 a_132722_n4054.n1 VSSD 0.298371f
C2958 a_132722_n4054.t0 VSSD 0.147144f
C2959 a_132722_n4054.t3 VSSD 0.1636f
C2960 a_132722_n4054.t5 VSSD 0.130517f
C2961 a_132722_n4054.n2 VSSD 2.29806f
C2962 a_132722_n4054.t7 VSSD 0.128165f
C2963 a_132722_n4054.n3 VSSD 1.28395f
C2964 a_132722_n4054.t4 VSSD 0.088694f
C2965 a_132722_n4054.n4 VSSD 1.24258f
C2966 a_132722_n4054.t1 VSSD 0.397759f
C2967 SAR_Asynchronous_Logic_5/D_reset_FF_1.Q.n0 VSSD 1.02167f
C2968 SAR_Asynchronous_Logic_5/D_reset_FF_1.Q.t0 VSSD 0.42575f
C2969 SAR_Asynchronous_Logic_5/D_reset_FF_1.Q.t8 VSSD 0.159509f
C2970 SAR_Asynchronous_Logic_5/D_reset_FF_1.Q.n1 VSSD 1.4315f
C2971 SAR_Asynchronous_Logic_5/D_reset_FF_1.Q.t1 VSSD 0.425995f
C2972 SAR_Asynchronous_Logic_5/D_reset_FF_1.Q.t6 VSSD 0.162054f
C2973 SAR_Asynchronous_Logic_5/D_reset_FF_1.Q.n2 VSSD 1.31157f
C2974 SAR_Asynchronous_Logic_5/D_reset_FF_1.Q.t5 VSSD 0.425995f
C2975 SAR_Asynchronous_Logic_5/D_reset_FF_1.Q.t7 VSSD 0.162054f
C2976 SAR_Asynchronous_Logic_5/D_reset_FF_1.Q.n3 VSSD 1.28469f
C2977 SAR_Asynchronous_Logic_5/D_reset_FF_1.Q.n4 VSSD 1.12616f
C2978 SAR_Asynchronous_Logic_5/D_reset_FF_1.Q.n5 VSSD 1.20247f
C2979 SAR_Asynchronous_Logic_5/D_reset_FF_1.Q.t2 VSSD 0.048745f
C2980 SAR_Asynchronous_Logic_5/D_reset_FF_1.Q.t4 VSSD 0.048608f
C2981 SAR_Asynchronous_Logic_5/D_reset_FF_1.Q.n6 VSSD 0.310534f
C2982 SAR_Asynchronous_Logic_5/D_reset_FF_1.Q.t3 VSSD 0.544596f
C2983 SAR_Asynchronous_Logic_5/D_reset_FF_1.Q.t11 VSSD 0.062055f
C2984 SAR_Asynchronous_Logic_5/D_reset_FF_1.Q.t12 VSSD 0.028828f
C2985 SAR_Asynchronous_Logic_5/D_reset_FF_1.Q.n7 VSSD 0.207197f
C2986 SAR_Asynchronous_Logic_5/D_reset_FF_1.Q.t10 VSSD 0.025172f
C2987 SAR_Asynchronous_Logic_5/D_reset_FF_1.Q.t9 VSSD 0.059386f
C2988 SAR_Asynchronous_Logic_5/D_reset_FF_1.Q.n8 VSSD 0.193875f
C2989 SAR_Asynchronous_Logic_5/D_reset_FF_1.Q.n9 VSSD 0.702129f
C2990 D_C_2.t1 VSSD 0.153273f
C2991 D_C_2.t0 VSSD 0.057419f
C2992 D_C_2.n0 VSSD 1.04233f
C2993 a_44732_n13054.n0 VSSD 1.62009f
C2994 a_44732_n13054.t4 VSSD 0.058764f
C2995 a_44732_n13054.t5 VSSD 0.026943f
C2996 a_44732_n13054.n1 VSSD 0.285443f
C2997 a_44732_n13054.t3 VSSD 0.411624f
C2998 a_44732_n13054.t0 VSSD 0.14055f
C2999 a_44732_n13054.t2 VSSD 0.14055f
C3000 a_44732_n13054.n2 VSSD 1.44271f
C3001 a_44732_n13054.t1 VSSD 0.473328f
C3002 a_38822_n13192.t2 VSSD 0.150297f
C3003 a_38822_n13192.t4 VSSD 0.111359f
C3004 a_38822_n13192.t3 VSSD 0.210813f
C3005 a_38822_n13192.n0 VSSD 2.80378f
C3006 a_38822_n13192.t5 VSSD 0.113401f
C3007 a_38822_n13192.n1 VSSD 1.56811f
C3008 a_38822_n13192.n2 VSSD 1.46986f
C3009 a_38822_n13192.t0 VSSD 0.198092f
C3010 a_38822_n13192.n3 VSSD 1.4663f
C3011 a_38822_n13192.t1 VSSD 0.407992f
C3012 a_8066_n18422.n0 VSSD 0.986138f
C3013 a_8066_n18422.t4 VSSD 0.035769f
C3014 a_8066_n18422.t5 VSSD 0.0164f
C3015 a_8066_n18422.n1 VSSD 0.173748f
C3016 a_8066_n18422.t2 VSSD 0.250558f
C3017 a_8066_n18422.t1 VSSD 0.085552f
C3018 a_8066_n18422.t3 VSSD 0.085552f
C3019 a_8066_n18422.n2 VSSD 0.878151f
C3020 a_8066_n18422.t0 VSSD 0.288131f
C3021 SAR_Asynchronous_Logic_4/D_reset_FF_1.Q.n0 VSSD 1.0216f
C3022 SAR_Asynchronous_Logic_4/D_reset_FF_1.Q.t11 VSSD 0.062055f
C3023 SAR_Asynchronous_Logic_4/D_reset_FF_1.Q.t12 VSSD 0.028828f
C3024 SAR_Asynchronous_Logic_4/D_reset_FF_1.Q.n1 VSSD 0.207197f
C3025 SAR_Asynchronous_Logic_4/D_reset_FF_1.Q.t2 VSSD 0.048608f
C3026 SAR_Asynchronous_Logic_4/D_reset_FF_1.Q.t0 VSSD 0.048745f
C3027 SAR_Asynchronous_Logic_4/D_reset_FF_1.Q.n2 VSSD 0.310534f
C3028 SAR_Asynchronous_Logic_4/D_reset_FF_1.Q.t1 VSSD 0.544665f
C3029 SAR_Asynchronous_Logic_4/D_reset_FF_1.Q.t9 VSSD 0.025173f
C3030 SAR_Asynchronous_Logic_4/D_reset_FF_1.Q.t10 VSSD 0.059386f
C3031 SAR_Asynchronous_Logic_4/D_reset_FF_1.Q.n3 VSSD 0.193874f
C3032 SAR_Asynchronous_Logic_4/D_reset_FF_1.Q.n4 VSSD 0.70213f
C3033 SAR_Asynchronous_Logic_4/D_reset_FF_1.Q.t8 VSSD 0.425781f
C3034 SAR_Asynchronous_Logic_4/D_reset_FF_1.Q.t5 VSSD 0.159509f
C3035 SAR_Asynchronous_Logic_4/D_reset_FF_1.Q.n5 VSSD 1.43147f
C3036 SAR_Asynchronous_Logic_4/D_reset_FF_1.Q.t3 VSSD 0.425987f
C3037 SAR_Asynchronous_Logic_4/D_reset_FF_1.Q.t6 VSSD 0.162054f
C3038 SAR_Asynchronous_Logic_4/D_reset_FF_1.Q.n6 VSSD 1.31158f
C3039 SAR_Asynchronous_Logic_4/D_reset_FF_1.Q.t4 VSSD 0.425987f
C3040 SAR_Asynchronous_Logic_4/D_reset_FF_1.Q.t7 VSSD 0.162054f
C3041 SAR_Asynchronous_Logic_4/D_reset_FF_1.Q.n7 VSSD 1.2847f
C3042 SAR_Asynchronous_Logic_4/D_reset_FF_1.Q.n8 VSSD 1.12616f
C3043 SAR_Asynchronous_Logic_4/D_reset_FF_1.Q.n9 VSSD 1.20247f
C3044 a_6822_n18190.t0 VSSD 0.198092f
C3045 a_6822_n18190.t2 VSSD 0.1503f
C3046 a_6822_n18190.t5 VSSD 0.111361f
C3047 a_6822_n18190.t4 VSSD 0.210813f
C3048 a_6822_n18190.n0 VSSD 2.80378f
C3049 a_6822_n18190.t3 VSSD 0.113403f
C3050 a_6822_n18190.n1 VSSD 1.56811f
C3051 a_6822_n18190.n2 VSSD 1.46985f
C3052 a_6822_n18190.n3 VSSD 1.46632f
C3053 a_6822_n18190.t1 VSSD 0.407979f
C3054 a_42818_n4422.t4 VSSD 0.043229f
C3055 a_42818_n4422.t1 VSSD 0.043351f
C3056 a_42818_n4422.n0 VSSD 0.276169f
C3057 a_42818_n4422.t3 VSSD 0.381059f
C3058 a_42818_n4422.t2 VSSD 0.141857f
C3059 a_42818_n4422.n1 VSSD 1.09466f
C3060 a_42818_n4422.n2 VSSD 0.535288f
C3061 a_42818_n4422.t0 VSSD 0.48439f
C3062 a_41342_n4422.n0 VSSD 1.4589f
C3063 a_41342_n4422.t1 VSSD 0.246654f
C3064 a_41342_n4422.t2 VSSD 0.075169f
C3065 a_41342_n4422.t3 VSSD 0.075381f
C3066 a_41342_n4422.n1 VSSD 0.480219f
C3067 a_41342_n4422.t4 VSSD 0.842287f
C3068 a_41342_n4422.n2 VSSD 0.872815f
C3069 a_41342_n4422.t6 VSSD 0.095963f
C3070 a_41342_n4422.t5 VSSD 0.044581f
C3071 a_41342_n4422.n3 VSSD 2.44958f
C3072 a_41342_n4422.t0 VSSD 0.658454f
C3073 a_6822_n13192.t4 VSSD 0.150297f
C3074 a_6822_n13192.t5 VSSD 0.111359f
C3075 a_6822_n13192.t3 VSSD 0.210813f
C3076 a_6822_n13192.n0 VSSD 2.80378f
C3077 a_6822_n13192.t2 VSSD 0.113401f
C3078 a_6822_n13192.n1 VSSD 1.56811f
C3079 a_6822_n13192.n2 VSSD 1.46986f
C3080 a_6822_n13192.t1 VSSD 0.198092f
C3081 a_6822_n13192.n3 VSSD 1.4663f
C3082 a_6822_n13192.t0 VSSD 0.407992f
C3083 a_108918_n14314.t1 VSSD 0.146586f
C3084 a_108918_n14314.t4 VSSD 0.04467f
C3085 a_108918_n14314.t3 VSSD 0.044796f
C3086 a_108918_n14314.n0 VSSD 0.285375f
C3087 a_108918_n14314.t2 VSSD 0.500537f
C3088 a_108918_n14314.n1 VSSD 0.55313f
C3089 a_108918_n14314.n2 VSSD 1.13118f
C3090 a_108918_n14314.t0 VSSD 0.393726f
C3091 a_107442_n14314.n0 VSSD 1.4589f
C3092 a_107442_n14314.t1 VSSD 0.246654f
C3093 a_107442_n14314.t2 VSSD 0.075169f
C3094 a_107442_n14314.t4 VSSD 0.075381f
C3095 a_107442_n14314.n1 VSSD 0.480219f
C3096 a_107442_n14314.t3 VSSD 0.842287f
C3097 a_107442_n14314.n2 VSSD 0.872815f
C3098 a_107442_n14314.t6 VSSD 0.095963f
C3099 a_107442_n14314.t5 VSSD 0.044581f
C3100 a_107442_n14314.n3 VSSD 2.44958f
C3101 a_107442_n14314.t0 VSSD 0.658454f
C3102 a_102822_n13946.n0 VSSD 1.29292f
C3103 a_102822_n13946.t2 VSSD 0.038175f
C3104 a_102822_n13946.t4 VSSD 0.090059f
C3105 a_102822_n13946.n1 VSSD 0.298371f
C3106 a_102822_n13946.t1 VSSD 0.147144f
C3107 a_102822_n13946.t6 VSSD 0.1636f
C3108 a_102822_n13946.t5 VSSD 0.130517f
C3109 a_102822_n13946.n2 VSSD 2.29806f
C3110 a_102822_n13946.t7 VSSD 0.128165f
C3111 a_102822_n13946.n3 VSSD 1.28395f
C3112 a_102822_n13946.t3 VSSD 0.088694f
C3113 a_102822_n13946.n4 VSSD 1.24258f
C3114 a_102822_n13946.t0 VSSD 0.397759f
C3115 a_96736_n13096.n0 VSSD 7.24543f
C3116 a_96736_n13096.n1 VSSD 4.09045f
C3117 a_96736_n13096.t2 VSSD 0.02929f
C3118 a_96736_n13096.t4 VSSD 0.069099f
C3119 a_96736_n13096.n2 VSSD 0.260362f
C3120 a_96736_n13096.t5 VSSD 0.13356f
C3121 a_96736_n13096.t6 VSSD 0.367163f
C3122 a_96736_n13096.t3 VSSD 0.077939f
C3123 a_96736_n13096.t7 VSSD 0.088896f
C3124 a_96736_n13096.n3 VSSD 2.7214f
C3125 a_96736_n13096.t0 VSSD 0.111234f
C3126 a_96736_n13096.t1 VSSD 0.305184f
C3127 a_110134_n18422.t3 VSSD 0.074342f
C3128 a_110134_n18422.t2 VSSD 0.230085f
C3129 a_110134_n18422.t0 VSSD 0.06831f
C3130 a_110134_n18422.n0 VSSD 0.749607f
C3131 a_110134_n18422.t4 VSSD 0.02856f
C3132 a_110134_n18422.t5 VSSD 0.013095f
C3133 a_110134_n18422.n1 VSSD 0.140208f
C3134 a_110134_n18422.n2 VSSD 0.351639f
C3135 a_110134_n18422.n3 VSSD 0.548746f
C3136 a_110134_n18422.t1 VSSD 0.195407f
C3137 a_112898_n18422.t0 VSSD 0.143873f
C3138 a_112898_n18422.t3 VSSD 0.04397f
C3139 a_112898_n18422.t4 VSSD 0.043846f
C3140 a_112898_n18422.n0 VSSD 0.280111f
C3141 a_112898_n18422.t2 VSSD 0.491242f
C3142 a_112898_n18422.n1 VSSD 0.534715f
C3143 a_112898_n18422.n2 VSSD 1.07819f
C3144 a_112898_n18422.t1 VSSD 0.384053f
C3145 a_102002_n18190.n0 VSSD 1.29327f
C3146 a_102002_n18190.t3 VSSD 0.038174f
C3147 a_102002_n18190.t4 VSSD 0.090059f
C3148 a_102002_n18190.n1 VSSD 0.298372f
C3149 a_102002_n18190.t0 VSSD 0.147143f
C3150 a_102002_n18190.t2 VSSD 0.1636f
C3151 a_102002_n18190.t7 VSSD 0.130517f
C3152 a_102002_n18190.n2 VSSD 2.29806f
C3153 a_102002_n18190.t6 VSSD 0.128166f
C3154 a_102002_n18190.n3 VSSD 1.28395f
C3155 a_102002_n18190.t5 VSSD 0.088697f
C3156 a_102002_n18190.n4 VSSD 1.24258f
C3157 a_102002_n18190.t1 VSSD 0.397411f
C3158 a_n21182_n4422.t3 VSSD 0.043229f
C3159 a_n21182_n4422.t1 VSSD 0.043351f
C3160 a_n21182_n4422.n0 VSSD 0.276169f
C3161 a_n21182_n4422.t2 VSSD 0.381059f
C3162 a_n21182_n4422.t4 VSSD 0.141857f
C3163 a_n21182_n4422.n1 VSSD 1.09466f
C3164 a_n21182_n4422.n2 VSSD 0.535288f
C3165 a_n21182_n4422.t0 VSSD 0.48439f
C3166 a_n27278_n4054.n0 VSSD 1.29292f
C3167 a_n27278_n4054.t3 VSSD 0.038175f
C3168 a_n27278_n4054.t5 VSSD 0.090059f
C3169 a_n27278_n4054.n1 VSSD 0.298371f
C3170 a_n27278_n4054.t1 VSSD 0.147144f
C3171 a_n27278_n4054.t7 VSSD 0.1636f
C3172 a_n27278_n4054.t4 VSSD 0.130517f
C3173 a_n27278_n4054.n2 VSSD 2.29806f
C3174 a_n27278_n4054.t2 VSSD 0.128165f
C3175 a_n27278_n4054.n3 VSSD 1.28395f
C3176 a_n27278_n4054.t6 VSSD 0.088694f
C3177 a_n27278_n4054.n4 VSSD 1.24258f
C3178 a_n27278_n4054.t0 VSSD 0.397759f
C3179 a_134950_n314.n0 VSSD 1.4589f
C3180 a_134950_n314.t3 VSSD 0.246654f
C3181 a_134950_n314.t6 VSSD 0.095963f
C3182 a_134950_n314.t5 VSSD 0.044581f
C3183 a_134950_n314.t2 VSSD 0.075381f
C3184 a_134950_n314.t4 VSSD 0.075169f
C3185 a_134950_n314.n1 VSSD 0.480219f
C3186 a_134950_n314.t1 VSSD 0.84218f
C3187 a_134950_n314.n2 VSSD 0.872922f
C3188 a_134950_n314.n3 VSSD 2.44962f
C3189 a_134950_n314.t0 VSSD 0.658416f
C3190 a_133966_n314.n0 VSSD 1.62012f
C3191 a_133966_n314.t5 VSSD 0.058764f
C3192 a_133966_n314.t4 VSSD 0.026943f
C3193 a_133966_n314.n1 VSSD 0.285443f
C3194 a_133966_n314.t2 VSSD 0.473406f
C3195 a_133966_n314.t3 VSSD 0.14055f
C3196 a_133966_n314.n2 VSSD 1.44263f
C3197 a_133966_n314.t1 VSSD 0.14055f
C3198 a_133966_n314.t0 VSSD 0.411594f
C3199 a_n23422_n314.t1 VSSD 0.044796f
C3200 a_n23422_n314.t0 VSSD 0.04467f
C3201 a_n23422_n314.n0 VSSD 0.285375f
C3202 a_n23422_n314.t4 VSSD 0.393754f
C3203 a_n23422_n314.t3 VSSD 0.146586f
C3204 a_n23422_n314.n1 VSSD 1.13115f
C3205 a_n23422_n314.n2 VSSD 0.553195f
C3206 a_n23422_n314.t2 VSSD 0.500473f
C3207 Reset.t27 VSSD 0.053845f
C3208 Reset.t52 VSSD 0.024688f
C3209 Reset.n0 VSSD 0.935635f
C3210 Reset.t40 VSSD 0.05367f
C3211 Reset.t64 VSSD 0.024933f
C3212 Reset.n1 VSSD 0.338006f
C3213 Reset.n2 VSSD 1.70118f
C3214 Reset.t39 VSSD 0.05367f
C3215 Reset.t5 VSSD 0.024933f
C3216 Reset.n3 VSSD 0.540483f
C3217 Reset.t48 VSSD 0.053845f
C3218 Reset.t0 VSSD 0.024688f
C3219 Reset.n4 VSSD 0.390381f
C3220 Reset.n5 VSSD 2.02712f
C3221 Reset.n6 VSSD 9.07505f
C3222 Reset.t4 VSSD 0.053845f
C3223 Reset.t26 VSSD 0.024688f
C3224 Reset.n7 VSSD 0.935635f
C3225 Reset.t16 VSSD 0.05367f
C3226 Reset.t36 VSSD 0.024933f
C3227 Reset.n8 VSSD 0.338006f
C3228 Reset.n9 VSSD 1.70118f
C3229 Reset.t12 VSSD 0.05367f
C3230 Reset.t1 VSSD 0.024933f
C3231 Reset.n10 VSSD 0.540483f
C3232 Reset.t42 VSSD 0.053845f
C3233 Reset.t10 VSSD 0.024688f
C3234 Reset.n11 VSSD 0.390381f
C3235 Reset.n12 VSSD 2.02712f
C3236 Reset.n13 VSSD 3.16321f
C3237 Reset.n14 VSSD 39.4646f
C3238 Reset.t28 VSSD 0.053845f
C3239 Reset.t53 VSSD 0.024688f
C3240 Reset.n15 VSSD 0.755247f
C3241 Reset.t79 VSSD 0.05367f
C3242 Reset.t6 VSSD 0.024933f
C3243 Reset.n16 VSSD 0.337986f
C3244 Reset.n17 VSSD 2.13895f
C3245 Reset.t71 VSSD 0.05367f
C3246 Reset.t87 VSSD 0.024933f
C3247 Reset.n18 VSSD 0.540513f
C3248 Reset.t85 VSSD 0.053845f
C3249 Reset.t18 VSSD 0.024688f
C3250 Reset.n19 VSSD 0.390405f
C3251 Reset.n20 VSSD 2.02707f
C3252 Reset.n21 VSSD 3.31843f
C3253 Reset.n22 VSSD 16.714499f
C3254 Reset.t60 VSSD 0.053845f
C3255 Reset.t77 VSSD 0.024688f
C3256 Reset.n23 VSSD 0.935635f
C3257 Reset.t84 VSSD 0.05367f
C3258 Reset.t17 VSSD 0.024933f
C3259 Reset.n24 VSSD 0.338006f
C3260 Reset.n25 VSSD 1.70118f
C3261 Reset.t33 VSSD 0.05367f
C3262 Reset.t73 VSSD 0.024933f
C3263 Reset.n26 VSSD 0.540483f
C3264 Reset.t65 VSSD 0.053845f
C3265 Reset.t68 VSSD 0.024688f
C3266 Reset.n27 VSSD 0.390381f
C3267 Reset.n28 VSSD 2.02712f
C3268 Reset.n29 VSSD 3.16321f
C3269 Reset.n30 VSSD 16.0148f
C3270 Reset.t59 VSSD 0.053845f
C3271 Reset.t76 VSSD 0.024688f
C3272 Reset.n31 VSSD 0.755247f
C3273 Reset.t15 VSSD 0.05367f
C3274 Reset.t34 VSSD 0.024933f
C3275 Reset.n32 VSSD 0.337986f
C3276 Reset.n33 VSSD 2.13895f
C3277 Reset.t2 VSSD 0.05367f
C3278 Reset.t24 VSSD 0.024933f
C3279 Reset.n34 VSSD 0.540513f
C3280 Reset.t22 VSSD 0.053845f
C3281 Reset.t46 VSSD 0.024688f
C3282 Reset.n35 VSSD 0.390405f
C3283 Reset.n36 VSSD 2.02707f
C3284 Reset.n37 VSSD 3.31843f
C3285 Reset.n38 VSSD 16.714499f
C3286 Reset.t19 VSSD 0.053845f
C3287 Reset.t37 VSSD 0.024688f
C3288 Reset.n39 VSSD 0.935635f
C3289 Reset.t49 VSSD 0.05367f
C3290 Reset.t70 VSSD 0.024933f
C3291 Reset.n40 VSSD 0.338006f
C3292 Reset.n41 VSSD 1.70118f
C3293 Reset.t62 VSSD 0.05367f
C3294 Reset.t50 VSSD 0.024933f
C3295 Reset.n42 VSSD 0.540483f
C3296 Reset.t81 VSSD 0.053845f
C3297 Reset.t44 VSSD 0.024688f
C3298 Reset.n43 VSSD 0.390381f
C3299 Reset.n44 VSSD 2.02712f
C3300 Reset.n45 VSSD 3.16321f
C3301 Reset.n46 VSSD 16.0148f
C3302 Reset.t82 VSSD 0.053845f
C3303 Reset.t11 VSSD 0.024688f
C3304 Reset.n47 VSSD 0.755247f
C3305 Reset.t43 VSSD 0.05367f
C3306 Reset.t67 VSSD 0.024933f
C3307 Reset.n48 VSSD 0.337986f
C3308 Reset.n49 VSSD 2.13895f
C3309 Reset.t30 VSSD 0.05367f
C3310 Reset.t55 VSSD 0.024933f
C3311 Reset.n50 VSSD 0.540513f
C3312 Reset.t51 VSSD 0.053845f
C3313 Reset.t72 VSSD 0.024688f
C3314 Reset.n51 VSSD 0.390405f
C3315 Reset.n52 VSSD 2.02707f
C3316 Reset.n53 VSSD 3.31843f
C3317 Reset.n54 VSSD 16.714499f
C3318 Reset.t58 VSSD 0.053845f
C3319 Reset.t75 VSSD 0.024688f
C3320 Reset.n55 VSSD 0.935635f
C3321 Reset.t83 VSSD 0.05367f
C3322 Reset.t14 VSSD 0.024933f
C3323 Reset.n56 VSSD 0.338006f
C3324 Reset.n57 VSSD 1.70118f
C3325 Reset.t66 VSSD 0.05367f
C3326 Reset.t45 VSSD 0.024933f
C3327 Reset.n58 VSSD 0.540483f
C3328 Reset.t86 VSSD 0.053845f
C3329 Reset.t35 VSSD 0.024688f
C3330 Reset.n59 VSSD 0.390381f
C3331 Reset.n60 VSSD 2.02712f
C3332 Reset.n61 VSSD 3.16321f
C3333 Reset.n62 VSSD 16.0148f
C3334 Reset.t80 VSSD 0.053845f
C3335 Reset.t9 VSSD 0.024688f
C3336 Reset.n63 VSSD 0.755247f
C3337 Reset.t3 VSSD 0.05367f
C3338 Reset.t25 VSSD 0.024933f
C3339 Reset.n64 VSSD 0.337986f
C3340 Reset.n65 VSSD 2.13895f
C3341 Reset.t29 VSSD 0.05367f
C3342 Reset.t54 VSSD 0.024933f
C3343 Reset.n66 VSSD 0.540513f
C3344 Reset.t8 VSSD 0.053845f
C3345 Reset.t32 VSSD 0.024688f
C3346 Reset.n67 VSSD 0.390405f
C3347 Reset.n68 VSSD 2.02707f
C3348 Reset.n69 VSSD 3.31843f
C3349 Reset.n70 VSSD 16.715f
C3350 Reset.t57 VSSD 0.053845f
C3351 Reset.t74 VSSD 0.024688f
C3352 Reset.n71 VSSD 0.755291f
C3353 Reset.t47 VSSD 0.05367f
C3354 Reset.t69 VSSD 0.024933f
C3355 Reset.n72 VSSD 0.338006f
C3356 Reset.n73 VSSD 2.13889f
C3357 Reset.t23 VSSD 0.05367f
C3358 Reset.t7 VSSD 0.024933f
C3359 Reset.n74 VSSD 0.540483f
C3360 Reset.t21 VSSD 0.053845f
C3361 Reset.t13 VSSD 0.024688f
C3362 Reset.n75 VSSD 0.390381f
C3363 Reset.n76 VSSD 2.02712f
C3364 Reset.n77 VSSD 2.90597f
C3365 Reset.n78 VSSD 16.015f
C3366 Reset.t20 VSSD 0.053845f
C3367 Reset.t41 VSSD 0.024688f
C3368 Reset.n79 VSSD 0.755247f
C3369 Reset.t31 VSSD 0.05367f
C3370 Reset.t56 VSSD 0.024933f
C3371 Reset.n80 VSSD 0.337986f
C3372 Reset.n81 VSSD 2.13895f
C3373 Reset.t61 VSSD 0.05367f
C3374 Reset.t78 VSSD 0.024933f
C3375 Reset.n82 VSSD 0.540513f
C3376 Reset.t38 VSSD 0.053845f
C3377 Reset.t63 VSSD 0.024688f
C3378 Reset.n83 VSSD 0.390405f
C3379 Reset.n84 VSSD 2.02707f
C3380 Reset.n85 VSSD 3.31843f
C3381 Reset.n86 VSSD 22.5276f
C3382 Reset.n87 VSSD 3.7203f
C3383 SAR_Asynchronous_Logic_7/D_reset_FF_0.Q.n0 VSSD 1.06897f
C3384 SAR_Asynchronous_Logic_7/D_reset_FF_0.Q.t0 VSSD 0.051002f
C3385 SAR_Asynchronous_Logic_7/D_reset_FF_0.Q.t2 VSSD 0.050858f
C3386 SAR_Asynchronous_Logic_7/D_reset_FF_0.Q.n1 VSSD 0.32491f
C3387 SAR_Asynchronous_Logic_7/D_reset_FF_0.Q.t1 VSSD 0.569808f
C3388 SAR_Asynchronous_Logic_7/D_reset_FF_0.Q.t5 VSSD 0.064927f
C3389 SAR_Asynchronous_Logic_7/D_reset_FF_0.Q.t6 VSSD 0.030163f
C3390 SAR_Asynchronous_Logic_7/D_reset_FF_0.Q.n2 VSSD 0.216789f
C3391 SAR_Asynchronous_Logic_7/D_reset_FF_0.Q.t3 VSSD 0.026338f
C3392 SAR_Asynchronous_Logic_7/D_reset_FF_0.Q.t4 VSSD 0.062135f
C3393 SAR_Asynchronous_Logic_7/D_reset_FF_0.Q.n3 VSSD 0.20285f
C3394 SAR_Asynchronous_Logic_7/D_reset_FF_0.Q.n4 VSSD 0.734634f
C3395 a_78134_n18422.t3 VSSD 0.074342f
C3396 a_78134_n18422.t2 VSSD 0.230085f
C3397 a_78134_n18422.t0 VSSD 0.06831f
C3398 a_78134_n18422.n0 VSSD 0.749607f
C3399 a_78134_n18422.t5 VSSD 0.02856f
C3400 a_78134_n18422.t4 VSSD 0.013095f
C3401 a_78134_n18422.n1 VSSD 0.140208f
C3402 a_78134_n18422.n2 VSSD 0.351639f
C3403 a_78134_n18422.n3 VSSD 0.548746f
C3404 a_78134_n18422.t1 VSSD 0.195407f
C3405 a_10818_n4422.t3 VSSD 0.043229f
C3406 a_10818_n4422.t0 VSSD 0.043351f
C3407 a_10818_n4422.n0 VSSD 0.276169f
C3408 a_10818_n4422.t4 VSSD 0.381059f
C3409 a_10818_n4422.t1 VSSD 0.141857f
C3410 a_10818_n4422.n1 VSSD 1.09466f
C3411 a_10818_n4422.n2 VSSD 0.535288f
C3412 a_10818_n4422.t2 VSSD 0.48439f
C3413 a_10632_n3162.n0 VSSD 0.986176f
C3414 a_10632_n3162.t4 VSSD 0.035769f
C3415 a_10632_n3162.t5 VSSD 0.0164f
C3416 a_10632_n3162.n1 VSSD 0.173748f
C3417 a_10632_n3162.t2 VSSD 0.288155f
C3418 a_10632_n3162.t0 VSSD 0.085552f
C3419 a_10632_n3162.n2 VSSD 0.878128f
C3420 a_10632_n3162.t3 VSSD 0.085552f
C3421 a_10632_n3162.t1 VSSD 0.250521f
C3422 a_4722_n3300.t4 VSSD 0.150297f
C3423 a_4722_n3300.t3 VSSD 0.111359f
C3424 a_4722_n3300.t5 VSSD 0.210813f
C3425 a_4722_n3300.n0 VSSD 2.80378f
C3426 a_4722_n3300.t2 VSSD 0.113401f
C3427 a_4722_n3300.n1 VSSD 1.56811f
C3428 a_4722_n3300.n2 VSSD 1.46986f
C3429 a_4722_n3300.t0 VSSD 0.198092f
C3430 a_4722_n3300.n3 VSSD 1.4663f
C3431 a_4722_n3300.t1 VSSD 0.407992f
C3432 a_106818_n4422.t2 VSSD 0.141857f
C3433 a_106818_n4422.t1 VSSD 0.043229f
C3434 a_106818_n4422.t3 VSSD 0.043351f
C3435 a_106818_n4422.n0 VSSD 0.276169f
C3436 a_106818_n4422.t4 VSSD 0.48439f
C3437 a_106818_n4422.n1 VSSD 0.535288f
C3438 a_106818_n4422.n2 VSSD 1.09469f
C3439 a_106818_n4422.t0 VSSD 0.381025f
C3440 a_105342_n4422.n0 VSSD 1.4589f
C3441 a_105342_n4422.t1 VSSD 0.246654f
C3442 a_105342_n4422.t4 VSSD 0.075169f
C3443 a_105342_n4422.t2 VSSD 0.075381f
C3444 a_105342_n4422.n1 VSSD 0.480219f
C3445 a_105342_n4422.t3 VSSD 0.842287f
C3446 a_105342_n4422.n2 VSSD 0.872815f
C3447 a_105342_n4422.t6 VSSD 0.095963f
C3448 a_105342_n4422.t5 VSSD 0.044581f
C3449 a_105342_n4422.n3 VSSD 2.44958f
C3450 a_105342_n4422.t0 VSSD 0.658454f
C3451 a_4790_n4422.t1 VSSD 0.143873f
C3452 a_4790_n4422.t0 VSSD 0.043846f
C3453 a_4790_n4422.t3 VSSD 0.04397f
C3454 a_4790_n4422.n0 VSSD 0.280111f
C3455 a_4790_n4422.t4 VSSD 0.491305f
C3456 a_4790_n4422.n1 VSSD 0.534653f
C3457 a_4790_n4422.n2 VSSD 1.07817f
C3458 a_4790_n4422.t2 VSSD 0.384075f
C3459 Set.t73 VSSD 0.040656f
C3460 Set.t3 VSSD 0.01864f
C3461 Set.n0 VSSD 0.261137f
C3462 Set.n1 VSSD 1.21259f
C3463 Set.t85 VSSD 0.040524f
C3464 Set.t14 VSSD 0.018826f
C3465 Set.n2 VSSD 0.155606f
C3466 Set.n3 VSSD 0.963721f
C3467 Set.t57 VSSD 0.040656f
C3468 Set.t63 VSSD 0.01864f
C3469 Set.n4 VSSD 0.261122f
C3470 Set.n5 VSSD 0.724341f
C3471 Set.t10 VSSD 0.040524f
C3472 Set.t17 VSSD 0.018826f
C3473 Set.n6 VSSD 0.223653f
C3474 Set.n7 VSSD 0.892373f
C3475 Set.n8 VSSD 4.48701f
C3476 Set.t65 VSSD 0.040656f
C3477 Set.t0 VSSD 0.01864f
C3478 Set.n9 VSSD 0.261137f
C3479 Set.n10 VSSD 1.21259f
C3480 Set.t32 VSSD 0.040524f
C3481 Set.t53 VSSD 0.018826f
C3482 Set.n11 VSSD 0.155606f
C3483 Set.n12 VSSD 0.963721f
C3484 Set.t80 VSSD 0.040656f
C3485 Set.t26 VSSD 0.01864f
C3486 Set.n13 VSSD 0.261122f
C3487 Set.n14 VSSD 0.724341f
C3488 Set.t76 VSSD 0.040524f
C3489 Set.t82 VSSD 0.018826f
C3490 Set.n15 VSSD 0.223653f
C3491 Set.n16 VSSD 0.892373f
C3492 Set.n17 VSSD 1.58424f
C3493 Set.n18 VSSD 32.3609f
C3494 Set.t23 VSSD 0.040656f
C3495 Set.t45 VSSD 0.01864f
C3496 Set.n19 VSSD 0.261122f
C3497 Set.n20 VSSD 1.2126f
C3498 Set.t12 VSSD 0.040524f
C3499 Set.t30 VSSD 0.018826f
C3500 Set.n21 VSSD 0.155602f
C3501 Set.n22 VSSD 0.963725f
C3502 Set.t7 VSSD 0.040656f
C3503 Set.t25 VSSD 0.01864f
C3504 Set.n23 VSSD 0.261137f
C3505 Set.n24 VSSD 0.724327f
C3506 Set.t22 VSSD 0.040524f
C3507 Set.t43 VSSD 0.018826f
C3508 Set.n25 VSSD 0.223664f
C3509 Set.n26 VSSD 0.892362f
C3510 Set.n27 VSSD 1.63549f
C3511 Set.n28 VSSD 12.751699f
C3512 Set.t11 VSSD 0.040656f
C3513 Set.t28 VSSD 0.01864f
C3514 Set.n29 VSSD 0.261137f
C3515 Set.n30 VSSD 1.21259f
C3516 Set.t86 VSSD 0.040524f
C3517 Set.t16 VSSD 0.018826f
C3518 Set.n31 VSSD 0.155606f
C3519 Set.n32 VSSD 0.963721f
C3520 Set.t9 VSSD 0.040656f
C3521 Set.t5 VSSD 0.01864f
C3522 Set.n33 VSSD 0.261122f
C3523 Set.n34 VSSD 0.724341f
C3524 Set.t56 VSSD 0.040524f
C3525 Set.t51 VSSD 0.018826f
C3526 Set.n35 VSSD 0.223653f
C3527 Set.n36 VSSD 0.892373f
C3528 Set.n37 VSSD 1.58424f
C3529 Set.n38 VSSD 12.5925f
C3530 Set.t50 VSSD 0.040656f
C3531 Set.t78 VSSD 0.01864f
C3532 Set.n39 VSSD 0.261122f
C3533 Set.n40 VSSD 1.2126f
C3534 Set.t20 VSSD 0.040524f
C3535 Set.t39 VSSD 0.018826f
C3536 Set.n41 VSSD 0.155602f
C3537 Set.n42 VSSD 0.963725f
C3538 Set.t18 VSSD 0.040656f
C3539 Set.t34 VSSD 0.01864f
C3540 Set.n43 VSSD 0.261137f
C3541 Set.n44 VSSD 0.724327f
C3542 Set.t49 VSSD 0.040524f
C3543 Set.t77 VSSD 0.018826f
C3544 Set.n45 VSSD 0.223664f
C3545 Set.n46 VSSD 0.892362f
C3546 Set.n47 VSSD 1.63549f
C3547 Set.n48 VSSD 12.751699f
C3548 Set.t55 VSSD 0.040656f
C3549 Set.t81 VSSD 0.01864f
C3550 Set.n49 VSSD 0.261137f
C3551 Set.n50 VSSD 1.21259f
C3552 Set.t42 VSSD 0.040524f
C3553 Set.t67 VSSD 0.018826f
C3554 Set.n51 VSSD 0.155606f
C3555 Set.n52 VSSD 0.963721f
C3556 Set.t27 VSSD 0.040656f
C3557 Set.t74 VSSD 0.01864f
C3558 Set.n53 VSSD 0.261122f
C3559 Set.n54 VSSD 0.724341f
C3560 Set.t21 VSSD 0.040524f
C3561 Set.t19 VSSD 0.018826f
C3562 Set.n55 VSSD 0.223653f
C3563 Set.n56 VSSD 0.892373f
C3564 Set.n57 VSSD 1.58424f
C3565 Set.n58 VSSD 12.5925f
C3566 Set.t38 VSSD 0.040656f
C3567 Set.t62 VSSD 0.01864f
C3568 Set.n59 VSSD 0.261122f
C3569 Set.n60 VSSD 1.2126f
C3570 Set.t47 VSSD 0.040524f
C3571 Set.t72 VSSD 0.018826f
C3572 Set.n61 VSSD 0.155602f
C3573 Set.n62 VSSD 0.963725f
C3574 Set.t44 VSSD 0.040656f
C3575 Set.t68 VSSD 0.01864f
C3576 Set.n63 VSSD 0.261137f
C3577 Set.n64 VSSD 0.724327f
C3578 Set.t37 VSSD 0.040524f
C3579 Set.t61 VSSD 0.018826f
C3580 Set.n65 VSSD 0.223664f
C3581 Set.n66 VSSD 0.892362f
C3582 Set.n67 VSSD 1.63549f
C3583 Set.n68 VSSD 12.751699f
C3584 Set.t40 VSSD 0.040656f
C3585 Set.t64 VSSD 0.01864f
C3586 Set.n69 VSSD 0.261137f
C3587 Set.n70 VSSD 1.21259f
C3588 Set.t31 VSSD 0.040524f
C3589 Set.t52 VSSD 0.018826f
C3590 Set.n71 VSSD 0.155606f
C3591 Set.n72 VSSD 0.963721f
C3592 Set.t60 VSSD 0.040656f
C3593 Set.t54 VSSD 0.01864f
C3594 Set.n73 VSSD 0.261122f
C3595 Set.n74 VSSD 0.724341f
C3596 Set.t29 VSSD 0.040524f
C3597 Set.t15 VSSD 0.018826f
C3598 Set.n75 VSSD 0.223653f
C3599 Set.n76 VSSD 0.892373f
C3600 Set.n77 VSSD 1.58424f
C3601 Set.n78 VSSD 12.5925f
C3602 Set.t36 VSSD 0.040656f
C3603 Set.t59 VSSD 0.01864f
C3604 Set.n79 VSSD 0.261122f
C3605 Set.n80 VSSD 1.2126f
C3606 Set.t46 VSSD 0.040524f
C3607 Set.t71 VSSD 0.018826f
C3608 Set.n81 VSSD 0.155602f
C3609 Set.n82 VSSD 0.963725f
C3610 Set.t41 VSSD 0.040656f
C3611 Set.t66 VSSD 0.01864f
C3612 Set.n83 VSSD 0.261137f
C3613 Set.n84 VSSD 0.724327f
C3614 Set.t35 VSSD 0.040524f
C3615 Set.t58 VSSD 0.018826f
C3616 Set.n85 VSSD 0.223664f
C3617 Set.n86 VSSD 0.892362f
C3618 Set.n87 VSSD 1.63549f
C3619 Set.n88 VSSD 12.751699f
C3620 Set.t6 VSSD 0.040656f
C3621 Set.t24 VSSD 0.01864f
C3622 Set.n89 VSSD 0.261137f
C3623 Set.n90 VSSD 1.21259f
C3624 Set.t83 VSSD 0.040524f
C3625 Set.t13 VSSD 0.018826f
C3626 Set.n91 VSSD 0.155606f
C3627 Set.n92 VSSD 0.963721f
C3628 Set.t87 VSSD 0.040656f
C3629 Set.t33 VSSD 0.01864f
C3630 Set.n93 VSSD 0.261122f
C3631 Set.n94 VSSD 0.724341f
C3632 Set.t48 VSSD 0.040524f
C3633 Set.t84 VSSD 0.018826f
C3634 Set.n95 VSSD 0.223653f
C3635 Set.n96 VSSD 0.892373f
C3636 Set.n97 VSSD 1.58424f
C3637 Set.n98 VSSD 12.5925f
C3638 Set.t70 VSSD 0.040656f
C3639 Set.t2 VSSD 0.01864f
C3640 Set.n99 VSSD 0.261122f
C3641 Set.n100 VSSD 1.2126f
C3642 Set.t79 VSSD 0.040524f
C3643 Set.t8 VSSD 0.018826f
C3644 Set.n101 VSSD 0.155602f
C3645 Set.n102 VSSD 0.963725f
C3646 Set.t75 VSSD 0.040656f
C3647 Set.t4 VSSD 0.01864f
C3648 Set.n103 VSSD 0.261137f
C3649 Set.n104 VSSD 0.724327f
C3650 Set.t69 VSSD 0.040524f
C3651 Set.t1 VSSD 0.018826f
C3652 Set.n105 VSSD 0.223664f
C3653 Set.n106 VSSD 0.892362f
C3654 Set.n107 VSSD 1.63549f
C3655 Set.n108 VSSD 17.772999f
C3656 a_n27210_n4422.t1 VSSD 0.043846f
C3657 a_n27210_n4422.t0 VSSD 0.04397f
C3658 a_n27210_n4422.n0 VSSD 0.280111f
C3659 a_n27210_n4422.t4 VSSD 0.38411f
C3660 a_n27210_n4422.t2 VSSD 0.143873f
C3661 a_n27210_n4422.n1 VSSD 1.07813f
C3662 a_n27210_n4422.n2 VSSD 0.534653f
C3663 a_n27210_n4422.t3 VSSD 0.491305f
C3664 SAR_Asynchronous_Logic_0/D_reset_FF_0.Q.n0 VSSD 1.54881f
C3665 SAR_Asynchronous_Logic_0/D_reset_FF_0.Q.t6 VSSD 0.094079f
C3666 SAR_Asynchronous_Logic_0/D_reset_FF_0.Q.t3 VSSD 0.043705f
C3667 SAR_Asynchronous_Logic_0/D_reset_FF_0.Q.n1 VSSD 0.314123f
C3668 SAR_Asynchronous_Logic_0/D_reset_FF_0.Q.t2 VSSD 0.073692f
C3669 SAR_Asynchronous_Logic_0/D_reset_FF_0.Q.t1 VSSD 0.073901f
C3670 SAR_Asynchronous_Logic_0/D_reset_FF_0.Q.n2 VSSD 0.470788f
C3671 SAR_Asynchronous_Logic_0/D_reset_FF_0.Q.t0 VSSD 0.825745f
C3672 SAR_Asynchronous_Logic_0/D_reset_FF_0.Q.t4 VSSD 0.038164f
C3673 SAR_Asynchronous_Logic_0/D_reset_FF_0.Q.t5 VSSD 0.090033f
C3674 SAR_Asynchronous_Logic_0/D_reset_FF_0.Q.n3 VSSD 0.293925f
C3675 SAR_Asynchronous_Logic_0/D_reset_FF_0.Q.n4 VSSD 1.06447f
C3676 a_n22658_n4422.n0 VSSD 1.4589f
C3677 a_n22658_n4422.t0 VSSD 0.075169f
C3678 a_n22658_n4422.t1 VSSD 0.075381f
C3679 a_n22658_n4422.n1 VSSD 0.480219f
C3680 a_n22658_n4422.t5 VSSD 0.095963f
C3681 a_n22658_n4422.t6 VSSD 0.044581f
C3682 a_n22658_n4422.t3 VSSD 0.658513f
C3683 a_n22658_n4422.t4 VSSD 0.246654f
C3684 a_n22658_n4422.n2 VSSD 2.44952f
C3685 a_n22658_n4422.n3 VSSD 0.872815f
C3686 a_n22658_n4422.t2 VSSD 0.842287f
C3687 a_n21368_n3162.n0 VSSD 0.986143f
C3688 a_n21368_n3162.t4 VSSD 0.035769f
C3689 a_n21368_n3162.t5 VSSD 0.0164f
C3690 a_n21368_n3162.n1 VSSD 0.173748f
C3691 a_n21368_n3162.t3 VSSD 0.250554f
C3692 a_n21368_n3162.t1 VSSD 0.085552f
C3693 a_n21368_n3162.t2 VSSD 0.085552f
C3694 a_n21368_n3162.n2 VSSD 0.878169f
C3695 a_n21368_n3162.t0 VSSD 0.288113f
C3696 a_99002_n80.n0 VSSD 7.24543f
C3697 a_99002_n80.n1 VSSD 4.09072f
C3698 a_99002_n80.t6 VSSD 0.133561f
C3699 a_99002_n80.t4 VSSD 0.367163f
C3700 a_99002_n80.t7 VSSD 0.077933f
C3701 a_99002_n80.t3 VSSD 0.088897f
C3702 a_99002_n80.n2 VSSD 2.7214f
C3703 a_99002_n80.t0 VSSD 0.111234f
C3704 a_99002_n80.t5 VSSD 0.029289f
C3705 a_99002_n80.t2 VSSD 0.069099f
C3706 a_99002_n80.n3 VSSD 0.26036f
C3707 a_99002_n80.t1 VSSD 0.304917f
C3708 a_98110_n80.n0 VSSD 8.2746f
C3709 a_98110_n80.n1 VSSD 4.39821f
C3710 a_98110_n80.t4 VSSD 0.030513f
C3711 a_98110_n80.t2 VSSD 0.071986f
C3712 a_98110_n80.n2 VSSD 0.235316f
C3713 a_98110_n80.t5 VSSD 0.125181f
C3714 a_98110_n80.t6 VSSD 0.098408f
C3715 a_98110_n80.t7 VSSD 0.097436f
C3716 a_98110_n80.n3 VSSD 2.56472f
C3717 a_98110_n80.t3 VSSD 0.270804f
C3718 a_98110_n80.t1 VSSD 0.115882f
C3719 a_98110_n80.t0 VSSD 0.316938f
C3720 a_12918_n14314.t1 VSSD 0.146586f
C3721 a_12918_n14314.t3 VSSD 0.04467f
C3722 a_12918_n14314.t0 VSSD 0.044796f
C3723 a_12918_n14314.n0 VSSD 0.285375f
C3724 a_12918_n14314.t4 VSSD 0.500537f
C3725 a_12918_n14314.n1 VSSD 0.55313f
C3726 a_12918_n14314.n2 VSSD 1.13118f
C3727 a_12918_n14314.t2 VSSD 0.393726f
C3728 a_12732_n13054.n0 VSSD 1.62015f
C3729 a_12732_n13054.t4 VSSD 0.058764f
C3730 a_12732_n13054.t5 VSSD 0.026943f
C3731 a_12732_n13054.n1 VSSD 0.285443f
C3732 a_12732_n13054.t2 VSSD 0.473397f
C3733 a_12732_n13054.t0 VSSD 0.14055f
C3734 a_12732_n13054.n2 VSSD 1.44264f
C3735 a_12732_n13054.t3 VSSD 0.14055f
C3736 a_12732_n13054.t1 VSSD 0.41157f
C3737 a_6822_n13946.n0 VSSD 1.29292f
C3738 a_6822_n13946.t5 VSSD 0.038175f
C3739 a_6822_n13946.t3 VSSD 0.090059f
C3740 a_6822_n13946.n1 VSSD 0.298371f
C3741 a_6822_n13946.t0 VSSD 0.147144f
C3742 a_6822_n13946.t6 VSSD 0.1636f
C3743 a_6822_n13946.t4 VSSD 0.130517f
C3744 a_6822_n13946.n2 VSSD 2.29806f
C3745 a_6822_n13946.t2 VSSD 0.128165f
C3746 a_6822_n13946.n3 VSSD 1.28395f
C3747 a_6822_n13946.t7 VSSD 0.088694f
C3748 a_6822_n13946.n4 VSSD 1.24258f
C3749 a_6822_n13946.t1 VSSD 0.397759f
C3750 VDDD.n0 VSSD 1.4213f
C3751 VDDD.n1 VSSD 0.130384f
C3752 VDDD.n2 VSSD 0.056675f
C3753 VDDD.n3 VSSD 0.045634f
C3754 VDDD.n4 VSSD 0.014342f
C3755 VDDD.n5 VSSD 0.045634f
C3756 VDDD.n6 VSSD 0.045634f
C3757 VDDD.n7 VSSD 0.072363f
C3758 VDDD.n8 VSSD 0.045634f
C3759 VDDD.n9 VSSD 0.045634f
C3760 VDDD.n10 VSSD 0.045634f
C3761 VDDD.n11 VSSD 0.010757f
C3762 VDDD.n12 VSSD 0.130384f
C3763 VDDD.n13 VSSD 0.045634f
C3764 VDDD.n14 VSSD 0.045634f
C3765 VDDD.n15 VSSD 0.014342f
C3766 VDDD.n16 VSSD 1.37223f
C3767 VDDD.n18 VSSD 0.045634f
C3768 VDDD.n19 VSSD 0.045634f
C3769 VDDD.n20 VSSD 0.045634f
C3770 VDDD.n22 VSSD 0.045634f
C3771 VDDD.n23 VSSD 0.045634f
C3772 VDDD.n24 VSSD 0.045634f
C3773 VDDD.n25 VSSD 0.045634f
C3774 VDDD.n28 VSSD 0.091269f
C3775 VDDD.n29 VSSD 0.056675f
C3776 VDDD.n33 VSSD 0.091269f
C3777 VDDD.n35 VSSD 0.091269f
C3778 VDDD.n38 VSSD 0.045634f
C3779 VDDD.n40 VSSD 0.045634f
C3780 VDDD.n41 VSSD 0.046547f
C3781 VDDD.n42 VSSD 0.046547f
C3782 VDDD.n43 VSSD 0.046547f
C3783 VDDD.n44 VSSD 0.046547f
C3784 VDDD.n45 VSSD 0.046547f
C3785 VDDD.t474 VSSD 0.035134f
C3786 VDDD.n46 VSSD 0.064631f
C3787 VDDD.t336 VSSD 0.035134f
C3788 VDDD.n47 VSSD 0.064631f
C3789 VDDD.t577 VSSD 0.049949f
C3790 VDDD.n48 VSSD 0.091269f
C3791 VDDD.n49 VSSD 0.091269f
C3792 VDDD.n51 VSSD 0.091269f
C3793 VDDD.n54 VSSD 0.047851f
C3794 VDDD.n55 VSSD 0.047851f
C3795 VDDD.n56 VSSD 0.047851f
C3796 VDDD.n57 VSSD 0.081038f
C3797 VDDD.n60 VSSD 0.047851f
C3798 VDDD.n62 VSSD 0.047851f
C3799 VDDD.n64 VSSD 0.047851f
C3800 VDDD.n66 VSSD 0.047851f
C3801 VDDD.n68 VSSD 0.147985f
C3802 VDDD.n69 VSSD 0.147985f
C3803 VDDD.n70 VSSD 0.147985f
C3804 VDDD.n73 VSSD 0.260767f
C3805 VDDD.n74 VSSD 0.260767f
C3806 VDDD.n75 VSSD 0.260767f
C3807 VDDD.n76 VSSD 0.260767f
C3808 VDDD.n79 VSSD 0.260767f
C3809 VDDD.n80 VSSD 0.260767f
C3810 VDDD.n81 VSSD 0.260767f
C3811 VDDD.n82 VSSD 0.260767f
C3812 VDDD.n87 VSSD 0.130384f
C3813 VDDD.n88 VSSD 0.130384f
C3814 VDDD.n89 VSSD 0.130384f
C3815 VDDD.n90 VSSD 0.130384f
C3816 VDDD.n91 VSSD 0.130384f
C3817 VDDD.n92 VSSD 0.130384f
C3818 VDDD.n93 VSSD 0.130384f
C3819 VDDD.n94 VSSD 0.130384f
C3820 VDDD.n95 VSSD 0.130384f
C3821 VDDD.n96 VSSD 0.130384f
C3822 VDDD.n97 VSSD 0.130384f
C3823 VDDD.n98 VSSD 0.130384f
C3824 VDDD.n99 VSSD 0.130384f
C3825 VDDD.n113 VSSD 0.130384f
C3826 VDDD.n114 VSSD 0.342783f
C3827 VDDD.n115 VSSD 0.130384f
C3828 VDDD.n116 VSSD 0.130384f
C3829 VDDD.n117 VSSD 7.02e-19
C3830 VDDD.n118 VSSD 0.045634f
C3831 VDDD.n119 VSSD 0.135431f
C3832 VDDD.n120 VSSD 0.091269f
C3833 VDDD.n121 VSSD 0.091269f
C3834 VDDD.n123 VSSD 0.091269f
C3835 VDDD.n126 VSSD 0.045634f
C3836 VDDD.n127 VSSD 0.045634f
C3837 VDDD.n128 VSSD 0.045634f
C3838 VDDD.n130 VSSD 1.33811f
C3839 VDDD.n132 VSSD 0.045634f
C3840 VDDD.n135 VSSD 0.045634f
C3841 VDDD.n138 VSSD 0.045634f
C3842 VDDD.n139 VSSD 0.014342f
C3843 VDDD.n140 VSSD 0.045596f
C3844 VDDD.n141 VSSD 0.045634f
C3845 VDDD.n142 VSSD 0.045634f
C3846 VDDD.n143 VSSD 0.010757f
C3847 VDDD.n144 VSSD 0.010757f
C3848 VDDD.n145 VSSD 0.130384f
C3849 VDDD.n146 VSSD 0.045634f
C3850 VDDD.n149 VSSD 0.056675f
C3851 VDDD.n150 VSSD 0.056873f
C3852 VDDD.n152 VSSD 0.045634f
C3853 VDDD.n153 VSSD 0.029743f
C3854 VDDD.n154 VSSD 1.24061f
C3855 VDDD.n155 VSSD 0.038149f
C3856 VDDD.n156 VSSD 0.038149f
C3857 VDDD.t320 VSSD 0.154524f
C3858 VDDD.n157 VSSD 0.038149f
C3859 VDDD.n158 VSSD 0.388226f
C3860 VDDD.n159 VSSD 0.249067f
C3861 VDDD.n160 VSSD 0.246436f
C3862 VDDD.t321 VSSD 0.035134f
C3863 VDDD.n161 VSSD 0.055592f
C3864 VDDD.t180 VSSD 0.035134f
C3865 VDDD.n162 VSSD 0.073685f
C3866 VDDD.t323 VSSD 0.035134f
C3867 VDDD.n163 VSSD 0.077851f
C3868 VDDD.t7 VSSD 0.035134f
C3869 VDDD.n164 VSSD 0.077772f
C3870 VDDD.t239 VSSD 0.035134f
C3871 VDDD.n165 VSSD 0.064631f
C3872 VDDD.n167 VSSD 0.091269f
C3873 VDDD.n168 VSSD 0.091269f
C3874 VDDD.n169 VSSD 0.091269f
C3875 VDDD.n171 VSSD 0.147985f
C3876 VDDD.n172 VSSD 0.147985f
C3877 VDDD.n173 VSSD 0.147985f
C3878 VDDD.n175 VSSD 0.147985f
C3879 VDDD.n176 VSSD 0.147985f
C3880 VDDD.n182 VSSD 0.091269f
C3881 VDDD.n183 VSSD 0.091269f
C3882 VDDD.n184 VSSD 0.047851f
C3883 VDDD.n186 VSSD 0.091269f
C3884 VDDD.n188 VSSD 0.047851f
C3885 VDDD.n189 VSSD 0.047851f
C3886 VDDD.n190 VSSD 0.047851f
C3887 VDDD.n191 VSSD 0.047851f
C3888 VDDD.t118 VSSD 0.035134f
C3889 VDDD.n193 VSSD 0.066479f
C3890 VDDD.n194 VSSD 0.046547f
C3891 VDDD.n195 VSSD 0.056675f
C3892 VDDD.n196 VSSD 0.045634f
C3893 VDDD.n197 VSSD 0.045634f
C3894 VDDD.n198 VSSD 0.045634f
C3895 VDDD.n199 VSSD 0.046547f
C3896 VDDD.n200 VSSD 0.045634f
C3897 VDDD.n201 VSSD 0.045634f
C3898 VDDD.n202 VSSD 0.045634f
C3899 VDDD.n203 VSSD 0.045634f
C3900 VDDD.n204 VSSD 0.05721f
C3901 VDDD.n206 VSSD 0.131014f
C3902 VDDD.n209 VSSD 0.091269f
C3903 VDDD.n210 VSSD 0.045634f
C3904 VDDD.n216 VSSD 0.045634f
C3905 VDDD.n220 VSSD 0.091269f
C3906 VDDD.n222 VSSD 0.091269f
C3907 VDDD.n224 VSSD 0.045634f
C3908 VDDD.n225 VSSD 0.045634f
C3909 VDDD.n226 VSSD 0.059859f
C3910 VDDD.n227 VSSD 0.132516f
C3911 VDDD.n228 VSSD 0.046547f
C3912 VDDD.n229 VSSD 0.045634f
C3913 VDDD.n230 VSSD 0.045634f
C3914 VDDD.n231 VSSD 0.045634f
C3915 VDDD.n232 VSSD 0.046547f
C3916 VDDD.n233 VSSD 0.046547f
C3917 VDDD.n234 VSSD 0.046547f
C3918 VDDD.n235 VSSD 0.045634f
C3919 VDDD.n236 VSSD 0.045634f
C3920 VDDD.n237 VSSD 0.056675f
C3921 VDDD.n238 VSSD 1.16338f
C3922 VDDD.n239 VSSD 1.1952f
C3923 VDDD.t292 VSSD 0.035134f
C3924 VDDD.t117 VSSD 0.202843f
C3925 VDDD.n240 VSSD 0.227224f
C3926 VDDD.t206 VSSD 0.780046f
C3927 VDDD.t138 VSSD 0.705018f
C3928 VDDD.t294 VSSD 0.64666f
C3929 VDDD.t344 VSSD 0.64666f
C3930 VDDD.t541 VSSD 0.686091f
C3931 VDDD.t290 VSSD 1.02519f
C3932 VDDD.t229 VSSD 1.11983f
C3933 VDDD.t416 VSSD 0.780724f
C3934 VDDD.t557 VSSD 0.641929f
C3935 VDDD.t460 VSSD 0.641929f
C3936 VDDD.t175 VSSD 0.630888f
C3937 VDDD.t378 VSSD 0.876897f
C3938 VDDD.t291 VSSD 0.57622f
C3939 VDDD.t126 VSSD 1.32373f
C3940 VDDD.t468 VSSD 0.035134f
C3941 VDDD.n241 VSSD 0.064631f
C3942 VDDD.n242 VSSD 1.01482f
C3943 VDDD.t467 VSSD 0.315139f
C3944 VDDD.n243 VSSD 0.285204f
C3945 VDDD.n244 VSSD 0.064631f
C3946 VDDD.n245 VSSD 0.660804f
C3947 VDDD.t176 VSSD 0.049949f
C3948 VDDD.n246 VSSD 0.86f
C3949 VDDD.t558 VSSD 0.049949f
C3950 VDDD.n247 VSSD 1.32347f
C3951 VDDD.t542 VSSD 0.049949f
C3952 VDDD.n248 VSSD 1.34049f
C3953 VDDD.t295 VSSD 0.049949f
C3954 VDDD.n249 VSSD 0.98744f
C3955 VDDD.n250 VSSD 1.22687f
C3956 VDDD.n251 VSSD 0.594276f
C3957 VDDD.n254 VSSD 0.047851f
C3958 VDDD.n256 VSSD 0.047851f
C3959 VDDD.n258 VSSD 0.047851f
C3960 VDDD.n259 VSSD 0.12071f
C3961 VDDD.n260 VSSD 0.081038f
C3962 VDDD.n261 VSSD 1.37418f
C3963 VDDD.n264 VSSD 0.147985f
C3964 VDDD.n266 VSSD 0.147985f
C3965 VDDD.n268 VSSD 0.147985f
C3966 VDDD.n269 VSSD 0.130384f
C3967 VDDD.n270 VSSD 7.02e-19
C3968 VDDD.n271 VSSD 0.045634f
C3969 VDDD.n272 VSSD 0.135431f
C3970 VDDD.n273 VSSD 0.091269f
C3971 VDDD.n274 VSSD 0.091269f
C3972 VDDD.n276 VSSD 0.091269f
C3973 VDDD.n279 VSSD 0.045634f
C3974 VDDD.n280 VSSD 0.045634f
C3975 VDDD.n281 VSSD 0.045634f
C3976 VDDD.n283 VSSD 1.33811f
C3977 VDDD.n285 VSSD 0.045634f
C3978 VDDD.n288 VSSD 0.045634f
C3979 VDDD.n291 VSSD 0.045634f
C3980 VDDD.n292 VSSD 0.014342f
C3981 VDDD.n293 VSSD 0.045596f
C3982 VDDD.n294 VSSD 0.045634f
C3983 VDDD.n295 VSSD 0.045634f
C3984 VDDD.n296 VSSD 0.010757f
C3985 VDDD.n297 VSSD 0.010757f
C3986 VDDD.n298 VSSD 0.130384f
C3987 VDDD.n299 VSSD 0.045634f
C3988 VDDD.n302 VSSD 0.056675f
C3989 VDDD.n303 VSSD 0.056873f
C3990 VDDD.n305 VSSD 0.045634f
C3991 VDDD.n306 VSSD 0.029743f
C3992 VDDD.n307 VSSD 1.24061f
C3993 VDDD.n308 VSSD 0.038149f
C3994 VDDD.n309 VSSD 0.038149f
C3995 VDDD.t120 VSSD 0.154524f
C3996 VDDD.n310 VSSD 0.038149f
C3997 VDDD.n311 VSSD 0.388226f
C3998 VDDD.n312 VSSD 0.249067f
C3999 VDDD.n313 VSSD 0.246436f
C4000 VDDD.t121 VSSD 0.035134f
C4001 VDDD.n314 VSSD 0.055592f
C4002 VDDD.t111 VSSD 0.035134f
C4003 VDDD.n315 VSSD 0.073685f
C4004 VDDD.t116 VSSD 0.035134f
C4005 VDDD.n316 VSSD 0.077851f
C4006 VDDD.t72 VSSD 0.035134f
C4007 VDDD.n317 VSSD 0.077772f
C4008 VDDD.t161 VSSD 0.035134f
C4009 VDDD.n318 VSSD 0.064631f
C4010 VDDD.n320 VSSD 0.091269f
C4011 VDDD.n321 VSSD 0.091269f
C4012 VDDD.n322 VSSD 0.091269f
C4013 VDDD.n324 VSSD 0.147985f
C4014 VDDD.n325 VSSD 0.147985f
C4015 VDDD.n326 VSSD 0.147985f
C4016 VDDD.n328 VSSD 0.147985f
C4017 VDDD.n329 VSSD 0.147985f
C4018 VDDD.n335 VSSD 0.091269f
C4019 VDDD.n336 VSSD 0.091269f
C4020 VDDD.n337 VSSD 0.047851f
C4021 VDDD.n339 VSSD 0.091269f
C4022 VDDD.n341 VSSD 0.047851f
C4023 VDDD.n342 VSSD 0.047851f
C4024 VDDD.n343 VSSD 0.047851f
C4025 VDDD.n344 VSSD 0.047851f
C4026 VDDD.t280 VSSD 0.035134f
C4027 VDDD.n346 VSSD 0.066479f
C4028 VDDD.n347 VSSD 0.046547f
C4029 VDDD.n348 VSSD 0.056675f
C4030 VDDD.n349 VSSD 0.045634f
C4031 VDDD.n350 VSSD 0.045634f
C4032 VDDD.n351 VSSD 0.045634f
C4033 VDDD.n352 VSSD 0.046547f
C4034 VDDD.n353 VSSD 0.045634f
C4035 VDDD.n354 VSSD 0.045634f
C4036 VDDD.n355 VSSD 0.045634f
C4037 VDDD.n356 VSSD 0.045634f
C4038 VDDD.n357 VSSD 0.05721f
C4039 VDDD.n359 VSSD 0.131014f
C4040 VDDD.n362 VSSD 0.091269f
C4041 VDDD.n363 VSSD 0.045634f
C4042 VDDD.n369 VSSD 0.045634f
C4043 VDDD.n373 VSSD 0.091269f
C4044 VDDD.n375 VSSD 0.091269f
C4045 VDDD.n377 VSSD 0.045634f
C4046 VDDD.n378 VSSD 0.045634f
C4047 VDDD.n379 VSSD 0.059859f
C4048 VDDD.n380 VSSD 0.132516f
C4049 VDDD.n381 VSSD 0.046547f
C4050 VDDD.n382 VSSD 0.045634f
C4051 VDDD.n383 VSSD 0.045634f
C4052 VDDD.n384 VSSD 0.045634f
C4053 VDDD.n385 VSSD 0.046547f
C4054 VDDD.n386 VSSD 0.046547f
C4055 VDDD.n387 VSSD 0.046547f
C4056 VDDD.n388 VSSD 0.045634f
C4057 VDDD.n389 VSSD 0.045634f
C4058 VDDD.n390 VSSD 0.056675f
C4059 VDDD.n391 VSSD 1.16338f
C4060 VDDD.n392 VSSD 1.1952f
C4061 VDDD.t301 VSSD 0.035134f
C4062 VDDD.t279 VSSD 0.202843f
C4063 VDDD.n393 VSSD 0.227224f
C4064 VDDD.t582 VSSD 0.780046f
C4065 VDDD.t395 VSSD 0.705018f
C4066 VDDD.t281 VSSD 0.64666f
C4067 VDDD.t293 VSSD 0.64666f
C4068 VDDD.t404 VSSD 0.686091f
C4069 VDDD.t248 VSSD 1.02519f
C4070 VDDD.t302 VSSD 1.11983f
C4071 VDDD.t592 VSSD 0.780724f
C4072 VDDD.t219 VSSD 0.641929f
C4073 VDDD.t374 VSSD 0.641929f
C4074 VDDD.t132 VSSD 0.630888f
C4075 VDDD.t581 VSSD 0.876897f
C4076 VDDD.t300 VSSD 0.57622f
C4077 VDDD.t122 VSSD 1.32373f
C4078 VDDD.t472 VSSD 0.035134f
C4079 VDDD.n394 VSSD 0.064631f
C4080 VDDD.n395 VSSD 1.01482f
C4081 VDDD.t471 VSSD 0.315139f
C4082 VDDD.n396 VSSD 0.285204f
C4083 VDDD.n397 VSSD 0.064631f
C4084 VDDD.n398 VSSD 0.660804f
C4085 VDDD.t133 VSSD 0.049949f
C4086 VDDD.n399 VSSD 0.86f
C4087 VDDD.t220 VSSD 0.049949f
C4088 VDDD.n400 VSSD 1.32347f
C4089 VDDD.t405 VSSD 0.049949f
C4090 VDDD.n401 VSSD 1.34049f
C4091 VDDD.t282 VSSD 0.049949f
C4092 VDDD.n402 VSSD 0.98744f
C4093 VDDD.n403 VSSD 1.22687f
C4094 VDDD.n404 VSSD 0.594276f
C4095 VDDD.n407 VSSD 0.047851f
C4096 VDDD.n409 VSSD 0.047851f
C4097 VDDD.n411 VSSD 0.047851f
C4098 VDDD.n412 VSSD 0.12071f
C4099 VDDD.n413 VSSD 0.081038f
C4100 VDDD.n414 VSSD 1.37418f
C4101 VDDD.n417 VSSD 0.147985f
C4102 VDDD.n419 VSSD 0.147985f
C4103 VDDD.n421 VSSD 0.147985f
C4104 VDDD.n422 VSSD 0.130384f
C4105 VDDD.n423 VSSD 7.02e-19
C4106 VDDD.n424 VSSD 0.045634f
C4107 VDDD.n425 VSSD 0.135431f
C4108 VDDD.n426 VSSD 0.091269f
C4109 VDDD.n427 VSSD 0.091269f
C4110 VDDD.n429 VSSD 0.091269f
C4111 VDDD.n432 VSSD 0.045634f
C4112 VDDD.n433 VSSD 0.045634f
C4113 VDDD.n434 VSSD 0.045634f
C4114 VDDD.n436 VSSD 1.33811f
C4115 VDDD.n438 VSSD 0.045634f
C4116 VDDD.n441 VSSD 0.045634f
C4117 VDDD.n444 VSSD 0.045634f
C4118 VDDD.n445 VSSD 0.014342f
C4119 VDDD.n446 VSSD 0.045596f
C4120 VDDD.n447 VSSD 0.045634f
C4121 VDDD.n448 VSSD 0.045634f
C4122 VDDD.n449 VSSD 0.010757f
C4123 VDDD.n450 VSSD 0.010757f
C4124 VDDD.n451 VSSD 0.130384f
C4125 VDDD.n452 VSSD 0.045634f
C4126 VDDD.n455 VSSD 0.056675f
C4127 VDDD.n456 VSSD 0.056873f
C4128 VDDD.n458 VSSD 0.045634f
C4129 VDDD.n459 VSSD 0.029743f
C4130 VDDD.n460 VSSD 1.24061f
C4131 VDDD.n461 VSSD 0.038149f
C4132 VDDD.n462 VSSD 0.038149f
C4133 VDDD.t448 VSSD 0.154524f
C4134 VDDD.n463 VSSD 0.038149f
C4135 VDDD.n464 VSSD 0.388226f
C4136 VDDD.n465 VSSD 0.249067f
C4137 VDDD.n466 VSSD 0.246436f
C4138 VDDD.t449 VSSD 0.035134f
C4139 VDDD.n467 VSSD 0.055592f
C4140 VDDD.t50 VSSD 0.035134f
C4141 VDDD.n468 VSSD 0.073685f
C4142 VDDD.t208 VSSD 0.035134f
C4143 VDDD.n469 VSSD 0.077851f
C4144 VDDD.t203 VSSD 0.035134f
C4145 VDDD.n470 VSSD 0.077772f
C4146 VDDD.t436 VSSD 0.035134f
C4147 VDDD.n471 VSSD 0.064631f
C4148 VDDD.n473 VSSD 0.091269f
C4149 VDDD.n474 VSSD 0.091269f
C4150 VDDD.n475 VSSD 0.091269f
C4151 VDDD.n477 VSSD 0.147985f
C4152 VDDD.n478 VSSD 0.147985f
C4153 VDDD.n479 VSSD 0.147985f
C4154 VDDD.n481 VSSD 0.147985f
C4155 VDDD.n482 VSSD 0.147985f
C4156 VDDD.n488 VSSD 0.091269f
C4157 VDDD.n489 VSSD 0.091269f
C4158 VDDD.n490 VSSD 0.047851f
C4159 VDDD.n492 VSSD 0.091269f
C4160 VDDD.n494 VSSD 0.047851f
C4161 VDDD.n495 VSSD 0.047851f
C4162 VDDD.n496 VSSD 0.047851f
C4163 VDDD.n497 VSSD 0.047851f
C4164 VDDD.t201 VSSD 0.035134f
C4165 VDDD.n499 VSSD 0.066479f
C4166 VDDD.n500 VSSD 0.046547f
C4167 VDDD.n501 VSSD 0.056675f
C4168 VDDD.n502 VSSD 0.045634f
C4169 VDDD.n503 VSSD 0.045634f
C4170 VDDD.n504 VSSD 0.045634f
C4171 VDDD.n505 VSSD 0.046547f
C4172 VDDD.n506 VSSD 0.045634f
C4173 VDDD.n507 VSSD 0.045634f
C4174 VDDD.n508 VSSD 0.045634f
C4175 VDDD.n509 VSSD 0.045634f
C4176 VDDD.n510 VSSD 0.05721f
C4177 VDDD.n512 VSSD 0.131014f
C4178 VDDD.n515 VSSD 0.091269f
C4179 VDDD.n516 VSSD 0.045634f
C4180 VDDD.n522 VSSD 0.045634f
C4181 VDDD.n526 VSSD 0.091269f
C4182 VDDD.n528 VSSD 0.091269f
C4183 VDDD.n530 VSSD 0.045634f
C4184 VDDD.n531 VSSD 0.045634f
C4185 VDDD.n532 VSSD 0.059859f
C4186 VDDD.n533 VSSD 0.132516f
C4187 VDDD.n534 VSSD 0.046547f
C4188 VDDD.n535 VSSD 0.045634f
C4189 VDDD.n536 VSSD 0.045634f
C4190 VDDD.n537 VSSD 0.045634f
C4191 VDDD.n538 VSSD 0.046547f
C4192 VDDD.n539 VSSD 0.046547f
C4193 VDDD.n540 VSSD 0.046547f
C4194 VDDD.n541 VSSD 0.045634f
C4195 VDDD.n542 VSSD 0.045634f
C4196 VDDD.n543 VSSD 0.056675f
C4197 VDDD.n544 VSSD 1.16338f
C4198 VDDD.n545 VSSD 1.1952f
C4199 VDDD.t33 VSSD 0.035134f
C4200 VDDD.t200 VSSD 0.202843f
C4201 VDDD.n546 VSSD 0.227224f
C4202 VDDD.t99 VSSD 0.780046f
C4203 VDDD.t218 VSSD 0.705018f
C4204 VDDD.t316 VSSD 0.64666f
C4205 VDDD.t108 VSSD 0.64666f
C4206 VDDD.t579 VSSD 0.686091f
C4207 VDDD.t34 VSSD 1.02519f
C4208 VDDD.t35 VSSD 1.11983f
C4209 VDDD.t525 VSSD 0.780724f
C4210 VDDD.t432 VSSD 0.641929f
C4211 VDDD.t359 VSSD 0.641929f
C4212 VDDD.t396 VSSD 0.630888f
C4213 VDDD.t394 VSSD 0.876897f
C4214 VDDD.t32 VSSD 0.57622f
C4215 VDDD.t434 VSSD 1.32373f
C4216 VDDD.t466 VSSD 0.035134f
C4217 VDDD.n547 VSSD 0.064631f
C4218 VDDD.n548 VSSD 1.01482f
C4219 VDDD.t465 VSSD 0.315139f
C4220 VDDD.n549 VSSD 0.285204f
C4221 VDDD.n550 VSSD 0.064631f
C4222 VDDD.n551 VSSD 0.660804f
C4223 VDDD.t397 VSSD 0.049949f
C4224 VDDD.n552 VSSD 0.86f
C4225 VDDD.t433 VSSD 0.049949f
C4226 VDDD.n553 VSSD 1.32347f
C4227 VDDD.t580 VSSD 0.049949f
C4228 VDDD.n554 VSSD 1.34049f
C4229 VDDD.t317 VSSD 0.049949f
C4230 VDDD.n555 VSSD 0.98744f
C4231 VDDD.n556 VSSD 1.22687f
C4232 VDDD.n557 VSSD 0.594276f
C4233 VDDD.n560 VSSD 0.047851f
C4234 VDDD.n562 VSSD 0.047851f
C4235 VDDD.n564 VSSD 0.047851f
C4236 VDDD.n565 VSSD 0.12071f
C4237 VDDD.n566 VSSD 0.081038f
C4238 VDDD.n567 VSSD 1.37418f
C4239 VDDD.n570 VSSD 0.147985f
C4240 VDDD.n572 VSSD 0.147985f
C4241 VDDD.n574 VSSD 0.147985f
C4242 VDDD.n575 VSSD 0.130384f
C4243 VDDD.n576 VSSD 7.02e-19
C4244 VDDD.n577 VSSD 0.045634f
C4245 VDDD.n578 VSSD 0.135431f
C4246 VDDD.n579 VSSD 0.091269f
C4247 VDDD.n580 VSSD 0.091269f
C4248 VDDD.n582 VSSD 0.091269f
C4249 VDDD.n585 VSSD 0.045634f
C4250 VDDD.n586 VSSD 0.045634f
C4251 VDDD.n587 VSSD 0.045634f
C4252 VDDD.n589 VSSD 1.33811f
C4253 VDDD.n591 VSSD 0.045634f
C4254 VDDD.n594 VSSD 0.045634f
C4255 VDDD.n597 VSSD 0.045634f
C4256 VDDD.n598 VSSD 0.014342f
C4257 VDDD.n599 VSSD 0.045596f
C4258 VDDD.n600 VSSD 0.045634f
C4259 VDDD.n601 VSSD 0.045634f
C4260 VDDD.n602 VSSD 0.010757f
C4261 VDDD.n603 VSSD 0.010757f
C4262 VDDD.n604 VSSD 0.130384f
C4263 VDDD.n605 VSSD 0.045634f
C4264 VDDD.n608 VSSD 0.056675f
C4265 VDDD.n609 VSSD 0.056873f
C4266 VDDD.n611 VSSD 0.045634f
C4267 VDDD.n612 VSSD 0.029743f
C4268 VDDD.n613 VSSD 1.24061f
C4269 VDDD.n614 VSSD 0.038149f
C4270 VDDD.n615 VSSD 0.038149f
C4271 VDDD.t409 VSSD 0.154524f
C4272 VDDD.n616 VSSD 0.038149f
C4273 VDDD.n617 VSSD 0.388226f
C4274 VDDD.n618 VSSD 0.249067f
C4275 VDDD.n619 VSSD 0.246436f
C4276 VDDD.t410 VSSD 0.035134f
C4277 VDDD.n620 VSSD 0.055592f
C4278 VDDD.t389 VSSD 0.035134f
C4279 VDDD.n621 VSSD 0.073685f
C4280 VDDD.t407 VSSD 0.035134f
C4281 VDDD.n622 VSSD 0.077851f
C4282 VDDD.t187 VSSD 0.035134f
C4283 VDDD.n623 VSSD 0.077772f
C4284 VDDD.t16 VSSD 0.035134f
C4285 VDDD.n624 VSSD 0.064631f
C4286 VDDD.n626 VSSD 0.091269f
C4287 VDDD.n627 VSSD 0.091269f
C4288 VDDD.n628 VSSD 0.091269f
C4289 VDDD.n630 VSSD 0.147985f
C4290 VDDD.n631 VSSD 0.147985f
C4291 VDDD.n632 VSSD 0.147985f
C4292 VDDD.n634 VSSD 0.147985f
C4293 VDDD.n635 VSSD 0.147985f
C4294 VDDD.n641 VSSD 0.091269f
C4295 VDDD.n642 VSSD 0.091269f
C4296 VDDD.n643 VSSD 0.047851f
C4297 VDDD.n645 VSSD 0.091269f
C4298 VDDD.n647 VSSD 0.047851f
C4299 VDDD.n648 VSSD 0.047851f
C4300 VDDD.n649 VSSD 0.047851f
C4301 VDDD.n650 VSSD 0.047851f
C4302 VDDD.t552 VSSD 0.035134f
C4303 VDDD.n652 VSSD 0.066479f
C4304 VDDD.n653 VSSD 0.046547f
C4305 VDDD.n654 VSSD 0.056675f
C4306 VDDD.n655 VSSD 0.045634f
C4307 VDDD.n656 VSSD 0.045634f
C4308 VDDD.n657 VSSD 0.045634f
C4309 VDDD.n658 VSSD 0.046547f
C4310 VDDD.n659 VSSD 0.045634f
C4311 VDDD.n660 VSSD 0.045634f
C4312 VDDD.n661 VSSD 0.045634f
C4313 VDDD.n662 VSSD 0.045634f
C4314 VDDD.n663 VSSD 0.05721f
C4315 VDDD.n665 VSSD 0.131014f
C4316 VDDD.n668 VSSD 0.091269f
C4317 VDDD.n669 VSSD 0.045634f
C4318 VDDD.n675 VSSD 0.045634f
C4319 VDDD.n679 VSSD 0.091269f
C4320 VDDD.n681 VSSD 0.091269f
C4321 VDDD.n683 VSSD 0.045634f
C4322 VDDD.n684 VSSD 0.045634f
C4323 VDDD.n685 VSSD 0.059859f
C4324 VDDD.n686 VSSD 0.132516f
C4325 VDDD.n687 VSSD 0.046547f
C4326 VDDD.n688 VSSD 0.045634f
C4327 VDDD.n689 VSSD 0.045634f
C4328 VDDD.n690 VSSD 0.045634f
C4329 VDDD.n691 VSSD 0.046547f
C4330 VDDD.n692 VSSD 0.046547f
C4331 VDDD.n693 VSSD 0.046547f
C4332 VDDD.n694 VSSD 0.045634f
C4333 VDDD.n695 VSSD 0.045634f
C4334 VDDD.n696 VSSD 0.056675f
C4335 VDDD.n697 VSSD 1.16338f
C4336 VDDD.n698 VSSD 1.1952f
C4337 VDDD.t546 VSSD 0.035134f
C4338 VDDD.t551 VSSD 0.202843f
C4339 VDDD.n699 VSSD 0.227224f
C4340 VDDD.t447 VSSD 0.780046f
C4341 VDDD.t56 VSSD 0.705018f
C4342 VDDD.t553 VSSD 0.64666f
C4343 VDDD.t375 VSSD 0.64666f
C4344 VDDD.t427 VSSD 0.686091f
C4345 VDDD.t548 VSSD 1.02519f
C4346 VDDD.t547 VSSD 1.11983f
C4347 VDDD.t543 VSSD 0.780724f
C4348 VDDD.t451 VSSD 0.641929f
C4349 VDDD.t341 VSSD 0.641929f
C4350 VDDD.t568 VSSD 0.630888f
C4351 VDDD.t485 VSSD 0.876897f
C4352 VDDD.t545 VSSD 0.57622f
C4353 VDDD.t21 VSSD 1.32373f
C4354 VDDD.t470 VSSD 0.035134f
C4355 VDDD.n700 VSSD 0.064631f
C4356 VDDD.n701 VSSD 1.01482f
C4357 VDDD.t469 VSSD 0.315139f
C4358 VDDD.n702 VSSD 0.285204f
C4359 VDDD.n703 VSSD 0.064631f
C4360 VDDD.n704 VSSD 0.660804f
C4361 VDDD.t569 VSSD 0.049949f
C4362 VDDD.n705 VSSD 0.86f
C4363 VDDD.t452 VSSD 0.049949f
C4364 VDDD.n706 VSSD 1.32347f
C4365 VDDD.t428 VSSD 0.049949f
C4366 VDDD.n707 VSSD 1.34049f
C4367 VDDD.t554 VSSD 0.049949f
C4368 VDDD.n708 VSSD 0.98744f
C4369 VDDD.n709 VSSD 1.22687f
C4370 VDDD.n710 VSSD 0.594276f
C4371 VDDD.n713 VSSD 0.047851f
C4372 VDDD.n715 VSSD 0.047851f
C4373 VDDD.n717 VSSD 0.047851f
C4374 VDDD.n718 VSSD 0.12071f
C4375 VDDD.n719 VSSD 0.081038f
C4376 VDDD.n720 VSSD 1.37418f
C4377 VDDD.n723 VSSD 0.147985f
C4378 VDDD.n725 VSSD 0.147985f
C4379 VDDD.n727 VSSD 0.147985f
C4380 VDDD.n728 VSSD 0.130384f
C4381 VDDD.n729 VSSD 7.02e-19
C4382 VDDD.n730 VSSD 0.045634f
C4383 VDDD.n731 VSSD 0.135431f
C4384 VDDD.n732 VSSD 0.091269f
C4385 VDDD.n733 VSSD 0.091269f
C4386 VDDD.n735 VSSD 0.091269f
C4387 VDDD.n738 VSSD 0.045634f
C4388 VDDD.n739 VSSD 0.045634f
C4389 VDDD.n740 VSSD 0.045634f
C4390 VDDD.n742 VSSD 1.33811f
C4391 VDDD.n744 VSSD 0.045634f
C4392 VDDD.n747 VSSD 0.045634f
C4393 VDDD.n750 VSSD 0.045634f
C4394 VDDD.n751 VSSD 0.014342f
C4395 VDDD.n752 VSSD 0.045596f
C4396 VDDD.n753 VSSD 0.045634f
C4397 VDDD.n754 VSSD 0.045634f
C4398 VDDD.n755 VSSD 0.010757f
C4399 VDDD.n756 VSSD 0.010757f
C4400 VDDD.n757 VSSD 0.130384f
C4401 VDDD.n758 VSSD 0.045634f
C4402 VDDD.n761 VSSD 0.056675f
C4403 VDDD.n762 VSSD 0.056873f
C4404 VDDD.n764 VSSD 0.045634f
C4405 VDDD.n765 VSSD 0.029743f
C4406 VDDD.n766 VSSD 1.24061f
C4407 VDDD.n767 VSSD 0.038149f
C4408 VDDD.n768 VSSD 0.038149f
C4409 VDDD.t444 VSSD 0.154524f
C4410 VDDD.n769 VSSD 0.038149f
C4411 VDDD.n770 VSSD 0.388226f
C4412 VDDD.n771 VSSD 0.249067f
C4413 VDDD.n772 VSSD 0.246436f
C4414 VDDD.t445 VSSD 0.035134f
C4415 VDDD.n773 VSSD 0.055592f
C4416 VDDD.t168 VSSD 0.035134f
C4417 VDDD.n774 VSSD 0.073685f
C4418 VDDD.t443 VSSD 0.035134f
C4419 VDDD.n775 VSSD 0.077851f
C4420 VDDD.t331 VSSD 0.035134f
C4421 VDDD.n776 VSSD 0.077772f
C4422 VDDD.t145 VSSD 0.035134f
C4423 VDDD.n777 VSSD 0.064631f
C4424 VDDD.n779 VSSD 0.091269f
C4425 VDDD.n780 VSSD 0.147207f
C4426 VDDD.n781 VSSD 0.091269f
C4427 VDDD.n783 VSSD 0.147985f
C4428 VDDD.n784 VSSD 0.147985f
C4429 VDDD.n785 VSSD 0.147985f
C4430 VDDD.n791 VSSD 0.091269f
C4431 VDDD.n792 VSSD 0.091269f
C4432 VDDD.n793 VSSD 0.047851f
C4433 VDDD.n795 VSSD 0.091269f
C4434 VDDD.n797 VSSD 0.047851f
C4435 VDDD.n798 VSSD 0.047851f
C4436 VDDD.n799 VSSD 0.047851f
C4437 VDDD.n800 VSSD 0.047851f
C4438 VDDD.t11 VSSD 0.035134f
C4439 VDDD.n802 VSSD 0.066479f
C4440 VDDD.n803 VSSD 0.046547f
C4441 VDDD.n804 VSSD 0.056675f
C4442 VDDD.n805 VSSD 0.045634f
C4443 VDDD.n806 VSSD 0.045634f
C4444 VDDD.n807 VSSD 0.045634f
C4445 VDDD.n808 VSSD 0.046547f
C4446 VDDD.n809 VSSD 0.045634f
C4447 VDDD.n810 VSSD 0.045634f
C4448 VDDD.n811 VSSD 0.045634f
C4449 VDDD.n812 VSSD 0.045634f
C4450 VDDD.n813 VSSD 0.05721f
C4451 VDDD.n815 VSSD 0.131014f
C4452 VDDD.n818 VSSD 0.091269f
C4453 VDDD.n819 VSSD 0.045634f
C4454 VDDD.n825 VSSD 0.045634f
C4455 VDDD.n829 VSSD 0.091269f
C4456 VDDD.n831 VSSD 0.091269f
C4457 VDDD.n833 VSSD 0.045634f
C4458 VDDD.n834 VSSD 0.045634f
C4459 VDDD.n835 VSSD 0.059859f
C4460 VDDD.n836 VSSD 0.132516f
C4461 VDDD.n837 VSSD 0.046547f
C4462 VDDD.n838 VSSD 0.045634f
C4463 VDDD.n839 VSSD 0.045634f
C4464 VDDD.n840 VSSD 0.045634f
C4465 VDDD.n841 VSSD 0.046547f
C4466 VDDD.n842 VSSD 0.046547f
C4467 VDDD.n843 VSSD 0.046547f
C4468 VDDD.n844 VSSD 0.045634f
C4469 VDDD.n845 VSSD 0.045634f
C4470 VDDD.n846 VSSD 0.056675f
C4471 VDDD.n847 VSSD 1.16338f
C4472 VDDD.n848 VSSD 1.1952f
C4473 VDDD.t227 VSSD 0.035134f
C4474 VDDD.t10 VSSD 0.202843f
C4475 VDDD.n849 VSSD 0.236569f
C4476 VDDD.t244 VSSD 0.770701f
C4477 VDDD.t500 VSSD 0.705018f
C4478 VDDD.t8 VSSD 0.64666f
C4479 VDDD.t563 VSSD 0.64666f
C4480 VDDD.t421 VSSD 0.686091f
C4481 VDDD.t225 VSSD 1.02519f
C4482 VDDD.t228 VSSD 1.11983f
C4483 VDDD.t149 VSSD 0.780724f
C4484 VDDD.t83 VSSD 0.641929f
C4485 VDDD.t383 VSSD 0.641929f
C4486 VDDD.t505 VSSD 0.630888f
C4487 VDDD.t245 VSSD 0.87619f
C4488 VDDD.t226 VSSD 0.601391f
C4489 VDDD.t165 VSSD 1.35593f
C4490 VDDD.t476 VSSD 0.035134f
C4491 VDDD.n850 VSSD 0.064631f
C4492 VDDD.n851 VSSD 1.03422f
C4493 VDDD.t475 VSSD 0.329366f
C4494 VDDD.n852 VSSD 0.29943f
C4495 VDDD.n853 VSSD 0.064631f
C4496 VDDD.n854 VSSD 0.660804f
C4497 VDDD.t506 VSSD 0.049949f
C4498 VDDD.n855 VSSD 0.86f
C4499 VDDD.t84 VSSD 0.049949f
C4500 VDDD.n856 VSSD 1.32347f
C4501 VDDD.t422 VSSD 0.049949f
C4502 VDDD.n857 VSSD 1.34049f
C4503 VDDD.t9 VSSD 0.049949f
C4504 VDDD.n858 VSSD 0.98744f
C4505 VDDD.n859 VSSD 1.22687f
C4506 VDDD.n860 VSSD 0.594276f
C4507 VDDD.n863 VSSD 0.047851f
C4508 VDDD.n865 VSSD 0.047851f
C4509 VDDD.n867 VSSD 0.047851f
C4510 VDDD.n868 VSSD 0.12071f
C4511 VDDD.n869 VSSD 0.081038f
C4512 VDDD.n870 VSSD 1.37418f
C4513 VDDD.n873 VSSD 0.147985f
C4514 VDDD.n876 VSSD 0.147985f
C4515 VDDD.n879 VSSD 0.147985f
C4516 VDDD.n881 VSSD 0.147985f
C4517 VDDD.n882 VSSD 0.130384f
C4518 VDDD.n883 VSSD 0.117345f
C4519 VDDD.n886 VSSD 0.117345f
C4520 VDDD.n887 VSSD 0.117345f
C4521 VDDD.n888 VSSD 0.117345f
C4522 VDDD.n889 VSSD 0.117345f
C4523 VDDD.n890 VSSD 0.117345f
C4524 VDDD.n891 VSSD 0.117345f
C4525 VDDD.n892 VSSD 0.117345f
C4526 VDDD.n893 VSSD 0.117345f
C4527 VDDD.n894 VSSD 0.117345f
C4528 VDDD.n895 VSSD 0.117345f
C4529 VDDD.n896 VSSD 0.117345f
C4530 VDDD.n897 VSSD 0.117345f
C4531 VDDD.n898 VSSD 0.117345f
C4532 VDDD.n900 VSSD 0.117345f
C4533 VDDD.n901 VSSD 0.117345f
C4534 VDDD.n902 VSSD 0.117345f
C4535 VDDD.n903 VSSD 0.117345f
C4536 VDDD.n904 VSSD 0.117345f
C4537 VDDD.n905 VSSD 0.117345f
C4538 VDDD.n906 VSSD 0.117345f
C4539 VDDD.n907 VSSD 0.117345f
C4540 VDDD.n908 VSSD 0.117345f
C4541 VDDD.n909 VSSD 0.117345f
C4542 VDDD.n910 VSSD 0.117345f
C4543 VDDD.n911 VSSD 0.119238f
C4544 VDDD.n919 VSSD 0.117345f
C4545 VDDD.n920 VSSD 0.119238f
C4546 VDDD.n921 VSSD 0.130384f
C4547 VDDD.n922 VSSD 0.117345f
C4548 VDDD.n924 VSSD 0.542564f
C4549 VDDD.n925 VSSD 0.260767f
C4550 VDDD.n926 VSSD 0.260767f
C4551 VDDD.n927 VSSD 0.260767f
C4552 VDDD.n928 VSSD 0.260767f
C4553 VDDD.n930 VSSD 0.260767f
C4554 VDDD.n931 VSSD 0.260767f
C4555 VDDD.n932 VSSD 0.260767f
C4556 VDDD.n933 VSSD 0.260767f
C4557 VDDD.n934 VSSD 0.117345f
C4558 VDDD.n940 VSSD 0.260767f
C4559 VDDD.n952 VSSD 0.260767f
C4560 VDDD.n954 VSSD 0.117345f
C4561 VDDD.n955 VSSD 0.130384f
C4562 VDDD.n956 VSSD 0.117345f
C4563 VDDD.n957 VSSD 0.130384f
C4564 VDDD.n958 VSSD 0.117345f
C4565 VDDD.n959 VSSD 0.130384f
C4566 VDDD.n960 VSSD 0.117345f
C4567 VDDD.n961 VSSD 0.130384f
C4568 VDDD.n962 VSSD 0.117345f
C4569 VDDD.n963 VSSD 0.130384f
C4570 VDDD.n964 VSSD 0.117345f
C4571 VDDD.n965 VSSD 0.130384f
C4572 VDDD.n966 VSSD 0.117345f
C4573 VDDD.n967 VSSD 0.117345f
C4574 VDDD.n968 VSSD 0.130384f
C4575 VDDD.n969 VSSD 0.130384f
C4576 VDDD.n970 VSSD 0.130384f
C4577 VDDD.n971 VSSD 0.117345f
C4578 VDDD.n972 VSSD 0.117345f
C4579 VDDD.n973 VSSD 0.117345f
C4580 VDDD.n974 VSSD 0.130384f
C4581 VDDD.n975 VSSD 0.130384f
C4582 VDDD.n976 VSSD 0.130384f
C4583 VDDD.n977 VSSD 0.117345f
C4584 VDDD.n978 VSSD 0.117345f
C4585 VDDD.n979 VSSD 0.117345f
C4586 VDDD.n980 VSSD 0.130384f
C4587 VDDD.n981 VSSD 0.130384f
C4588 VDDD.n982 VSSD 0.130384f
C4589 VDDD.n983 VSSD 0.117345f
C4590 VDDD.n984 VSSD 0.117345f
C4591 VDDD.n985 VSSD 0.117345f
C4592 VDDD.n986 VSSD 0.130384f
C4593 VDDD.n987 VSSD 0.130384f
C4594 VDDD.n988 VSSD 0.130384f
C4595 VDDD.n989 VSSD 0.117345f
C4596 VDDD.n990 VSSD 0.117345f
C4597 VDDD.n991 VSSD 0.117345f
C4598 VDDD.n992 VSSD 0.130384f
C4599 VDDD.n993 VSSD 0.130384f
C4600 VDDD.n994 VSSD 0.130384f
C4601 VDDD.n995 VSSD 0.117345f
C4602 VDDD.n996 VSSD 0.117345f
C4603 VDDD.n997 VSSD 0.117345f
C4604 VDDD.n998 VSSD 0.582052f
C4605 VDDD.n999 VSSD 0.139351f
C4606 VDDD.n1011 VSSD 0.260767f
C4607 VDDD.n1012 VSSD 0.120622f
C4608 VDDD.n1014 VSSD 0.260767f
C4609 VDDD.n1015 VSSD 0.117345f
C4610 VDDD.n1016 VSSD 0.117345f
C4611 VDDD.n1017 VSSD 0.130384f
C4612 VDDD.n1018 VSSD 0.130384f
C4613 VDDD.n1019 VSSD 0.130384f
C4614 VDDD.n1020 VSSD 0.056675f
C4615 VDDD.n1021 VSSD 0.045634f
C4616 VDDD.n1022 VSSD 0.014342f
C4617 VDDD.n1023 VSSD 0.045634f
C4618 VDDD.n1024 VSSD 0.045634f
C4619 VDDD.n1025 VSSD 0.072363f
C4620 VDDD.n1026 VSSD 0.045634f
C4621 VDDD.n1027 VSSD 0.045634f
C4622 VDDD.n1028 VSSD 0.045634f
C4623 VDDD.n1029 VSSD 0.010757f
C4624 VDDD.n1030 VSSD 0.130384f
C4625 VDDD.n1031 VSSD 0.045634f
C4626 VDDD.n1032 VSSD 0.045634f
C4627 VDDD.n1033 VSSD 0.014342f
C4628 VDDD.n1034 VSSD 1.37223f
C4629 VDDD.n1036 VSSD 0.045634f
C4630 VDDD.n1037 VSSD 0.045634f
C4631 VDDD.n1038 VSSD 0.045634f
C4632 VDDD.n1040 VSSD 0.045634f
C4633 VDDD.n1041 VSSD 0.045634f
C4634 VDDD.n1042 VSSD 0.045634f
C4635 VDDD.n1043 VSSD 0.045634f
C4636 VDDD.n1046 VSSD 0.091269f
C4637 VDDD.n1047 VSSD 0.056675f
C4638 VDDD.n1051 VSSD 0.091269f
C4639 VDDD.n1053 VSSD 0.091269f
C4640 VDDD.n1056 VSSD 0.045634f
C4641 VDDD.n1058 VSSD 0.045634f
C4642 VDDD.n1059 VSSD 0.046547f
C4643 VDDD.n1060 VSSD 0.046547f
C4644 VDDD.n1061 VSSD 0.046547f
C4645 VDDD.n1062 VSSD 0.046547f
C4646 VDDD.n1063 VSSD 0.046547f
C4647 VDDD.t480 VSSD 0.035134f
C4648 VDDD.n1064 VSSD 0.064631f
C4649 VDDD.t271 VSSD 0.035134f
C4650 VDDD.n1065 VSSD 0.064631f
C4651 VDDD.t600 VSSD 0.049949f
C4652 VDDD.n1066 VSSD 0.091269f
C4653 VDDD.n1067 VSSD 0.091269f
C4654 VDDD.n1069 VSSD 0.091269f
C4655 VDDD.n1072 VSSD 0.047851f
C4656 VDDD.n1073 VSSD 0.047851f
C4657 VDDD.n1074 VSSD 0.047851f
C4658 VDDD.n1075 VSSD 0.081038f
C4659 VDDD.n1078 VSSD 0.047851f
C4660 VDDD.n1080 VSSD 0.047851f
C4661 VDDD.n1082 VSSD 0.047851f
C4662 VDDD.n1084 VSSD 0.047851f
C4663 VDDD.n1086 VSSD 0.147985f
C4664 VDDD.n1087 VSSD 0.147985f
C4665 VDDD.n1088 VSSD 0.147985f
C4666 VDDD.n1089 VSSD 0.147985f
C4667 VDDD.n1091 VSSD 0.147985f
C4668 VDDD.n1092 VSSD 0.147985f
C4669 VDDD.n1094 VSSD 0.091269f
C4670 VDDD.n1100 VSSD 0.091269f
C4671 VDDD.n1101 VSSD 0.130384f
C4672 VDDD.n1102 VSSD 0.056675f
C4673 VDDD.n1103 VSSD 0.045634f
C4674 VDDD.n1104 VSSD 0.014342f
C4675 VDDD.n1105 VSSD 0.045634f
C4676 VDDD.n1106 VSSD 0.045634f
C4677 VDDD.n1107 VSSD 0.072363f
C4678 VDDD.n1108 VSSD 0.045634f
C4679 VDDD.n1109 VSSD 0.045634f
C4680 VDDD.n1110 VSSD 0.045634f
C4681 VDDD.n1111 VSSD 0.010757f
C4682 VDDD.n1112 VSSD 0.130384f
C4683 VDDD.n1113 VSSD 0.045634f
C4684 VDDD.n1114 VSSD 0.045634f
C4685 VDDD.n1115 VSSD 0.014342f
C4686 VDDD.n1116 VSSD 1.37223f
C4687 VDDD.n1118 VSSD 0.045634f
C4688 VDDD.n1119 VSSD 0.045634f
C4689 VDDD.n1120 VSSD 0.045634f
C4690 VDDD.n1122 VSSD 0.045634f
C4691 VDDD.n1123 VSSD 0.045634f
C4692 VDDD.n1124 VSSD 0.045634f
C4693 VDDD.n1125 VSSD 0.045634f
C4694 VDDD.n1128 VSSD 0.091269f
C4695 VDDD.n1129 VSSD 0.056675f
C4696 VDDD.n1133 VSSD 0.091269f
C4697 VDDD.n1135 VSSD 0.091269f
C4698 VDDD.n1138 VSSD 0.045634f
C4699 VDDD.n1140 VSSD 0.045634f
C4700 VDDD.n1141 VSSD 0.046547f
C4701 VDDD.n1142 VSSD 0.046547f
C4702 VDDD.n1143 VSSD 0.046547f
C4703 VDDD.n1144 VSSD 0.046547f
C4704 VDDD.n1145 VSSD 0.046547f
C4705 VDDD.t478 VSSD 0.035134f
C4706 VDDD.n1146 VSSD 0.064631f
C4707 VDDD.t98 VSSD 0.035134f
C4708 VDDD.n1147 VSSD 0.064631f
C4709 VDDD.t527 VSSD 0.049949f
C4710 VDDD.n1148 VSSD 0.091269f
C4711 VDDD.n1149 VSSD 0.091269f
C4712 VDDD.n1151 VSSD 0.091269f
C4713 VDDD.n1154 VSSD 0.047851f
C4714 VDDD.n1155 VSSD 0.047851f
C4715 VDDD.n1156 VSSD 0.047851f
C4716 VDDD.n1157 VSSD 0.081038f
C4717 VDDD.n1160 VSSD 0.047851f
C4718 VDDD.n1162 VSSD 0.047851f
C4719 VDDD.n1164 VSSD 0.047851f
C4720 VDDD.n1166 VSSD 0.047851f
C4721 VDDD.n1168 VSSD 0.147985f
C4722 VDDD.n1169 VSSD 0.147985f
C4723 VDDD.n1170 VSSD 0.147985f
C4724 VDDD.n1172 VSSD 0.130384f
C4725 VDDD.n1173 VSSD 0.056675f
C4726 VDDD.n1174 VSSD 0.045634f
C4727 VDDD.n1175 VSSD 0.014342f
C4728 VDDD.n1176 VSSD 0.045634f
C4729 VDDD.n1177 VSSD 0.045634f
C4730 VDDD.n1178 VSSD 0.072363f
C4731 VDDD.n1179 VSSD 0.045634f
C4732 VDDD.n1180 VSSD 0.045634f
C4733 VDDD.n1181 VSSD 0.045634f
C4734 VDDD.n1182 VSSD 0.010757f
C4735 VDDD.n1183 VSSD 0.130384f
C4736 VDDD.n1184 VSSD 0.045634f
C4737 VDDD.n1185 VSSD 0.045634f
C4738 VDDD.n1186 VSSD 0.014342f
C4739 VDDD.n1187 VSSD 1.37223f
C4740 VDDD.n1189 VSSD 0.045634f
C4741 VDDD.n1190 VSSD 0.045634f
C4742 VDDD.n1191 VSSD 0.045634f
C4743 VDDD.n1193 VSSD 0.045634f
C4744 VDDD.n1194 VSSD 0.045634f
C4745 VDDD.n1195 VSSD 0.045634f
C4746 VDDD.n1196 VSSD 0.045634f
C4747 VDDD.n1199 VSSD 0.091269f
C4748 VDDD.n1200 VSSD 0.056675f
C4749 VDDD.n1204 VSSD 0.091269f
C4750 VDDD.n1206 VSSD 0.091269f
C4751 VDDD.n1209 VSSD 0.045634f
C4752 VDDD.n1211 VSSD 0.045634f
C4753 VDDD.n1212 VSSD 0.046547f
C4754 VDDD.n1213 VSSD 0.046547f
C4755 VDDD.n1214 VSSD 0.046547f
C4756 VDDD.n1215 VSSD 0.046547f
C4757 VDDD.n1216 VSSD 0.046547f
C4758 VDDD.t482 VSSD 0.035134f
C4759 VDDD.n1217 VSSD 0.064631f
C4760 VDDD.t393 VSSD 0.035134f
C4761 VDDD.n1218 VSSD 0.064631f
C4762 VDDD.t603 VSSD 0.049949f
C4763 VDDD.n1219 VSSD 0.091269f
C4764 VDDD.n1220 VSSD 0.091269f
C4765 VDDD.n1222 VSSD 0.091269f
C4766 VDDD.n1225 VSSD 0.047851f
C4767 VDDD.n1226 VSSD 0.047851f
C4768 VDDD.n1227 VSSD 0.047851f
C4769 VDDD.n1228 VSSD 0.081038f
C4770 VDDD.n1231 VSSD 0.047851f
C4771 VDDD.n1233 VSSD 0.047851f
C4772 VDDD.n1235 VSSD 0.047851f
C4773 VDDD.n1237 VSSD 0.047851f
C4774 VDDD.n1239 VSSD 0.147985f
C4775 VDDD.n1240 VSSD 0.147985f
C4776 VDDD.n1241 VSSD 0.147985f
C4777 VDDD.n1243 VSSD 0.130384f
C4778 VDDD.n1244 VSSD 0.056675f
C4779 VDDD.n1245 VSSD 0.045634f
C4780 VDDD.n1246 VSSD 0.014342f
C4781 VDDD.n1247 VSSD 0.045634f
C4782 VDDD.n1248 VSSD 0.045634f
C4783 VDDD.n1249 VSSD 0.072363f
C4784 VDDD.n1250 VSSD 0.045634f
C4785 VDDD.n1251 VSSD 0.045634f
C4786 VDDD.n1252 VSSD 0.045634f
C4787 VDDD.n1253 VSSD 0.010757f
C4788 VDDD.n1254 VSSD 0.130384f
C4789 VDDD.n1255 VSSD 0.045634f
C4790 VDDD.n1256 VSSD 0.045634f
C4791 VDDD.n1257 VSSD 0.014342f
C4792 VDDD.n1258 VSSD 1.37223f
C4793 VDDD.n1260 VSSD 0.045634f
C4794 VDDD.n1261 VSSD 0.045634f
C4795 VDDD.n1262 VSSD 0.045634f
C4796 VDDD.n1264 VSSD 0.045634f
C4797 VDDD.n1265 VSSD 0.045634f
C4798 VDDD.n1266 VSSD 0.045634f
C4799 VDDD.n1267 VSSD 0.045634f
C4800 VDDD.n1270 VSSD 0.091269f
C4801 VDDD.n1271 VSSD 0.056675f
C4802 VDDD.n1275 VSSD 0.091269f
C4803 VDDD.n1277 VSSD 0.091269f
C4804 VDDD.n1280 VSSD 0.045634f
C4805 VDDD.n1282 VSSD 0.045634f
C4806 VDDD.n1283 VSSD 0.046547f
C4807 VDDD.n1284 VSSD 0.046547f
C4808 VDDD.n1285 VSSD 0.046547f
C4809 VDDD.n1286 VSSD 0.046547f
C4810 VDDD.n1287 VSSD 0.046547f
C4811 VDDD.t484 VSSD 0.035134f
C4812 VDDD.n1288 VSSD 0.064631f
C4813 VDDD.t55 VSSD 0.035134f
C4814 VDDD.n1289 VSSD 0.064631f
C4815 VDDD.t529 VSSD 0.049949f
C4816 VDDD.n1290 VSSD 0.091269f
C4817 VDDD.n1291 VSSD 0.091269f
C4818 VDDD.n1293 VSSD 0.091269f
C4819 VDDD.n1296 VSSD 0.047851f
C4820 VDDD.n1297 VSSD 0.047851f
C4821 VDDD.n1298 VSSD 0.047851f
C4822 VDDD.n1299 VSSD 0.081038f
C4823 VDDD.n1302 VSSD 0.047851f
C4824 VDDD.n1304 VSSD 0.047851f
C4825 VDDD.n1306 VSSD 0.047851f
C4826 VDDD.n1308 VSSD 0.047851f
C4827 VDDD.n1310 VSSD 0.147985f
C4828 VDDD.n1311 VSSD 0.147985f
C4829 VDDD.n1312 VSSD 0.147985f
C4830 VDDD.n1314 VSSD 0.130384f
C4831 VDDD.n1315 VSSD 0.056675f
C4832 VDDD.n1316 VSSD 0.045634f
C4833 VDDD.n1317 VSSD 0.014342f
C4834 VDDD.n1318 VSSD 0.045634f
C4835 VDDD.n1319 VSSD 0.045634f
C4836 VDDD.n1320 VSSD 0.072363f
C4837 VDDD.n1321 VSSD 0.045634f
C4838 VDDD.n1322 VSSD 0.045634f
C4839 VDDD.n1323 VSSD 0.045634f
C4840 VDDD.n1324 VSSD 0.010757f
C4841 VDDD.n1325 VSSD 0.130384f
C4842 VDDD.n1326 VSSD 0.045634f
C4843 VDDD.n1327 VSSD 0.045634f
C4844 VDDD.n1328 VSSD 0.014342f
C4845 VDDD.n1329 VSSD 1.37223f
C4846 VDDD.n1331 VSSD 0.045634f
C4847 VDDD.n1332 VSSD 0.045634f
C4848 VDDD.n1333 VSSD 0.045634f
C4849 VDDD.n1335 VSSD 0.045634f
C4850 VDDD.n1336 VSSD 0.045634f
C4851 VDDD.n1337 VSSD 0.045634f
C4852 VDDD.n1338 VSSD 0.045634f
C4853 VDDD.n1341 VSSD 0.091269f
C4854 VDDD.n1342 VSSD 0.056675f
C4855 VDDD.n1346 VSSD 0.091269f
C4856 VDDD.n1348 VSSD 0.091269f
C4857 VDDD.n1351 VSSD 0.045634f
C4858 VDDD.n1353 VSSD 0.045634f
C4859 VDDD.n1354 VSSD 0.046547f
C4860 VDDD.n1355 VSSD 0.046547f
C4861 VDDD.n1356 VSSD 0.046547f
C4862 VDDD.n1357 VSSD 0.046547f
C4863 VDDD.n1358 VSSD 0.046547f
C4864 VDDD.t464 VSSD 0.035134f
C4865 VDDD.n1359 VSSD 0.064631f
C4866 VDDD.t89 VSSD 0.035134f
C4867 VDDD.n1360 VSSD 0.064631f
C4868 VDDD.t147 VSSD 0.049949f
C4869 VDDD.n1361 VSSD 0.091269f
C4870 VDDD.n1362 VSSD 0.091269f
C4871 VDDD.n1364 VSSD 0.091269f
C4872 VDDD.n1367 VSSD 0.047851f
C4873 VDDD.n1368 VSSD 0.047851f
C4874 VDDD.n1369 VSSD 0.047851f
C4875 VDDD.n1370 VSSD 0.081038f
C4876 VDDD.n1373 VSSD 0.047851f
C4877 VDDD.n1375 VSSD 0.047851f
C4878 VDDD.n1377 VSSD 0.047851f
C4879 VDDD.n1379 VSSD 0.047851f
C4880 VDDD.n1381 VSSD 0.147985f
C4881 VDDD.n1382 VSSD 0.147985f
C4882 VDDD.n1383 VSSD 0.147985f
C4883 VDDD.n1385 VSSD 0.147985f
C4884 VDDD.n1386 VSSD 0.147985f
C4885 VDDD.n1389 VSSD 0.091269f
C4886 VDDD.n1395 VSSD 0.091269f
C4887 VDDD.n1397 VSSD 0.147985f
C4888 VDDD.t233 VSSD 0.035134f
C4889 VDDD.n1399 VSSD 0.289607f
C4890 VDDD.t328 VSSD 0.035134f
C4891 VDDD.n1400 VSSD 0.064631f
C4892 VDDD.t488 VSSD 0.035134f
C4893 VDDD.n1401 VSSD 0.077772f
C4894 VDDD.t284 VSSD 0.035134f
C4895 VDDD.n1402 VSSD 0.077851f
C4896 VDDD.t212 VSSD 0.035134f
C4897 VDDD.n1403 VSSD 0.073685f
C4898 VDDD.t286 VSSD 0.035134f
C4899 VDDD.n1404 VSSD 0.055592f
C4900 VDDD.n1405 VSSD 1.24709f
C4901 VDDD.n1406 VSSD 0.038149f
C4902 VDDD.n1407 VSSD 0.038149f
C4903 VDDD.t158 VSSD 0.280783f
C4904 VDDD.n1408 VSSD 0.038727f
C4905 VDDD.n1409 VSSD 0.038727f
C4906 VDDD.t159 VSSD 0.035134f
C4907 VDDD.n1410 VSSD 0.055592f
C4908 VDDD.n1411 VSSD 1.24061f
C4909 VDDD.n1412 VSSD 0.365915f
C4910 VDDD.n1413 VSSD 1.54073f
C4911 VDDD.t251 VSSD 0.714178f
C4912 VDDD.n1414 VSSD 0.505259f
C4913 VDDD.n1415 VSSD 0.038149f
C4914 VDDD.n1416 VSSD 0.029743f
C4915 VDDD.n1417 VSSD 0.036649f
C4916 VDDD.n1418 VSSD 0.052668f
C4917 VDDD.n1419 VSSD 0.038149f
C4918 VDDD.n1420 VSSD 0.452864f
C4919 VDDD.t458 VSSD 0.593208f
C4920 VDDD.n1421 VSSD 0.029743f
C4921 VDDD.n1422 VSSD 0.052668f
C4922 VDDD.n1423 VSSD 0.036649f
C4923 VDDD.n1424 VSSD 0.246436f
C4924 VDDD.t487 VSSD 0.263364f
C4925 VDDD.n1425 VSSD 0.085091f
C4926 VDDD.t232 VSSD 0.369182f
C4927 VDDD.n1426 VSSD 0.336791f
C4928 VDDD.t327 VSSD 0.294356f
C4929 VDDD.n1427 VSSD 0.059327f
C4930 VDDD.t283 VSSD 0.191277f
C4931 VDDD.n1428 VSSD 0.194088f
C4932 VDDD.n1429 VSSD 0.521521f
C4933 VDDD.n1430 VSSD 0.658644f
C4934 VDDD.t243 VSSD 0.581206f
C4935 VDDD.t503 VSSD 0.630888f
C4936 VDDD.t446 VSSD 0.641929f
C4937 VDDD.t298 VSSD 0.641929f
C4938 VDDD.t578 VSSD 0.780724f
C4939 VDDD.t14 VSSD 1.11983f
C4940 VDDD.t486 VSSD 1.02519f
C4941 VDDD.t402 VSSD 0.686091f
C4942 VDDD.t24 VSSD 0.64666f
C4943 VDDD.t209 VSSD 0.64666f
C4944 VDDD.t507 VSSD 0.705018f
C4945 VDDD.t242 VSSD 0.761009f
C4946 VDDD.n1431 VSSD 0.363433f
C4947 VDDD.t211 VSSD 0.34553f
C4948 VDDD.n1432 VSSD 0.388226f
C4949 VDDD.n1433 VSSD 0.013144f
C4950 VDDD.n1434 VSSD 0.326751f
C4951 VDDD.t285 VSSD 0.154524f
C4952 VDDD.n1435 VSSD 0.249067f
C4953 VDDD.n1436 VSSD 0.365915f
C4954 VDDD.n1437 VSSD 0.700875f
C4955 VDDD.n1438 VSSD 2.32627f
C4956 VDDD.t210 VSSD 0.049965f
C4957 VDDD.n1439 VSSD 2.783f
C4958 VDDD.t403 VSSD 0.049965f
C4959 VDDD.n1440 VSSD 3.79545f
C4960 VDDD.t299 VSSD 0.049965f
C4961 VDDD.n1441 VSSD 3.76886f
C4962 VDDD.t504 VSSD 0.049965f
C4963 VDDD.n1442 VSSD 2.54768f
C4964 VDDD.n1443 VSSD 2.50405f
C4965 VDDD.n1444 VSSD 1.4819f
C4966 VDDD.n1445 VSSD 1.13997f
C4967 VDDD.n1446 VSSD 0.624536f
C4968 VDDD.n1448 VSSD 0.147207f
C4969 VDDD.n1450 VSSD 0.147985f
C4970 VDDD.n1451 VSSD 0.091269f
C4971 VDDD.n1452 VSSD 0.147985f
C4972 VDDD.n1453 VSSD 1.37418f
C4973 VDDD.n1457 VSSD 1.37418f
C4974 VDDD.n1459 VSSD 0.047851f
C4975 VDDD.n1460 VSSD 0.12071f
C4976 VDDD.n1461 VSSD 0.594276f
C4977 VDDD.t66 VSSD 0.035134f
C4978 VDDD.t459 VSSD 1.35593f
C4979 VDDD.n1462 VSSD 1.03422f
C4980 VDDD.t463 VSSD 0.329366f
C4981 VDDD.n1463 VSSD 0.29943f
C4982 VDDD.t88 VSSD 0.601391f
C4983 VDDD.t376 VSSD 0.87619f
C4984 VDDD.t521 VSSD 0.630888f
C4985 VDDD.t289 VSSD 0.641929f
C4986 VDDD.t489 VSSD 0.641929f
C4987 VDDD.t429 VSSD 0.780724f
C4988 VDDD.t572 VSSD 1.11983f
C4989 VDDD.t87 VSSD 1.02519f
C4990 VDDD.t146 VSSD 0.686091f
C4991 VDDD.t520 VSSD 0.64666f
C4992 VDDD.t67 VSSD 0.64666f
C4993 VDDD.t497 VSSD 0.705018f
C4994 VDDD.t377 VSSD 0.770701f
C4995 VDDD.t65 VSSD 0.202843f
C4996 VDDD.n1464 VSSD 0.236569f
C4997 VDDD.n1465 VSSD 0.066479f
C4998 VDDD.n1466 VSSD 1.22687f
C4999 VDDD.t68 VSSD 0.049949f
C5000 VDDD.n1467 VSSD 0.98744f
C5001 VDDD.n1468 VSSD 1.34049f
C5002 VDDD.t490 VSSD 0.049949f
C5003 VDDD.n1469 VSSD 1.32347f
C5004 VDDD.t522 VSSD 0.049949f
C5005 VDDD.n1470 VSSD 0.86f
C5006 VDDD.n1471 VSSD 0.660804f
C5007 VDDD.n1472 VSSD 1.1952f
C5008 VDDD.n1473 VSSD 1.16338f
C5009 VDDD.n1474 VSSD 0.046547f
C5010 VDDD.n1475 VSSD 0.045634f
C5011 VDDD.n1476 VSSD 0.045634f
C5012 VDDD.n1477 VSSD 0.045634f
C5013 VDDD.n1478 VSSD 0.045634f
C5014 VDDD.n1479 VSSD 0.045634f
C5015 VDDD.n1480 VSSD 0.045634f
C5016 VDDD.n1481 VSSD 0.045634f
C5017 VDDD.n1482 VSSD 0.132516f
C5018 VDDD.n1483 VSSD 0.059859f
C5019 VDDD.n1484 VSSD 0.05721f
C5020 VDDD.n1486 VSSD 0.131014f
C5021 VDDD.n1487 VSSD 0.056675f
C5022 VDDD.n1488 VSSD 1.33811f
C5023 VDDD.n1489 VSSD 1.33811f
C5024 VDDD.n1490 VSSD 0.091269f
C5025 VDDD.n1492 VSSD 0.045634f
C5026 VDDD.n1494 VSSD 0.045634f
C5027 VDDD.n1500 VSSD 0.091269f
C5028 VDDD.n1502 VSSD 0.045634f
C5029 VDDD.n1506 VSSD 0.091269f
C5030 VDDD.n1508 VSSD 0.045634f
C5031 VDDD.n1509 VSSD 0.135431f
C5032 VDDD.n1511 VSSD 0.056675f
C5033 VDDD.n1512 VSSD 0.056873f
C5034 VDDD.n1513 VSSD 7.02e-19
C5035 VDDD.n1514 VSSD 0.045596f
C5036 VDDD.n1515 VSSD 0.045634f
C5037 VDDD.n1516 VSSD 0.130384f
C5038 VDDD.n1517 VSSD 0.130384f
C5039 VDDD.n1518 VSSD 0.097788f
C5040 VDDD.n1519 VSSD 0.045634f
C5041 VDDD.n1520 VSSD 0.010757f
C5042 VDDD.n1521 VSSD 0.045634f
C5043 VDDD.n1522 VSSD 0.097788f
C5044 VDDD.n1523 VSSD 0.130384f
C5045 VDDD.n1524 VSSD 0.130384f
C5046 VDDD.n1525 VSSD 0.045634f
C5047 VDDD.n1526 VSSD 0.045596f
C5048 VDDD.n1527 VSSD 7.02e-19
C5049 VDDD.n1528 VSSD 0.056873f
C5050 VDDD.n1529 VSSD 3.52983f
C5051 VDDD.n1530 VSSD 3.57531f
C5052 VDDD.n1531 VSSD 0.147985f
C5053 VDDD.n1532 VSSD 0.147985f
C5054 VDDD.n1535 VSSD 0.091269f
C5055 VDDD.n1541 VSSD 0.091269f
C5056 VDDD.n1543 VSSD 0.147985f
C5057 VDDD.t236 VSSD 0.035134f
C5058 VDDD.n1545 VSSD 0.289607f
C5059 VDDD.t192 VSSD 0.035134f
C5060 VDDD.n1546 VSSD 0.064631f
C5061 VDDD.t86 VSSD 0.035134f
C5062 VDDD.n1547 VSSD 0.077772f
C5063 VDDD.t586 VSSD 0.035134f
C5064 VDDD.n1548 VSSD 0.077851f
C5065 VDDD.t130 VSSD 0.035134f
C5066 VDDD.n1549 VSSD 0.073685f
C5067 VDDD.t584 VSSD 0.035134f
C5068 VDDD.n1550 VSSD 0.055592f
C5069 VDDD.n1551 VSSD 1.24709f
C5070 VDDD.n1552 VSSD 0.038149f
C5071 VDDD.n1553 VSSD 0.038149f
C5072 VDDD.t461 VSSD 0.280783f
C5073 VDDD.n1554 VSSD 0.038727f
C5074 VDDD.n1555 VSSD 0.038727f
C5075 VDDD.t462 VSSD 0.035134f
C5076 VDDD.n1556 VSSD 0.055592f
C5077 VDDD.n1557 VSSD 1.24061f
C5078 VDDD.n1558 VSSD 0.365915f
C5079 VDDD.n1559 VSSD 1.54073f
C5080 VDDD.t587 VSSD 0.714178f
C5081 VDDD.n1560 VSSD 0.505259f
C5082 VDDD.n1561 VSSD 0.038149f
C5083 VDDD.n1562 VSSD 0.029743f
C5084 VDDD.n1563 VSSD 0.036649f
C5085 VDDD.n1564 VSSD 0.052668f
C5086 VDDD.n1565 VSSD 0.038149f
C5087 VDDD.n1566 VSSD 0.452864f
C5088 VDDD.t190 VSSD 0.593208f
C5089 VDDD.n1567 VSSD 0.029743f
C5090 VDDD.n1568 VSSD 0.052668f
C5091 VDDD.n1569 VSSD 0.036649f
C5092 VDDD.n1570 VSSD 0.246436f
C5093 VDDD.t85 VSSD 0.263364f
C5094 VDDD.n1571 VSSD 0.085091f
C5095 VDDD.t235 VSSD 0.369182f
C5096 VDDD.n1572 VSSD 0.336791f
C5097 VDDD.t191 VSSD 0.294356f
C5098 VDDD.n1573 VSSD 0.059327f
C5099 VDDD.t585 VSSD 0.191277f
C5100 VDDD.n1574 VSSD 0.194088f
C5101 VDDD.n1575 VSSD 0.521521f
C5102 VDDD.n1576 VSSD 0.658644f
C5103 VDDD.t523 VSSD 0.581206f
C5104 VDDD.t257 VSSD 0.630888f
C5105 VDDD.t231 VSSD 0.641929f
C5106 VDDD.t318 VSSD 0.641929f
C5107 VDDD.t535 VSSD 0.780724f
C5108 VDDD.t255 VSSD 1.11983f
C5109 VDDD.t254 VSSD 1.02519f
C5110 VDDD.t423 VSSD 0.686091f
C5111 VDDD.t454 VSSD 0.64666f
C5112 VDDD.t127 VSSD 0.64666f
C5113 VDDD.t171 VSSD 0.705018f
C5114 VDDD.t562 VSSD 0.761009f
C5115 VDDD.n1577 VSSD 0.363433f
C5116 VDDD.t129 VSSD 0.34553f
C5117 VDDD.n1578 VSSD 0.388226f
C5118 VDDD.n1579 VSSD 0.013144f
C5119 VDDD.n1580 VSSD 0.326751f
C5120 VDDD.t583 VSSD 0.154524f
C5121 VDDD.n1581 VSSD 0.249067f
C5122 VDDD.n1582 VSSD 0.365915f
C5123 VDDD.n1583 VSSD 0.700875f
C5124 VDDD.n1584 VSSD 2.32627f
C5125 VDDD.t128 VSSD 0.049965f
C5126 VDDD.n1585 VSSD 2.783f
C5127 VDDD.t424 VSSD 0.049965f
C5128 VDDD.n1586 VSSD 3.79545f
C5129 VDDD.t319 VSSD 0.049965f
C5130 VDDD.n1587 VSSD 3.76886f
C5131 VDDD.t258 VSSD 0.049965f
C5132 VDDD.n1588 VSSD 2.54768f
C5133 VDDD.n1589 VSSD 2.50405f
C5134 VDDD.n1590 VSSD 1.4819f
C5135 VDDD.n1591 VSSD 1.13997f
C5136 VDDD.n1592 VSSD 0.624536f
C5137 VDDD.n1594 VSSD 0.147207f
C5138 VDDD.n1596 VSSD 0.147985f
C5139 VDDD.n1597 VSSD 0.091269f
C5140 VDDD.n1598 VSSD 0.147985f
C5141 VDDD.n1599 VSSD 1.37418f
C5142 VDDD.n1603 VSSD 1.37418f
C5143 VDDD.n1605 VSSD 0.047851f
C5144 VDDD.n1606 VSSD 0.12071f
C5145 VDDD.n1607 VSSD 0.594276f
C5146 VDDD.t589 VSSD 0.035134f
C5147 VDDD.t193 VSSD 1.35593f
C5148 VDDD.n1608 VSSD 1.03422f
C5149 VDDD.t483 VSSD 0.329366f
C5150 VDDD.n1609 VSSD 0.29943f
C5151 VDDD.t54 VSSD 0.601391f
C5152 VDDD.t400 VSSD 0.87619f
C5153 VDDD.t512 VSSD 0.630888f
C5154 VDDD.t598 VSSD 0.641929f
C5155 VDDD.t516 VSSD 0.641929f
C5156 VDDD.t593 VSSD 0.780724f
C5157 VDDD.t380 VSSD 1.11983f
C5158 VDDD.t379 VSSD 1.02519f
C5159 VDDD.t528 VSSD 0.686091f
C5160 VDDD.t155 VSSD 0.64666f
C5161 VDDD.t260 VSSD 0.64666f
C5162 VDDD.t174 VSSD 0.705018f
C5163 VDDD.t399 VSSD 0.770701f
C5164 VDDD.t588 VSSD 0.202843f
C5165 VDDD.n1610 VSSD 0.236569f
C5166 VDDD.n1611 VSSD 0.066479f
C5167 VDDD.n1612 VSSD 1.22687f
C5168 VDDD.t261 VSSD 0.049949f
C5169 VDDD.n1613 VSSD 0.98744f
C5170 VDDD.n1614 VSSD 1.34049f
C5171 VDDD.t517 VSSD 0.049949f
C5172 VDDD.n1615 VSSD 1.32347f
C5173 VDDD.t513 VSSD 0.049949f
C5174 VDDD.n1616 VSSD 0.86f
C5175 VDDD.n1617 VSSD 0.660804f
C5176 VDDD.n1618 VSSD 1.1952f
C5177 VDDD.n1619 VSSD 1.16338f
C5178 VDDD.n1620 VSSD 0.046547f
C5179 VDDD.n1621 VSSD 0.045634f
C5180 VDDD.n1622 VSSD 0.045634f
C5181 VDDD.n1623 VSSD 0.045634f
C5182 VDDD.n1624 VSSD 0.045634f
C5183 VDDD.n1625 VSSD 0.045634f
C5184 VDDD.n1626 VSSD 0.045634f
C5185 VDDD.n1627 VSSD 0.045634f
C5186 VDDD.n1628 VSSD 0.132516f
C5187 VDDD.n1629 VSSD 0.059859f
C5188 VDDD.n1630 VSSD 0.05721f
C5189 VDDD.n1632 VSSD 0.131014f
C5190 VDDD.n1633 VSSD 0.056675f
C5191 VDDD.n1634 VSSD 1.33811f
C5192 VDDD.n1635 VSSD 1.33811f
C5193 VDDD.n1636 VSSD 0.091269f
C5194 VDDD.n1638 VSSD 0.045634f
C5195 VDDD.n1640 VSSD 0.045634f
C5196 VDDD.n1646 VSSD 0.091269f
C5197 VDDD.n1648 VSSD 0.045634f
C5198 VDDD.n1652 VSSD 0.091269f
C5199 VDDD.n1654 VSSD 0.045634f
C5200 VDDD.n1655 VSSD 0.135431f
C5201 VDDD.n1657 VSSD 0.056675f
C5202 VDDD.n1658 VSSD 0.056873f
C5203 VDDD.n1659 VSSD 7.02e-19
C5204 VDDD.n1660 VSSD 0.045596f
C5205 VDDD.n1661 VSSD 0.045634f
C5206 VDDD.n1662 VSSD 0.130384f
C5207 VDDD.n1663 VSSD 0.130384f
C5208 VDDD.n1664 VSSD 0.097788f
C5209 VDDD.n1665 VSSD 0.045634f
C5210 VDDD.n1666 VSSD 0.010757f
C5211 VDDD.n1667 VSSD 0.045634f
C5212 VDDD.n1668 VSSD 0.097788f
C5213 VDDD.n1669 VSSD 0.130384f
C5214 VDDD.n1670 VSSD 0.130384f
C5215 VDDD.n1671 VSSD 0.045634f
C5216 VDDD.n1672 VSSD 0.045596f
C5217 VDDD.n1673 VSSD 7.02e-19
C5218 VDDD.n1674 VSSD 0.056873f
C5219 VDDD.n1675 VSSD 3.52983f
C5220 VDDD.n1676 VSSD 3.57531f
C5221 VDDD.n1677 VSSD 0.147985f
C5222 VDDD.n1678 VSSD 0.147985f
C5223 VDDD.n1681 VSSD 0.091269f
C5224 VDDD.n1687 VSSD 0.091269f
C5225 VDDD.n1689 VSSD 0.147985f
C5226 VDDD.t20 VSSD 0.035134f
C5227 VDDD.n1691 VSSD 0.289607f
C5228 VDDD.t308 VSSD 0.035134f
C5229 VDDD.n1692 VSSD 0.064631f
C5230 VDDD.t493 VSSD 0.035134f
C5231 VDDD.n1693 VSSD 0.077772f
C5232 VDDD.t385 VSSD 0.035134f
C5233 VDDD.n1694 VSSD 0.077851f
C5234 VDDD.t263 VSSD 0.035134f
C5235 VDDD.n1695 VSSD 0.073685f
C5236 VDDD.t373 VSSD 0.035134f
C5237 VDDD.n1696 VSSD 0.055592f
C5238 VDDD.n1697 VSSD 1.24709f
C5239 VDDD.n1698 VSSD 0.038149f
C5240 VDDD.n1699 VSSD 0.038149f
C5241 VDDD.t346 VSSD 0.280783f
C5242 VDDD.n1700 VSSD 0.038727f
C5243 VDDD.n1701 VSSD 0.038727f
C5244 VDDD.t347 VSSD 0.035134f
C5245 VDDD.n1702 VSSD 0.055592f
C5246 VDDD.n1703 VSSD 1.24061f
C5247 VDDD.n1704 VSSD 0.365915f
C5248 VDDD.n1705 VSSD 1.54073f
C5249 VDDD.t64 VSSD 0.714178f
C5250 VDDD.n1706 VSSD 0.505259f
C5251 VDDD.n1707 VSSD 0.038149f
C5252 VDDD.n1708 VSSD 0.029743f
C5253 VDDD.n1709 VSSD 0.036649f
C5254 VDDD.n1710 VSSD 0.052668f
C5255 VDDD.n1711 VSSD 0.038149f
C5256 VDDD.n1712 VSSD 0.452864f
C5257 VDDD.t309 VSSD 0.593208f
C5258 VDDD.n1713 VSSD 0.029743f
C5259 VDDD.n1714 VSSD 0.052668f
C5260 VDDD.n1715 VSSD 0.036649f
C5261 VDDD.n1716 VSSD 0.246436f
C5262 VDDD.t492 VSSD 0.263364f
C5263 VDDD.n1717 VSSD 0.085091f
C5264 VDDD.t19 VSSD 0.369182f
C5265 VDDD.n1718 VSSD 0.336791f
C5266 VDDD.t307 VSSD 0.294356f
C5267 VDDD.n1719 VSSD 0.059327f
C5268 VDDD.t384 VSSD 0.191277f
C5269 VDDD.n1720 VSSD 0.194088f
C5270 VDDD.n1721 VSSD 0.521521f
C5271 VDDD.n1722 VSSD 0.658644f
C5272 VDDD.t30 VSSD 0.581206f
C5273 VDDD.t134 VSSD 0.630888f
C5274 VDDD.t90 VSSD 0.641929f
C5275 VDDD.t101 VSSD 0.641929f
C5276 VDDD.t544 VSSD 0.780724f
C5277 VDDD.t494 VSSD 1.11983f
C5278 VDDD.t495 VSSD 1.02519f
C5279 VDDD.t596 VSSD 0.686091f
C5280 VDDD.t100 VSSD 0.64666f
C5281 VDDD.t264 VSSD 0.64666f
C5282 VDDD.t139 VSSD 0.705018f
C5283 VDDD.t31 VSSD 0.761009f
C5284 VDDD.n1723 VSSD 0.363433f
C5285 VDDD.t262 VSSD 0.34553f
C5286 VDDD.n1724 VSSD 0.388226f
C5287 VDDD.n1725 VSSD 0.013144f
C5288 VDDD.n1726 VSSD 0.326751f
C5289 VDDD.t372 VSSD 0.154524f
C5290 VDDD.n1727 VSSD 0.249067f
C5291 VDDD.n1728 VSSD 0.365915f
C5292 VDDD.n1729 VSSD 0.700875f
C5293 VDDD.n1730 VSSD 2.32627f
C5294 VDDD.t265 VSSD 0.049965f
C5295 VDDD.n1731 VSSD 2.783f
C5296 VDDD.t597 VSSD 0.049965f
C5297 VDDD.n1732 VSSD 3.79545f
C5298 VDDD.t102 VSSD 0.049965f
C5299 VDDD.n1733 VSSD 3.76886f
C5300 VDDD.t135 VSSD 0.049965f
C5301 VDDD.n1734 VSSD 2.54768f
C5302 VDDD.n1735 VSSD 2.50405f
C5303 VDDD.n1736 VSSD 1.4819f
C5304 VDDD.n1737 VSSD 1.13997f
C5305 VDDD.n1738 VSSD 0.624536f
C5306 VDDD.n1740 VSSD 0.147207f
C5307 VDDD.n1742 VSSD 0.147985f
C5308 VDDD.n1743 VSSD 0.091269f
C5309 VDDD.n1744 VSSD 0.147985f
C5310 VDDD.n1745 VSSD 1.37418f
C5311 VDDD.n1749 VSSD 1.37418f
C5312 VDDD.n1751 VSSD 0.047851f
C5313 VDDD.n1752 VSSD 0.12071f
C5314 VDDD.n1753 VSSD 0.594276f
C5315 VDDD.t199 VSSD 0.035134f
C5316 VDDD.t53 VSSD 1.35593f
C5317 VDDD.n1754 VSSD 1.03422f
C5318 VDDD.t481 VSSD 0.329366f
C5319 VDDD.n1755 VSSD 0.29943f
C5320 VDDD.t392 VSSD 0.601391f
C5321 VDDD.t29 VSSD 0.87619f
C5322 VDDD.t221 VSSD 0.630888f
C5323 VDDD.t358 VSSD 0.641929f
C5324 VDDD.t368 VSSD 0.641929f
C5325 VDDD.t148 VSSD 0.780724f
C5326 VDDD.t306 VSSD 1.11983f
C5327 VDDD.t305 VSSD 1.02519f
C5328 VDDD.t602 VSSD 0.686091f
C5329 VDDD.t303 VSSD 0.64666f
C5330 VDDD.t196 VSSD 0.64666f
C5331 VDDD.t185 VSSD 0.705018f
C5332 VDDD.t411 VSSD 0.770701f
C5333 VDDD.t198 VSSD 0.202843f
C5334 VDDD.n1756 VSSD 0.236569f
C5335 VDDD.n1757 VSSD 0.066479f
C5336 VDDD.n1758 VSSD 1.22687f
C5337 VDDD.t197 VSSD 0.049949f
C5338 VDDD.n1759 VSSD 0.98744f
C5339 VDDD.n1760 VSSD 1.34049f
C5340 VDDD.t369 VSSD 0.049949f
C5341 VDDD.n1761 VSSD 1.32347f
C5342 VDDD.t222 VSSD 0.049949f
C5343 VDDD.n1762 VSSD 0.86f
C5344 VDDD.n1763 VSSD 0.660804f
C5345 VDDD.n1764 VSSD 1.1952f
C5346 VDDD.n1765 VSSD 1.16338f
C5347 VDDD.n1766 VSSD 0.046547f
C5348 VDDD.n1767 VSSD 0.045634f
C5349 VDDD.n1768 VSSD 0.045634f
C5350 VDDD.n1769 VSSD 0.045634f
C5351 VDDD.n1770 VSSD 0.045634f
C5352 VDDD.n1771 VSSD 0.045634f
C5353 VDDD.n1772 VSSD 0.045634f
C5354 VDDD.n1773 VSSD 0.045634f
C5355 VDDD.n1774 VSSD 0.132516f
C5356 VDDD.n1775 VSSD 0.059859f
C5357 VDDD.n1776 VSSD 0.05721f
C5358 VDDD.n1778 VSSD 0.131014f
C5359 VDDD.n1779 VSSD 0.056675f
C5360 VDDD.n1780 VSSD 1.33811f
C5361 VDDD.n1781 VSSD 1.33811f
C5362 VDDD.n1782 VSSD 0.091269f
C5363 VDDD.n1784 VSSD 0.045634f
C5364 VDDD.n1786 VSSD 0.045634f
C5365 VDDD.n1792 VSSD 0.091269f
C5366 VDDD.n1794 VSSD 0.045634f
C5367 VDDD.n1798 VSSD 0.091269f
C5368 VDDD.n1800 VSSD 0.045634f
C5369 VDDD.n1801 VSSD 0.135431f
C5370 VDDD.n1803 VSSD 0.056675f
C5371 VDDD.n1804 VSSD 0.056873f
C5372 VDDD.n1805 VSSD 7.02e-19
C5373 VDDD.n1806 VSSD 0.045596f
C5374 VDDD.n1807 VSSD 0.045634f
C5375 VDDD.n1808 VSSD 0.130384f
C5376 VDDD.n1809 VSSD 0.130384f
C5377 VDDD.n1810 VSSD 0.097788f
C5378 VDDD.n1811 VSSD 0.045634f
C5379 VDDD.n1812 VSSD 0.010757f
C5380 VDDD.n1813 VSSD 0.045634f
C5381 VDDD.n1814 VSSD 0.097788f
C5382 VDDD.n1815 VSSD 0.130384f
C5383 VDDD.n1816 VSSD 0.130384f
C5384 VDDD.n1817 VSSD 0.045634f
C5385 VDDD.n1818 VSSD 0.045596f
C5386 VDDD.n1819 VSSD 7.02e-19
C5387 VDDD.n1820 VSSD 0.056873f
C5388 VDDD.n1821 VSSD 3.52983f
C5389 VDDD.n1822 VSSD 3.57531f
C5390 VDDD.n1823 VSSD 0.147985f
C5391 VDDD.n1824 VSSD 0.147985f
C5392 VDDD.n1827 VSSD 0.091269f
C5393 VDDD.n1833 VSSD 0.091269f
C5394 VDDD.n1835 VSSD 0.147985f
C5395 VDDD.t288 VSSD 0.035134f
C5396 VDDD.n1837 VSSD 0.289607f
C5397 VDDD.t76 VSSD 0.035134f
C5398 VDDD.n1838 VSSD 0.064631f
C5399 VDDD.t62 VSSD 0.035134f
C5400 VDDD.n1839 VSSD 0.077772f
C5401 VDDD.t81 VSSD 0.035134f
C5402 VDDD.n1840 VSSD 0.077851f
C5403 VDDD.t456 VSSD 0.035134f
C5404 VDDD.n1841 VSSD 0.073685f
C5405 VDDD.t79 VSSD 0.035134f
C5406 VDDD.n1842 VSSD 0.055592f
C5407 VDDD.n1843 VSSD 1.24709f
C5408 VDDD.n1844 VSSD 0.038149f
C5409 VDDD.n1845 VSSD 0.038149f
C5410 VDDD.t103 VSSD 0.280783f
C5411 VDDD.n1846 VSSD 0.038727f
C5412 VDDD.n1847 VSSD 0.038727f
C5413 VDDD.t104 VSSD 0.035134f
C5414 VDDD.n1848 VSSD 0.055592f
C5415 VDDD.n1849 VSSD 1.24061f
C5416 VDDD.n1850 VSSD 0.365915f
C5417 VDDD.n1851 VSSD 1.54073f
C5418 VDDD.t82 VSSD 0.714178f
C5419 VDDD.n1852 VSSD 0.505259f
C5420 VDDD.n1853 VSSD 0.038149f
C5421 VDDD.n1854 VSSD 0.029743f
C5422 VDDD.n1855 VSSD 0.036649f
C5423 VDDD.n1856 VSSD 0.052668f
C5424 VDDD.n1857 VSSD 0.038149f
C5425 VDDD.n1858 VSSD 0.452864f
C5426 VDDD.t77 VSSD 0.593208f
C5427 VDDD.n1859 VSSD 0.029743f
C5428 VDDD.n1860 VSSD 0.052668f
C5429 VDDD.n1861 VSSD 0.036649f
C5430 VDDD.n1862 VSSD 0.246436f
C5431 VDDD.t61 VSSD 0.263364f
C5432 VDDD.n1863 VSSD 0.085091f
C5433 VDDD.t287 VSSD 0.369182f
C5434 VDDD.n1864 VSSD 0.336791f
C5435 VDDD.t75 VSSD 0.294356f
C5436 VDDD.n1865 VSSD 0.059327f
C5437 VDDD.t80 VSSD 0.191277f
C5438 VDDD.n1866 VSSD 0.194088f
C5439 VDDD.n1867 VSSD 0.521521f
C5440 VDDD.n1868 VSSD 0.658644f
C5441 VDDD.t381 VSSD 0.581206f
C5442 VDDD.t140 VSSD 0.630888f
C5443 VDDD.t491 VSSD 0.641929f
C5444 VDDD.t36 VSSD 0.641929f
C5445 VDDD.t531 VSSD 0.780724f
C5446 VDDD.t63 VSSD 1.11983f
C5447 VDDD.t60 VSSD 1.02519f
C5448 VDDD.t536 VSSD 0.686091f
C5449 VDDD.t23 VSSD 0.64666f
C5450 VDDD.t390 VSSD 0.64666f
C5451 VDDD.t496 VSSD 0.705018f
C5452 VDDD.t382 VSSD 0.761009f
C5453 VDDD.n1869 VSSD 0.363433f
C5454 VDDD.t455 VSSD 0.34553f
C5455 VDDD.n1870 VSSD 0.388226f
C5456 VDDD.n1871 VSSD 0.013144f
C5457 VDDD.n1872 VSSD 0.326751f
C5458 VDDD.t78 VSSD 0.154524f
C5459 VDDD.n1873 VSSD 0.249067f
C5460 VDDD.n1874 VSSD 0.365915f
C5461 VDDD.n1875 VSSD 0.700875f
C5462 VDDD.n1876 VSSD 2.32627f
C5463 VDDD.t391 VSSD 0.049965f
C5464 VDDD.n1877 VSSD 2.783f
C5465 VDDD.t537 VSSD 0.049965f
C5466 VDDD.n1878 VSSD 3.79545f
C5467 VDDD.t37 VSSD 0.049965f
C5468 VDDD.n1879 VSSD 3.76886f
C5469 VDDD.t141 VSSD 0.049965f
C5470 VDDD.n1880 VSSD 2.54768f
C5471 VDDD.n1881 VSSD 2.50405f
C5472 VDDD.n1882 VSSD 1.4819f
C5473 VDDD.n1883 VSSD 1.13997f
C5474 VDDD.n1884 VSSD 0.624536f
C5475 VDDD.n1886 VSSD 0.147207f
C5476 VDDD.n1888 VSSD 0.147985f
C5477 VDDD.n1889 VSSD 0.091269f
C5478 VDDD.n1890 VSSD 0.147985f
C5479 VDDD.n1891 VSSD 1.37418f
C5480 VDDD.n1895 VSSD 1.37418f
C5481 VDDD.n1897 VSSD 0.047851f
C5482 VDDD.n1898 VSSD 0.12071f
C5483 VDDD.n1899 VSSD 0.594276f
C5484 VDDD.t224 VSSD 0.035134f
C5485 VDDD.t74 VSSD 1.35593f
C5486 VDDD.n1900 VSSD 1.03422f
C5487 VDDD.t477 VSSD 0.329366f
C5488 VDDD.n1901 VSSD 0.29943f
C5489 VDDD.t97 VSSD 0.601391f
C5490 VDDD.t326 VSSD 0.87619f
C5491 VDDD.t414 VSSD 0.630888f
C5492 VDDD.t353 VSSD 0.641929f
C5493 VDDD.t348 VSSD 0.641929f
C5494 VDDD.t591 VSSD 0.780724f
C5495 VDDD.t96 VSSD 1.11983f
C5496 VDDD.t106 VSSD 1.02519f
C5497 VDDD.t526 VSSD 0.686091f
C5498 VDDD.t533 VSSD 0.64666f
C5499 VDDD.t40 VSSD 0.64666f
C5500 VDDD.t398 VSSD 0.705018f
C5501 VDDD.t352 VSSD 0.770701f
C5502 VDDD.t223 VSSD 0.202843f
C5503 VDDD.n1902 VSSD 0.236569f
C5504 VDDD.n1903 VSSD 0.066479f
C5505 VDDD.n1904 VSSD 1.22687f
C5506 VDDD.t41 VSSD 0.049949f
C5507 VDDD.n1905 VSSD 0.98744f
C5508 VDDD.n1906 VSSD 1.34049f
C5509 VDDD.t349 VSSD 0.049949f
C5510 VDDD.n1907 VSSD 1.32347f
C5511 VDDD.t415 VSSD 0.049949f
C5512 VDDD.n1908 VSSD 0.86f
C5513 VDDD.n1909 VSSD 0.660804f
C5514 VDDD.n1910 VSSD 1.1952f
C5515 VDDD.n1911 VSSD 1.16338f
C5516 VDDD.n1912 VSSD 0.046547f
C5517 VDDD.n1913 VSSD 0.045634f
C5518 VDDD.n1914 VSSD 0.045634f
C5519 VDDD.n1915 VSSD 0.045634f
C5520 VDDD.n1916 VSSD 0.045634f
C5521 VDDD.n1917 VSSD 0.045634f
C5522 VDDD.n1918 VSSD 0.045634f
C5523 VDDD.n1919 VSSD 0.045634f
C5524 VDDD.n1920 VSSD 0.132516f
C5525 VDDD.n1921 VSSD 0.059859f
C5526 VDDD.n1922 VSSD 0.05721f
C5527 VDDD.n1924 VSSD 0.131014f
C5528 VDDD.n1925 VSSD 0.056675f
C5529 VDDD.n1926 VSSD 1.33811f
C5530 VDDD.n1927 VSSD 1.33811f
C5531 VDDD.n1928 VSSD 0.091269f
C5532 VDDD.n1930 VSSD 0.045634f
C5533 VDDD.n1932 VSSD 0.045634f
C5534 VDDD.n1938 VSSD 0.091269f
C5535 VDDD.n1940 VSSD 0.045634f
C5536 VDDD.n1944 VSSD 0.091269f
C5537 VDDD.n1946 VSSD 0.045634f
C5538 VDDD.n1947 VSSD 0.135431f
C5539 VDDD.n1949 VSSD 0.056675f
C5540 VDDD.n1950 VSSD 0.056873f
C5541 VDDD.n1951 VSSD 7.02e-19
C5542 VDDD.n1952 VSSD 0.045596f
C5543 VDDD.n1953 VSSD 0.045634f
C5544 VDDD.n1954 VSSD 0.130384f
C5545 VDDD.n1955 VSSD 0.130384f
C5546 VDDD.n1956 VSSD 0.097788f
C5547 VDDD.n1957 VSSD 0.045634f
C5548 VDDD.n1958 VSSD 0.010757f
C5549 VDDD.n1959 VSSD 0.045634f
C5550 VDDD.n1960 VSSD 0.097788f
C5551 VDDD.n1961 VSSD 0.130384f
C5552 VDDD.n1962 VSSD 0.130384f
C5553 VDDD.n1963 VSSD 0.045634f
C5554 VDDD.n1964 VSSD 0.045596f
C5555 VDDD.n1965 VSSD 7.02e-19
C5556 VDDD.n1966 VSSD 0.056873f
C5557 VDDD.n1967 VSSD 3.52983f
C5558 VDDD.t363 VSSD 0.035134f
C5559 VDDD.n1968 VSSD 0.289607f
C5560 VDDD.t355 VSSD 0.035134f
C5561 VDDD.n1969 VSSD 0.064631f
C5562 VDDD.t339 VSSD 0.035134f
C5563 VDDD.n1970 VSSD 0.077772f
C5564 VDDD.t276 VSSD 0.035134f
C5565 VDDD.n1971 VSSD 0.077851f
C5566 VDDD.t164 VSSD 0.035134f
C5567 VDDD.n1972 VSSD 0.073685f
C5568 VDDD.t273 VSSD 0.035134f
C5569 VDDD.n1973 VSSD 0.055592f
C5570 VDDD.n1974 VSSD 1.24709f
C5571 VDDD.n1975 VSSD 0.038149f
C5572 VDDD.n1976 VSSD 0.038149f
C5573 VDDD.t277 VSSD 0.280783f
C5574 VDDD.n1977 VSSD 0.038727f
C5575 VDDD.n1978 VSSD 0.038727f
C5576 VDDD.t278 VSSD 0.035134f
C5577 VDDD.n1979 VSSD 0.055592f
C5578 VDDD.n1980 VSSD 1.24061f
C5579 VDDD.n1981 VSSD 0.365915f
C5580 VDDD.n1982 VSSD 1.54073f
C5581 VDDD.t274 VSSD 0.714178f
C5582 VDDD.n1983 VSSD 0.505259f
C5583 VDDD.n1984 VSSD 0.038149f
C5584 VDDD.n1985 VSSD 0.029743f
C5585 VDDD.n1986 VSSD 0.036649f
C5586 VDDD.n1987 VSSD 0.052668f
C5587 VDDD.n1988 VSSD 0.038149f
C5588 VDDD.n1989 VSSD 0.452864f
C5589 VDDD.t356 VSSD 0.593208f
C5590 VDDD.n1990 VSSD 0.029743f
C5591 VDDD.n1991 VSSD 0.052668f
C5592 VDDD.n1992 VSSD 0.036649f
C5593 VDDD.n1993 VSSD 0.246436f
C5594 VDDD.t362 VSSD 0.369182f
C5595 VDDD.n1994 VSSD 0.336791f
C5596 VDDD.t354 VSSD 0.227765f
C5597 VDDD.n1995 VSSD 0.337741f
C5598 VDDD.n1996 VSSD 0.189086f
C5599 VDDD.t275 VSSD 0.227624f
C5600 VDDD.n1997 VSSD 0.197689f
C5601 VDDD.t338 VSSD 0.282634f
C5602 VDDD.n1998 VSSD 0.80513f
C5603 VDDD.t13 VSSD 0.581206f
C5604 VDDD.t216 VSSD 0.630888f
C5605 VDDD.t109 VSSD 0.641929f
C5606 VDDD.t350 VSSD 0.641929f
C5607 VDDD.t150 VSSD 0.780724f
C5608 VDDD.t340 VSSD 1.11983f
C5609 VDDD.t337 VSSD 1.02519f
C5610 VDDD.t152 VSSD 0.686091f
C5611 VDDD.t453 VSSD 0.64666f
C5612 VDDD.t123 VSSD 0.64666f
C5613 VDDD.t514 VSSD 0.705018f
C5614 VDDD.t437 VSSD 0.761009f
C5615 VDDD.n1999 VSSD 0.363433f
C5616 VDDD.t163 VSSD 0.34553f
C5617 VDDD.n2000 VSSD 0.388226f
C5618 VDDD.n2001 VSSD 0.013144f
C5619 VDDD.n2002 VSSD 0.326751f
C5620 VDDD.t272 VSSD 0.154524f
C5621 VDDD.n2003 VSSD 0.249067f
C5622 VDDD.n2004 VSSD 0.365915f
C5623 VDDD.n2005 VSSD 0.700875f
C5624 VDDD.n2006 VSSD 2.32627f
C5625 VDDD.t124 VSSD 0.049965f
C5626 VDDD.n2007 VSSD 2.783f
C5627 VDDD.t153 VSSD 0.049965f
C5628 VDDD.n2008 VSSD 3.79545f
C5629 VDDD.t351 VSSD 0.049965f
C5630 VDDD.n2009 VSSD 3.76886f
C5631 VDDD.t217 VSSD 0.049965f
C5632 VDDD.n2010 VSSD 2.54768f
C5633 VDDD.n2011 VSSD 2.50405f
C5634 VDDD.n2012 VSSD 1.4819f
C5635 VDDD.n2013 VSSD 1.13997f
C5636 VDDD.n2014 VSSD 0.624536f
C5637 VDDD.n2016 VSSD 0.147985f
C5638 VDDD.n2020 VSSD 0.091269f
C5639 VDDD.n2021 VSSD 3.57531f
C5640 VDDD.n2022 VSSD 0.147207f
C5641 VDDD.n2023 VSSD 0.147985f
C5642 VDDD.n2024 VSSD 1.37418f
C5643 VDDD.n2028 VSSD 1.37418f
C5644 VDDD.n2030 VSSD 0.047851f
C5645 VDDD.n2031 VSSD 0.12071f
C5646 VDDD.n2032 VSSD 0.594276f
C5647 VDDD.t250 VSSD 0.035134f
C5648 VDDD.t357 VSSD 1.35593f
C5649 VDDD.n2033 VSSD 1.03422f
C5650 VDDD.t479 VSSD 0.329366f
C5651 VDDD.n2034 VSSD 0.29943f
C5652 VDDD.t270 VSSD 0.601391f
C5653 VDDD.t195 VSSD 0.87619f
C5654 VDDD.t508 VSSD 0.630888f
C5655 VDDD.t234 VSSD 0.641929f
C5656 VDDD.t252 VSSD 0.641929f
C5657 VDDD.t590 VSSD 0.780724f
C5658 VDDD.t269 VSSD 1.11983f
C5659 VDDD.t268 VSSD 1.02519f
C5660 VDDD.t599 VSSD 0.686091f
C5661 VDDD.t296 VSSD 0.64666f
C5662 VDDD.t94 VSSD 0.64666f
C5663 VDDD.t169 VSSD 0.705018f
C5664 VDDD.t194 VSSD 0.770701f
C5665 VDDD.t249 VSSD 0.202843f
C5666 VDDD.n2035 VSSD 0.236569f
C5667 VDDD.n2036 VSSD 0.066479f
C5668 VDDD.n2037 VSSD 1.22687f
C5669 VDDD.t95 VSSD 0.049949f
C5670 VDDD.n2038 VSSD 0.98744f
C5671 VDDD.n2039 VSSD 1.34049f
C5672 VDDD.t253 VSSD 0.049949f
C5673 VDDD.n2040 VSSD 1.32347f
C5674 VDDD.t509 VSSD 0.049949f
C5675 VDDD.n2041 VSSD 0.86f
C5676 VDDD.n2042 VSSD 0.660804f
C5677 VDDD.n2043 VSSD 1.1952f
C5678 VDDD.n2044 VSSD 1.16338f
C5679 VDDD.n2045 VSSD 0.046547f
C5680 VDDD.n2046 VSSD 0.045634f
C5681 VDDD.n2047 VSSD 0.045634f
C5682 VDDD.n2048 VSSD 0.045634f
C5683 VDDD.n2049 VSSD 0.045634f
C5684 VDDD.n2050 VSSD 0.045634f
C5685 VDDD.n2051 VSSD 0.045634f
C5686 VDDD.n2052 VSSD 0.045634f
C5687 VDDD.n2053 VSSD 0.132516f
C5688 VDDD.n2054 VSSD 0.059859f
C5689 VDDD.n2055 VSSD 0.05721f
C5690 VDDD.n2057 VSSD 0.131014f
C5691 VDDD.n2058 VSSD 0.056675f
C5692 VDDD.n2059 VSSD 1.33811f
C5693 VDDD.n2060 VSSD 1.33811f
C5694 VDDD.n2061 VSSD 0.091269f
C5695 VDDD.n2063 VSSD 0.045634f
C5696 VDDD.n2065 VSSD 0.045634f
C5697 VDDD.n2071 VSSD 0.091269f
C5698 VDDD.n2073 VSSD 0.045634f
C5699 VDDD.n2077 VSSD 0.091269f
C5700 VDDD.n2079 VSSD 0.045634f
C5701 VDDD.n2080 VSSD 0.135431f
C5702 VDDD.n2082 VSSD 0.056675f
C5703 VDDD.n2083 VSSD 0.056873f
C5704 VDDD.n2084 VSSD 7.02e-19
C5705 VDDD.n2085 VSSD 0.045596f
C5706 VDDD.n2086 VSSD 0.045634f
C5707 VDDD.n2087 VSSD 0.130384f
C5708 VDDD.n2088 VSSD 0.130384f
C5709 VDDD.n2089 VSSD 0.097788f
C5710 VDDD.n2090 VSSD 0.045634f
C5711 VDDD.n2091 VSSD 0.010757f
C5712 VDDD.n2092 VSSD 0.045634f
C5713 VDDD.n2093 VSSD 0.097788f
C5714 VDDD.n2094 VSSD 0.130384f
C5715 VDDD.n2095 VSSD 0.130384f
C5716 VDDD.n2096 VSSD 0.045634f
C5717 VDDD.n2097 VSSD 0.045596f
C5718 VDDD.n2098 VSSD 7.02e-19
C5719 VDDD.n2099 VSSD 0.056873f
C5720 VDDD.n2100 VSSD 4.47615f
C5721 VDDD.n2101 VSSD 4.47615f
C5722 VDDD.n2102 VSSD 0.130384f
C5723 VDDD.n2103 VSSD 0.117345f
C5724 VDDD.n2104 VSSD 0.117345f
C5725 VDDD.n2106 VSSD 13.149799f
C5726 VDDD.n2107 VSSD 13.149799f
C5727 VDDD.n2108 VSSD 0.260767f
C5728 VDDD.n2109 VSSD 0.260767f
C5729 VDDD.n2110 VSSD 0.260767f
C5730 VDDD.n2111 VSSD 0.260767f
C5731 VDDD.n2112 VSSD 0.260767f
C5732 VDDD.n2114 VSSD 0.260767f
C5733 VDDD.n2115 VSSD 0.260767f
C5734 VDDD.n2116 VSSD 0.260767f
C5735 VDDD.n2117 VSSD 0.260767f
C5736 VDDD.n2120 VSSD 0.117345f
C5737 VDDD.n2121 VSSD 0.117345f
C5738 VDDD.n2122 VSSD 0.117345f
C5739 VDDD.n2123 VSSD 0.117345f
C5740 VDDD.n2124 VSSD 0.117345f
C5741 VDDD.n2125 VSSD 0.117345f
C5742 VDDD.n2126 VSSD 0.117345f
C5743 VDDD.n2127 VSSD 0.117345f
C5744 VDDD.n2128 VSSD 0.117345f
C5745 VDDD.n2129 VSSD 0.117345f
C5746 VDDD.n2130 VSSD 0.117345f
C5747 VDDD.n2131 VSSD 0.117345f
C5748 VDDD.n2132 VSSD 0.120622f
C5749 VDDD.n2134 VSSD 0.117345f
C5750 VDDD.n2135 VSSD 0.117345f
C5751 VDDD.n2136 VSSD 0.117345f
C5752 VDDD.n2137 VSSD 0.117345f
C5753 VDDD.n2138 VSSD 0.117345f
C5754 VDDD.n2139 VSSD 0.117345f
C5755 VDDD.n2140 VSSD 0.117345f
C5756 VDDD.n2141 VSSD 0.117345f
C5757 VDDD.n2142 VSSD 0.117345f
C5758 VDDD.n2143 VSSD 0.117345f
C5759 VDDD.n2144 VSSD 0.117345f
C5760 VDDD.n2145 VSSD 0.117345f
C5761 VDDD.n2151 VSSD 0.117345f
C5762 VDDD.n2165 VSSD 0.260767f
C5763 VDDD.n2167 VSSD 0.54677f
C5764 VDDD.n2180 VSSD 0.260767f
C5765 VDDD.n2186 VSSD 0.117345f
C5766 VDDD.n2187 VSSD 0.117345f
C5767 VDDD.n2188 VSSD 0.130384f
C5768 VDDD.n2189 VSSD 0.117345f
C5769 VDDD.n2190 VSSD 0.130384f
C5770 VDDD.n2191 VSSD 0.117345f
C5771 VDDD.n2192 VSSD 0.130384f
C5772 VDDD.n2193 VSSD 0.117345f
C5773 VDDD.n2194 VSSD 0.130384f
C5774 VDDD.n2195 VSSD 0.117345f
C5775 VDDD.n2196 VSSD 0.130384f
C5776 VDDD.n2197 VSSD 0.117345f
C5777 VDDD.n2198 VSSD 0.130384f
C5778 VDDD.n2199 VSSD 0.117345f
C5779 VDDD.n2200 VSSD 0.139351f
C5780 VDDD.n2201 VSSD 0.582052f
C5781 VDDD.n2202 VSSD 0.117345f
C5782 VDDD.n2203 VSSD 0.117345f
C5783 VDDD.n2204 VSSD 0.117345f
C5784 VDDD.n2205 VSSD 0.130384f
C5785 VDDD.n2206 VSSD 0.130384f
C5786 VDDD.n2207 VSSD 0.130384f
C5787 VDDD.n2208 VSSD 0.117345f
C5788 VDDD.n2209 VSSD 0.117345f
C5789 VDDD.n2210 VSSD 0.117345f
C5790 VDDD.n2211 VSSD 0.130384f
C5791 VDDD.n2212 VSSD 0.130384f
C5792 VDDD.n2213 VSSD 0.130384f
C5793 VDDD.n2214 VSSD 0.117345f
C5794 VDDD.n2215 VSSD 0.117345f
C5795 VDDD.n2216 VSSD 0.117345f
C5796 VDDD.n2217 VSSD 0.130384f
C5797 VDDD.n2218 VSSD 0.130384f
C5798 VDDD.n2219 VSSD 0.130384f
C5799 VDDD.n2220 VSSD 0.117345f
C5800 VDDD.n2221 VSSD 0.117345f
C5801 VDDD.n2222 VSSD 0.117345f
C5802 VDDD.n2223 VSSD 0.130384f
C5803 VDDD.n2224 VSSD 0.130384f
C5804 VDDD.n2225 VSSD 0.130384f
C5805 VDDD.n2226 VSSD 0.117345f
C5806 VDDD.n2227 VSSD 0.117345f
C5807 VDDD.n2228 VSSD 0.117345f
C5808 VDDD.n2229 VSSD 0.130384f
C5809 VDDD.n2230 VSSD 0.130384f
C5810 VDDD.n2231 VSSD 0.130384f
C5811 VDDD.n2232 VSSD 0.117345f
C5812 VDDD.n2233 VSSD 0.117345f
C5813 VDDD.n2234 VSSD 0.117345f
C5814 VDDD.n2235 VSSD 0.130384f
C5815 VDDD.n2236 VSSD 0.130384f
C5816 VDDD.n2237 VSSD 0.130384f
C5817 VDDD.n2238 VSSD 0.117345f
C5818 VDDD.n2239 VSSD 0.117345f
C5819 VDDD.n2240 VSSD 0.260767f
C5820 VDDD.n2241 VSSD 0.119238f
C5821 VDDD.n2242 VSSD 0.119238f
C5822 VDDD.n2243 VSSD 5.27412f
C5823 VDDD.n2245 VSSD 0.091269f
C5824 VDDD.n2247 VSSD 0.147985f
C5825 VDDD.n2249 VSSD 5.31983f
C5826 VDDD.n2250 VSSD 1.37418f
C5827 VDDD.n2251 VSSD 0.624536f
C5828 VDDD.t367 VSSD 0.035134f
C5829 VDDD.t167 VSSD 0.34553f
C5830 VDDD.n2252 VSSD 0.363433f
C5831 VDDD.t560 VSSD 0.761009f
C5832 VDDD.t502 VSSD 0.705018f
C5833 VDDD.t246 VSSD 0.64666f
C5834 VDDD.t105 VSSD 0.64666f
C5835 VDDD.t594 VSSD 0.686091f
C5836 VDDD.t332 VSSD 1.02519f
C5837 VDDD.t329 VSSD 1.11983f
C5838 VDDD.t573 VSSD 0.780724f
C5839 VDDD.t570 VSSD 0.641929f
C5840 VDDD.t237 VSSD 0.641929f
C5841 VDDD.t498 VSSD 0.630888f
C5842 VDDD.t559 VSSD 0.581206f
C5843 VDDD.n2253 VSSD 0.805129f
C5844 VDDD.t330 VSSD 0.282634f
C5845 VDDD.n2254 VSSD 0.197689f
C5846 VDDD.t442 VSSD 0.227624f
C5847 VDDD.n2255 VSSD 0.189086f
C5848 VDDD.n2256 VSSD 0.337741f
C5849 VDDD.t144 VSSD 0.227765f
C5850 VDDD.n2257 VSSD 0.336791f
C5851 VDDD.t366 VSSD 0.369182f
C5852 VDDD.n2258 VSSD 0.289607f
C5853 VDDD.n2259 VSSD 1.13997f
C5854 VDDD.n2260 VSSD 1.4819f
C5855 VDDD.n2261 VSSD 2.50405f
C5856 VDDD.t499 VSSD 0.049965f
C5857 VDDD.n2262 VSSD 2.54768f
C5858 VDDD.t571 VSSD 0.049965f
C5859 VDDD.n2263 VSSD 3.76886f
C5860 VDDD.t595 VSSD 0.049965f
C5861 VDDD.n2264 VSSD 3.79545f
C5862 VDDD.t247 VSSD 0.049965f
C5863 VDDD.n2265 VSSD 2.783f
C5864 VDDD.n2266 VSSD 2.32627f
C5865 VDDD.n2267 VSSD 0.700875f
C5866 VDDD.n2268 VSSD 0.365915f
C5867 VDDD.n2269 VSSD 1.24709f
C5868 VDDD.n2270 VSSD 0.029743f
C5869 VDDD.n2271 VSSD 0.036649f
C5870 VDDD.n2272 VSSD 0.052668f
C5871 VDDD.n2273 VSSD 0.038149f
C5872 VDDD.n2274 VSSD 0.013144f
C5873 VDDD.n2275 VSSD 0.326751f
C5874 VDDD.t540 VSSD 0.593208f
C5875 VDDD.n2276 VSSD 0.452864f
C5876 VDDD.t45 VSSD 0.714178f
C5877 VDDD.n2277 VSSD 0.505259f
C5878 VDDD.t157 VSSD 0.035134f
C5879 VDDD.n2278 VSSD 0.055592f
C5880 VDDD.n2279 VSSD 0.052668f
C5881 VDDD.n2280 VSSD 0.036649f
C5882 VDDD.n2281 VSSD 0.038727f
C5883 VDDD.t156 VSSD 0.280783f
C5884 VDDD.n2282 VSSD 0.038727f
C5885 VDDD.n2283 VSSD 0.365915f
C5886 VDDD.n2284 VSSD 1.54073f
C5887 VDDD.n2285 VSSD 1.37223f
C5888 VDDD.n2286 VSSD 0.130384f
C5889 VDDD.n2287 VSSD 0.130384f
C5890 VDDD.n2288 VSSD 0.045634f
C5891 VDDD.n2289 VSSD 7.02e-19
C5892 VDDD.n2290 VSSD 0.045596f
C5893 VDDD.n2291 VSSD 0.014342f
C5894 VDDD.n2292 VSSD 0.045634f
C5895 VDDD.n2293 VSSD 0.045634f
C5896 VDDD.n2294 VSSD 0.097788f
C5897 VDDD.n2295 VSSD 0.072363f
C5898 VDDD.n2296 VSSD 0.097788f
C5899 VDDD.n2297 VSSD 0.130384f
C5900 VDDD.n2298 VSSD 0.130384f
C5901 VDDD.n2299 VSSD 0.045634f
C5902 VDDD.n2300 VSSD 0.045634f
C5903 VDDD.n2301 VSSD 1.33811f
C5904 VDDD.n2302 VSSD 0.056675f
C5905 VDDD.n2303 VSSD 0.056873f
C5906 VDDD.n2304 VSSD 3.52983f
C5907 VDDD.n2310 VSSD 0.147207f
C5908 VDDD.n2311 VSSD 3.57531f
C5909 VDDD.n2312 VSSD 1.37418f
C5910 VDDD.n2313 VSSD 0.624536f
C5911 VDDD.t314 VSSD 0.035134f
C5912 VDDD.t388 VSSD 0.34553f
C5913 VDDD.n2314 VSSD 0.363433f
C5914 VDDD.t38 VSSD 0.761009f
C5915 VDDD.t59 VSSD 0.705018f
C5916 VDDD.t386 VSSD 0.64666f
C5917 VDDD.t91 VSSD 0.64666f
C5918 VDDD.t417 VSSD 0.686091f
C5919 VDDD.t188 VSSD 1.02519f
C5920 VDDD.t189 VSSD 1.11983f
C5921 VDDD.t401 VSSD 0.780724f
C5922 VDDD.t266 VSSD 0.641929f
C5923 VDDD.t534 VSSD 0.641929f
C5924 VDDD.t57 VSSD 0.630888f
C5925 VDDD.t39 VSSD 0.581206f
C5926 VDDD.n2315 VSSD 0.805129f
C5927 VDDD.t186 VSSD 0.282634f
C5928 VDDD.n2316 VSSD 0.197689f
C5929 VDDD.t406 VSSD 0.227624f
C5930 VDDD.n2317 VSSD 0.189086f
C5931 VDDD.n2318 VSSD 0.337741f
C5932 VDDD.t15 VSSD 0.227765f
C5933 VDDD.n2319 VSSD 0.336791f
C5934 VDDD.t313 VSSD 0.369182f
C5935 VDDD.n2320 VSSD 0.289607f
C5936 VDDD.n2321 VSSD 1.13997f
C5937 VDDD.n2322 VSSD 1.4819f
C5938 VDDD.n2323 VSSD 2.50405f
C5939 VDDD.t58 VSSD 0.049965f
C5940 VDDD.n2324 VSSD 2.54768f
C5941 VDDD.t267 VSSD 0.049965f
C5942 VDDD.n2325 VSSD 3.76886f
C5943 VDDD.t418 VSSD 0.049965f
C5944 VDDD.n2326 VSSD 3.79545f
C5945 VDDD.t387 VSSD 0.049965f
C5946 VDDD.n2327 VSSD 2.783f
C5947 VDDD.n2328 VSSD 2.32627f
C5948 VDDD.n2329 VSSD 0.700875f
C5949 VDDD.n2330 VSSD 0.365915f
C5950 VDDD.n2331 VSSD 1.24709f
C5951 VDDD.n2332 VSSD 0.029743f
C5952 VDDD.n2333 VSSD 0.036649f
C5953 VDDD.n2334 VSSD 0.052668f
C5954 VDDD.n2335 VSSD 0.038149f
C5955 VDDD.n2336 VSSD 0.013144f
C5956 VDDD.n2337 VSSD 0.326751f
C5957 VDDD.t22 VSSD 0.593208f
C5958 VDDD.n2338 VSSD 0.452864f
C5959 VDDD.t408 VSSD 0.714178f
C5960 VDDD.n2339 VSSD 0.505259f
C5961 VDDD.t47 VSSD 0.035134f
C5962 VDDD.n2340 VSSD 0.055592f
C5963 VDDD.n2341 VSSD 0.052668f
C5964 VDDD.n2342 VSSD 0.036649f
C5965 VDDD.n2343 VSSD 0.038727f
C5966 VDDD.t46 VSSD 0.280783f
C5967 VDDD.n2344 VSSD 0.038727f
C5968 VDDD.n2345 VSSD 0.365915f
C5969 VDDD.n2346 VSSD 1.54073f
C5970 VDDD.n2347 VSSD 1.37223f
C5971 VDDD.n2348 VSSD 0.130384f
C5972 VDDD.n2349 VSSD 0.130384f
C5973 VDDD.n2350 VSSD 0.045634f
C5974 VDDD.n2351 VSSD 7.02e-19
C5975 VDDD.n2352 VSSD 0.045596f
C5976 VDDD.n2353 VSSD 0.014342f
C5977 VDDD.n2354 VSSD 0.045634f
C5978 VDDD.n2355 VSSD 0.045634f
C5979 VDDD.n2356 VSSD 0.097788f
C5980 VDDD.n2357 VSSD 0.072363f
C5981 VDDD.n2358 VSSD 0.097788f
C5982 VDDD.n2359 VSSD 0.130384f
C5983 VDDD.n2360 VSSD 0.130384f
C5984 VDDD.n2361 VSSD 0.045634f
C5985 VDDD.n2362 VSSD 0.045634f
C5986 VDDD.n2363 VSSD 1.33811f
C5987 VDDD.n2364 VSSD 0.056675f
C5988 VDDD.n2365 VSSD 0.056873f
C5989 VDDD.n2366 VSSD 3.52983f
C5990 VDDD.n2372 VSSD 0.147207f
C5991 VDDD.n2373 VSSD 3.57531f
C5992 VDDD.n2374 VSSD 1.37418f
C5993 VDDD.n2375 VSSD 0.624536f
C5994 VDDD.t361 VSSD 0.035134f
C5995 VDDD.t49 VSSD 0.34553f
C5996 VDDD.n2376 VSSD 0.363433f
C5997 VDDD.t125 VSSD 0.761009f
C5998 VDDD.t297 VSSD 0.705018f
C5999 VDDD.t51 VSSD 0.64666f
C6000 VDDD.t457 VSSD 0.64666f
C6001 VDDD.t419 VSSD 0.686091f
C6002 VDDD.t204 VSSD 1.02519f
C6003 VDDD.t205 VSSD 1.11983f
C6004 VDDD.t604 VSSD 0.780724f
C6005 VDDD.t183 VSSD 0.641929f
C6006 VDDD.t44 VSSD 0.641929f
C6007 VDDD.t142 VSSD 0.630888f
C6008 VDDD.t119 VSSD 0.581206f
C6009 VDDD.n2377 VSSD 0.805129f
C6010 VDDD.t202 VSSD 0.282634f
C6011 VDDD.n2378 VSSD 0.197689f
C6012 VDDD.t207 VSSD 0.227624f
C6013 VDDD.n2379 VSSD 0.189086f
C6014 VDDD.n2380 VSSD 0.337741f
C6015 VDDD.t435 VSSD 0.227765f
C6016 VDDD.n2381 VSSD 0.336791f
C6017 VDDD.t360 VSSD 0.369182f
C6018 VDDD.n2382 VSSD 0.289607f
C6019 VDDD.n2383 VSSD 1.13997f
C6020 VDDD.n2384 VSSD 1.4819f
C6021 VDDD.n2385 VSSD 2.50405f
C6022 VDDD.t143 VSSD 0.049965f
C6023 VDDD.n2386 VSSD 2.54768f
C6024 VDDD.t184 VSSD 0.049965f
C6025 VDDD.n2387 VSSD 3.76886f
C6026 VDDD.t420 VSSD 0.049965f
C6027 VDDD.n2388 VSSD 3.79545f
C6028 VDDD.t52 VSSD 0.049965f
C6029 VDDD.n2389 VSSD 2.783f
C6030 VDDD.n2390 VSSD 2.32627f
C6031 VDDD.n2391 VSSD 0.700875f
C6032 VDDD.n2392 VSSD 0.365915f
C6033 VDDD.n2393 VSSD 1.24709f
C6034 VDDD.n2394 VSSD 0.029743f
C6035 VDDD.n2395 VSSD 0.036649f
C6036 VDDD.n2396 VSSD 0.052668f
C6037 VDDD.n2397 VSSD 0.038149f
C6038 VDDD.n2398 VSSD 0.013144f
C6039 VDDD.n2399 VSSD 0.326751f
C6040 VDDD.t256 VSSD 0.593208f
C6041 VDDD.n2400 VSSD 0.452864f
C6042 VDDD.t450 VSSD 0.714178f
C6043 VDDD.n2401 VSSD 0.505259f
C6044 VDDD.t325 VSSD 0.035134f
C6045 VDDD.n2402 VSSD 0.055592f
C6046 VDDD.n2403 VSSD 0.052668f
C6047 VDDD.n2404 VSSD 0.036649f
C6048 VDDD.n2405 VSSD 0.038727f
C6049 VDDD.t324 VSSD 0.280783f
C6050 VDDD.n2406 VSSD 0.038727f
C6051 VDDD.n2407 VSSD 0.365915f
C6052 VDDD.n2408 VSSD 1.54073f
C6053 VDDD.n2409 VSSD 1.37223f
C6054 VDDD.n2410 VSSD 0.130384f
C6055 VDDD.n2411 VSSD 0.130384f
C6056 VDDD.n2412 VSSD 0.045634f
C6057 VDDD.n2413 VSSD 7.02e-19
C6058 VDDD.n2414 VSSD 0.045596f
C6059 VDDD.n2415 VSSD 0.014342f
C6060 VDDD.n2416 VSSD 0.045634f
C6061 VDDD.n2417 VSSD 0.045634f
C6062 VDDD.n2418 VSSD 0.097788f
C6063 VDDD.n2419 VSSD 0.072363f
C6064 VDDD.n2420 VSSD 0.097788f
C6065 VDDD.n2421 VSSD 0.130384f
C6066 VDDD.n2422 VSSD 0.130384f
C6067 VDDD.n2423 VSSD 0.045634f
C6068 VDDD.n2424 VSSD 0.045634f
C6069 VDDD.n2425 VSSD 1.33811f
C6070 VDDD.n2426 VSSD 0.056675f
C6071 VDDD.n2427 VSSD 0.056873f
C6072 VDDD.n2428 VSSD 3.52983f
C6073 VDDD.n2434 VSSD 0.147207f
C6074 VDDD.n2435 VSSD 3.57531f
C6075 VDDD.n2436 VSSD 1.37418f
C6076 VDDD.n2437 VSSD 0.624536f
C6077 VDDD.t241 VSSD 0.035134f
C6078 VDDD.t110 VSSD 0.34553f
C6079 VDDD.n2438 VSSD 0.363433f
C6080 VDDD.t431 VSSD 0.761009f
C6081 VDDD.t131 VSSD 0.705018f
C6082 VDDD.t112 VSSD 0.64666f
C6083 VDDD.t12 VSSD 0.64666f
C6084 VDDD.t425 VSSD 0.686091f
C6085 VDDD.t69 VSSD 1.02519f
C6086 VDDD.t70 VSSD 1.11983f
C6087 VDDD.t151 VSSD 0.780724f
C6088 VDDD.t412 VSSD 0.641929f
C6089 VDDD.t561 VSSD 0.641929f
C6090 VDDD.t566 VSSD 0.630888f
C6091 VDDD.t430 VSSD 0.581206f
C6092 VDDD.n2439 VSSD 0.805129f
C6093 VDDD.t71 VSSD 0.282634f
C6094 VDDD.n2440 VSSD 0.197689f
C6095 VDDD.t115 VSSD 0.227624f
C6096 VDDD.n2441 VSSD 0.189086f
C6097 VDDD.n2442 VSSD 0.337741f
C6098 VDDD.t160 VSSD 0.227765f
C6099 VDDD.n2443 VSSD 0.336791f
C6100 VDDD.t240 VSSD 0.369182f
C6101 VDDD.n2444 VSSD 0.289607f
C6102 VDDD.n2445 VSSD 1.13997f
C6103 VDDD.n2446 VSSD 1.4819f
C6104 VDDD.n2447 VSSD 2.50405f
C6105 VDDD.t567 VSSD 0.049965f
C6106 VDDD.n2448 VSSD 2.54768f
C6107 VDDD.t413 VSSD 0.049965f
C6108 VDDD.n2449 VSSD 3.76886f
C6109 VDDD.t426 VSSD 0.049965f
C6110 VDDD.n2450 VSSD 3.79545f
C6111 VDDD.t113 VSSD 0.049965f
C6112 VDDD.n2451 VSSD 2.783f
C6113 VDDD.n2452 VSSD 2.32627f
C6114 VDDD.n2453 VSSD 0.700875f
C6115 VDDD.n2454 VSSD 0.365915f
C6116 VDDD.n2455 VSSD 1.24709f
C6117 VDDD.n2456 VSSD 0.029743f
C6118 VDDD.n2457 VSSD 0.036649f
C6119 VDDD.n2458 VSSD 0.052668f
C6120 VDDD.n2459 VSSD 0.038149f
C6121 VDDD.n2460 VSSD 0.013144f
C6122 VDDD.n2461 VSSD 0.326751f
C6123 VDDD.t162 VSSD 0.593208f
C6124 VDDD.n2462 VSSD 0.452864f
C6125 VDDD.t114 VSSD 0.714178f
C6126 VDDD.n2463 VSSD 0.505259f
C6127 VDDD.t556 VSSD 0.035134f
C6128 VDDD.n2464 VSSD 0.055592f
C6129 VDDD.n2465 VSSD 0.052668f
C6130 VDDD.n2466 VSSD 0.036649f
C6131 VDDD.n2467 VSSD 0.038727f
C6132 VDDD.t555 VSSD 0.280783f
C6133 VDDD.n2468 VSSD 0.038727f
C6134 VDDD.n2469 VSSD 0.365915f
C6135 VDDD.n2470 VSSD 1.54073f
C6136 VDDD.n2471 VSSD 1.37223f
C6137 VDDD.n2472 VSSD 0.130384f
C6138 VDDD.n2473 VSSD 0.130384f
C6139 VDDD.n2474 VSSD 0.045634f
C6140 VDDD.n2475 VSSD 7.02e-19
C6141 VDDD.n2476 VSSD 0.045596f
C6142 VDDD.n2477 VSSD 0.014342f
C6143 VDDD.n2478 VSSD 0.045634f
C6144 VDDD.n2479 VSSD 0.045634f
C6145 VDDD.n2480 VSSD 0.097788f
C6146 VDDD.n2481 VSSD 0.072363f
C6147 VDDD.n2482 VSSD 0.097788f
C6148 VDDD.n2483 VSSD 0.130384f
C6149 VDDD.n2484 VSSD 0.130384f
C6150 VDDD.n2485 VSSD 0.045634f
C6151 VDDD.n2486 VSSD 0.045634f
C6152 VDDD.n2487 VSSD 1.33811f
C6153 VDDD.n2488 VSSD 0.056675f
C6154 VDDD.n2489 VSSD 0.056873f
C6155 VDDD.n2490 VSSD 3.52983f
C6156 VDDD.n2496 VSSD 0.147207f
C6157 VDDD.n2497 VSSD 3.57531f
C6158 VDDD.n2498 VSSD 1.37418f
C6159 VDDD.n2499 VSSD 0.624536f
C6160 VDDD.t371 VSSD 0.035134f
C6161 VDDD.t179 VSSD 0.34553f
C6162 VDDD.n2500 VSSD 0.363433f
C6163 VDDD.t177 VSSD 0.761009f
C6164 VDDD.t170 VSSD 0.705018f
C6165 VDDD.t181 VSSD 0.64666f
C6166 VDDD.t48 VSSD 0.64666f
C6167 VDDD.t538 VSSD 0.686091f
C6168 VDDD.t5 VSSD 1.02519f
C6169 VDDD.t0 VSSD 1.11983f
C6170 VDDD.t530 VSSD 0.780724f
C6171 VDDD.t342 VSSD 0.641929f
C6172 VDDD.t18 VSSD 0.641929f
C6173 VDDD.t136 VSSD 0.630888f
C6174 VDDD.t178 VSSD 0.581206f
C6175 VDDD.n2501 VSSD 0.805129f
C6176 VDDD.t6 VSSD 0.282634f
C6177 VDDD.n2502 VSSD 0.197689f
C6178 VDDD.t322 VSSD 0.227624f
C6179 VDDD.n2503 VSSD 0.189086f
C6180 VDDD.n2504 VSSD 0.337741f
C6181 VDDD.t238 VSSD 0.227765f
C6182 VDDD.n2505 VSSD 0.336791f
C6183 VDDD.t370 VSSD 0.369182f
C6184 VDDD.n2506 VSSD 0.289607f
C6185 VDDD.n2507 VSSD 1.13997f
C6186 VDDD.n2508 VSSD 1.4819f
C6187 VDDD.n2509 VSSD 2.50405f
C6188 VDDD.t137 VSSD 0.049965f
C6189 VDDD.n2510 VSSD 2.54768f
C6190 VDDD.t343 VSSD 0.049965f
C6191 VDDD.n2511 VSSD 3.76886f
C6192 VDDD.t539 VSSD 0.049965f
C6193 VDDD.n2512 VSSD 3.79545f
C6194 VDDD.t182 VSSD 0.049965f
C6195 VDDD.n2513 VSSD 2.783f
C6196 VDDD.n2514 VSSD 2.32627f
C6197 VDDD.n2515 VSSD 0.700875f
C6198 VDDD.n2516 VSSD 0.365915f
C6199 VDDD.n2517 VSSD 1.24709f
C6200 VDDD.n2518 VSSD 0.029743f
C6201 VDDD.n2519 VSSD 0.036649f
C6202 VDDD.n2520 VSSD 0.052668f
C6203 VDDD.n2521 VSSD 0.038149f
C6204 VDDD.n2522 VSSD 0.013144f
C6205 VDDD.n2523 VSSD 0.326751f
C6206 VDDD.t166 VSSD 0.593208f
C6207 VDDD.n2524 VSSD 0.452864f
C6208 VDDD.t304 VSSD 0.714178f
C6209 VDDD.n2525 VSSD 0.505259f
C6210 VDDD.t365 VSSD 0.035134f
C6211 VDDD.n2526 VSSD 0.055592f
C6212 VDDD.n2527 VSSD 0.052668f
C6213 VDDD.n2528 VSSD 0.036649f
C6214 VDDD.n2529 VSSD 0.038727f
C6215 VDDD.t364 VSSD 0.280783f
C6216 VDDD.n2530 VSSD 0.038727f
C6217 VDDD.n2531 VSSD 0.365915f
C6218 VDDD.n2532 VSSD 1.54073f
C6219 VDDD.n2533 VSSD 1.37223f
C6220 VDDD.n2534 VSSD 0.130384f
C6221 VDDD.n2535 VSSD 0.130384f
C6222 VDDD.n2536 VSSD 0.045634f
C6223 VDDD.n2537 VSSD 7.02e-19
C6224 VDDD.n2538 VSSD 0.045596f
C6225 VDDD.n2539 VSSD 0.014342f
C6226 VDDD.n2540 VSSD 0.045634f
C6227 VDDD.n2541 VSSD 0.045634f
C6228 VDDD.n2542 VSSD 0.097788f
C6229 VDDD.n2543 VSSD 0.072363f
C6230 VDDD.n2544 VSSD 0.097788f
C6231 VDDD.n2545 VSSD 0.130384f
C6232 VDDD.n2546 VSSD 0.130384f
C6233 VDDD.n2547 VSSD 0.045634f
C6234 VDDD.n2548 VSSD 0.045634f
C6235 VDDD.n2549 VSSD 1.33811f
C6236 VDDD.n2550 VSSD 0.056675f
C6237 VDDD.n2551 VSSD 0.056873f
C6238 VDDD.n2552 VSSD 18.523901f
C6239 VDDD.n2553 VSSD 0.260767f
C6240 VDDD.n2554 VSSD 0.260767f
C6241 VDDD.n2555 VSSD 0.260767f
C6242 VDDD.n2556 VSSD 0.260767f
C6243 VDDD.n2557 VSSD 0.260767f
C6244 VDDD.n2558 VSSD 0.260767f
C6245 VDDD.n2559 VSSD 0.130384f
C6246 VDDD.n2561 VSSD 0.260767f
C6247 VDDD.n2564 VSSD 0.260767f
C6248 VDDD.n2567 VSSD 0.260767f
C6249 VDDD.n2570 VSSD 0.260767f
C6250 VDDD.n2573 VSSD 0.260767f
C6251 VDDD.n2576 VSSD 0.260767f
C6252 VDDD.n2579 VSSD 0.130384f
C6253 VDDD.n2580 VSSD 0.130384f
C6254 VDDD.n2581 VSSD 0.130384f
C6255 VDDD.n2582 VSSD 0.130384f
C6256 VDDD.n2583 VSSD 0.130384f
C6257 VDDD.n2584 VSSD 0.130384f
C6258 VDDD.n2585 VSSD 0.130384f
C6259 VDDD.n2586 VSSD 0.130384f
C6260 VDDD.n2587 VSSD 0.130384f
C6261 VDDD.n2588 VSSD 0.130384f
C6262 VDDD.n2589 VSSD 0.130384f
C6263 VDDD.n2590 VSSD 0.130384f
C6264 VDDD.n2593 VSSD 0.130384f
C6265 VDDD.n2595 VSSD 0.130384f
C6266 VDDD.n2597 VSSD 0.130384f
C6267 VDDD.n2599 VSSD 0.130384f
C6268 VDDD.n2601 VSSD 0.130384f
C6269 VDDD.n2603 VSSD 0.130384f
C6270 VDDD.n2605 VSSD 0.130384f
C6271 VDDD.n2607 VSSD 0.130384f
C6272 VDDD.n2609 VSSD 0.130384f
C6273 VDDD.n2611 VSSD 0.130384f
C6274 VDDD.n2613 VSSD 0.130384f
C6275 VDDD.n2615 VSSD 0.130384f
C6276 VDDD.n2616 VSSD 0.407974f
C6277 VDDD.n2617 VSSD 18.523901f
C6278 VDDD.n2618 VSSD 13.2024f
C6279 VDDD.n2619 VSSD 0.130384f
C6280 VDDD.n2620 VSSD 0.130384f
C6281 VDDD.n2621 VSSD 0.130384f
C6282 VDDD.n2622 VSSD 0.130384f
C6283 VDDD.n2623 VSSD 0.130384f
C6284 VDDD.n2624 VSSD 0.130384f
C6285 VDDD.n2625 VSSD 0.130384f
C6286 VDDD.n2626 VSSD 0.130384f
C6287 VDDD.n2627 VSSD 0.130384f
C6288 VDDD.n2628 VSSD 0.130384f
C6289 VDDD.n2629 VSSD 0.130384f
C6290 VDDD.n2630 VSSD 0.130384f
C6291 VDDD.n2631 VSSD 0.130384f
C6292 VDDD.n2645 VSSD 0.576211f
C6293 VDDD.n2647 VSSD 0.260767f
C6294 VDDD.n2649 VSSD 0.260767f
C6295 VDDD.n2662 VSSD 0.260767f
C6296 VDDD.n2669 VSSD 0.130384f
C6297 VDDD.n2671 VSSD 0.260767f
C6298 VDDD.n2672 VSSD 0.342783f
C6299 VDDD.n2673 VSSD 13.2024f
C6300 VDDD.n2674 VSSD 2.49847f
C6301 VDDD.n2675 VSSD 2.54366f
C6302 VDDD.n2676 VSSD 0.147985f
C6303 VDDD.n2677 VSSD 0.147985f
C6304 VDDD.n2680 VSSD 0.091269f
C6305 VDDD.n2686 VSSD 0.091269f
C6306 VDDD.n2688 VSSD 0.147985f
C6307 VDDD.t215 VSSD 0.035134f
C6308 VDDD.n2690 VSSD 0.289607f
C6309 VDDD.t519 VSSD 0.035134f
C6310 VDDD.n2691 VSSD 0.064631f
C6311 VDDD.t312 VSSD 0.035134f
C6312 VDDD.n2692 VSSD 0.077772f
C6313 VDDD.t441 VSSD 0.035134f
C6314 VDDD.n2693 VSSD 0.077851f
C6315 VDDD.t26 VSSD 0.035134f
C6316 VDDD.n2694 VSSD 0.073685f
C6317 VDDD.t439 VSSD 0.035134f
C6318 VDDD.n2695 VSSD 0.055592f
C6319 VDDD.n2696 VSSD 1.24709f
C6320 VDDD.n2697 VSSD 0.038149f
C6321 VDDD.n2698 VSSD 0.038149f
C6322 VDDD.t549 VSSD 0.280783f
C6323 VDDD.n2699 VSSD 0.038727f
C6324 VDDD.n2700 VSSD 0.038727f
C6325 VDDD.t550 VSSD 0.035134f
C6326 VDDD.n2701 VSSD 0.055592f
C6327 VDDD.n2702 VSSD 1.24061f
C6328 VDDD.n2703 VSSD 0.365915f
C6329 VDDD.n2704 VSSD 1.54073f
C6330 VDDD.t73 VSSD 0.714178f
C6331 VDDD.n2705 VSSD 0.505259f
C6332 VDDD.n2706 VSSD 0.038149f
C6333 VDDD.n2707 VSSD 0.029743f
C6334 VDDD.n2708 VSSD 0.036649f
C6335 VDDD.n2709 VSSD 0.052668f
C6336 VDDD.n2710 VSSD 0.038149f
C6337 VDDD.n2711 VSSD 0.452864f
C6338 VDDD.t565 VSSD 0.593208f
C6339 VDDD.n2712 VSSD 0.029743f
C6340 VDDD.n2713 VSSD 0.052668f
C6341 VDDD.n2714 VSSD 0.036649f
C6342 VDDD.n2715 VSSD 0.246436f
C6343 VDDD.t311 VSSD 0.263364f
C6344 VDDD.n2716 VSSD 0.085091f
C6345 VDDD.t214 VSSD 0.369182f
C6346 VDDD.n2717 VSSD 0.336791f
C6347 VDDD.t518 VSSD 0.294356f
C6348 VDDD.n2718 VSSD 0.059327f
C6349 VDDD.t440 VSSD 0.191277f
C6350 VDDD.n2719 VSSD 0.194088f
C6351 VDDD.n2720 VSSD 0.521521f
C6352 VDDD.n2721 VSSD 0.658644f
C6353 VDDD.t345 VSSD 0.581206f
C6354 VDDD.t172 VSSD 0.630888f
C6355 VDDD.t107 VSSD 0.641929f
C6356 VDDD.t42 VSSD 0.641929f
C6357 VDDD.t601 VSSD 0.780724f
C6358 VDDD.t315 VSSD 1.11983f
C6359 VDDD.t310 VSSD 1.02519f
C6360 VDDD.t574 VSSD 0.686091f
C6361 VDDD.t532 VSSD 0.64666f
C6362 VDDD.t27 VSSD 0.64666f
C6363 VDDD.t259 VSSD 0.705018f
C6364 VDDD.t213 VSSD 0.761009f
C6365 VDDD.n2722 VSSD 0.363433f
C6366 VDDD.t25 VSSD 0.34553f
C6367 VDDD.n2723 VSSD 0.388226f
C6368 VDDD.n2724 VSSD 0.013144f
C6369 VDDD.n2725 VSSD 0.326751f
C6370 VDDD.t438 VSSD 0.154524f
C6371 VDDD.n2726 VSSD 0.249067f
C6372 VDDD.n2727 VSSD 0.365915f
C6373 VDDD.n2728 VSSD 0.700875f
C6374 VDDD.n2729 VSSD 2.32627f
C6375 VDDD.t28 VSSD 0.049965f
C6376 VDDD.n2730 VSSD 2.783f
C6377 VDDD.t575 VSSD 0.049965f
C6378 VDDD.n2731 VSSD 3.79545f
C6379 VDDD.t43 VSSD 0.049965f
C6380 VDDD.n2732 VSSD 3.76886f
C6381 VDDD.t173 VSSD 0.049965f
C6382 VDDD.n2733 VSSD 2.54768f
C6383 VDDD.n2734 VSSD 2.50405f
C6384 VDDD.n2735 VSSD 1.4819f
C6385 VDDD.n2736 VSSD 1.13997f
C6386 VDDD.n2737 VSSD 0.624536f
C6387 VDDD.n2739 VSSD 0.147207f
C6388 VDDD.n2741 VSSD 0.147985f
C6389 VDDD.n2742 VSSD 0.091269f
C6390 VDDD.n2743 VSSD 0.147985f
C6391 VDDD.n2744 VSSD 1.37418f
C6392 VDDD.n2748 VSSD 1.37418f
C6393 VDDD.n2750 VSSD 0.047851f
C6394 VDDD.n2751 VSSD 0.12071f
C6395 VDDD.n2752 VSSD 0.594276f
C6396 VDDD.t2 VSSD 0.035134f
C6397 VDDD.t524 VSSD 1.35593f
C6398 VDDD.n2753 VSSD 1.03422f
C6399 VDDD.t473 VSSD 0.329366f
C6400 VDDD.n2754 VSSD 0.29943f
C6401 VDDD.t335 VSSD 0.601391f
C6402 VDDD.t515 VSSD 0.87619f
C6403 VDDD.t510 VSSD 0.630888f
C6404 VDDD.t230 VSSD 0.641929f
C6405 VDDD.t92 VSSD 0.641929f
C6406 VDDD.t154 VSSD 0.780724f
C6407 VDDD.t333 VSSD 1.11983f
C6408 VDDD.t334 VSSD 1.02519f
C6409 VDDD.t576 VSSD 0.686091f
C6410 VDDD.t17 VSSD 0.64666f
C6411 VDDD.t3 VSSD 0.64666f
C6412 VDDD.t501 VSSD 0.705018f
C6413 VDDD.t564 VSSD 0.770701f
C6414 VDDD.t1 VSSD 0.202843f
C6415 VDDD.n2755 VSSD 0.236569f
C6416 VDDD.n2756 VSSD 0.066479f
C6417 VDDD.n2757 VSSD 1.22687f
C6418 VDDD.t4 VSSD 0.049949f
C6419 VDDD.n2758 VSSD 0.98744f
C6420 VDDD.n2759 VSSD 1.34049f
C6421 VDDD.t93 VSSD 0.049949f
C6422 VDDD.n2760 VSSD 1.32347f
C6423 VDDD.t511 VSSD 0.049949f
C6424 VDDD.n2761 VSSD 0.86f
C6425 VDDD.n2762 VSSD 0.660804f
C6426 VDDD.n2763 VSSD 1.1952f
C6427 VDDD.n2764 VSSD 1.16338f
C6428 VDDD.n2765 VSSD 0.046547f
C6429 VDDD.n2766 VSSD 0.045634f
C6430 VDDD.n2767 VSSD 0.045634f
C6431 VDDD.n2768 VSSD 0.045634f
C6432 VDDD.n2769 VSSD 0.045634f
C6433 VDDD.n2770 VSSD 0.045634f
C6434 VDDD.n2771 VSSD 0.045634f
C6435 VDDD.n2772 VSSD 0.045634f
C6436 VDDD.n2773 VSSD 0.132516f
C6437 VDDD.n2774 VSSD 0.059859f
C6438 VDDD.n2775 VSSD 0.05721f
C6439 VDDD.n2777 VSSD 0.131014f
C6440 VDDD.n2778 VSSD 0.056675f
C6441 VDDD.n2779 VSSD 1.33811f
C6442 VDDD.n2780 VSSD 1.33811f
C6443 VDDD.n2781 VSSD 0.091269f
C6444 VDDD.n2783 VSSD 0.045634f
C6445 VDDD.n2785 VSSD 0.045634f
C6446 VDDD.n2791 VSSD 0.091269f
C6447 VDDD.n2793 VSSD 0.045634f
C6448 VDDD.n2797 VSSD 0.091269f
C6449 VDDD.n2799 VSSD 0.045634f
C6450 VDDD.n2800 VSSD 0.135431f
C6451 VDDD.n2802 VSSD 0.056675f
C6452 VDDD.n2803 VSSD 0.056873f
C6453 VDDD.n2804 VSSD 7.02e-19
C6454 VDDD.n2805 VSSD 0.045596f
C6455 VDDD.n2806 VSSD 0.045634f
C6456 VDDD.n2807 VSSD 0.130384f
C6457 VDDD.n2808 VSSD 0.130384f
C6458 VDDD.n2809 VSSD 0.097788f
C6459 VDDD.n2810 VSSD 0.045634f
C6460 VDDD.n2811 VSSD 0.010757f
C6461 VDDD.n2812 VSSD 0.045634f
C6462 VDDD.n2813 VSSD 0.097788f
C6463 VDDD.n2814 VSSD 0.130384f
C6464 VDDD.n2815 VSSD 0.130384f
C6465 VDDD.n2816 VSSD 0.045634f
C6466 VDDD.n2817 VSSD 0.045596f
C6467 VDDD.n2818 VSSD 7.02e-19
C6468 VDDD.n2819 VSSD 0.056873f
C6469 VDDD.n2820 VSSD 2.21862f
C6470 a_70950_n314.n0 VSSD 1.4589f
C6471 a_70950_n314.t3 VSSD 0.075381f
C6472 a_70950_n314.t2 VSSD 0.075169f
C6473 a_70950_n314.n1 VSSD 0.480219f
C6474 a_70950_n314.t5 VSSD 0.095963f
C6475 a_70950_n314.t6 VSSD 0.044581f
C6476 a_70950_n314.t4 VSSD 0.658502f
C6477 a_70950_n314.t0 VSSD 0.246654f
C6478 a_70950_n314.n2 VSSD 2.44953f
C6479 a_70950_n314.n3 VSSD 0.872922f
C6480 a_70950_n314.t1 VSSD 0.84218f
C6481 a_67902_n82.n0 VSSD 1.29327f
C6482 a_67902_n82.t7 VSSD 0.038174f
C6483 a_67902_n82.t5 VSSD 0.090059f
C6484 a_67902_n82.n1 VSSD 0.298372f
C6485 a_67902_n82.t1 VSSD 0.147143f
C6486 a_67902_n82.t6 VSSD 0.1636f
C6487 a_67902_n82.t2 VSSD 0.130517f
C6488 a_67902_n82.n2 VSSD 2.29806f
C6489 a_67902_n82.t3 VSSD 0.128166f
C6490 a_67902_n82.n3 VSSD 1.28395f
C6491 a_67902_n82.t4 VSSD 0.088697f
C6492 a_67902_n82.n4 VSSD 1.24258f
C6493 a_67902_n82.t0 VSSD 0.397411f
.ends
