v {xschem version=3.4.0 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
N -20 -40 50 -40 {
lab=VB}
N 190 -40 260 -40 {
lab=VB}
N 410 -40 480 -40 {
lab=VB}
N 630 -40 700 -40 {
lab=VB}
N 120 -40 150 -40 {
lab=VG}
N 340 -40 370 -40 {
lab=VG}
N 560 -40 590 -40 {
lab=VG}
N -20 -130 -20 -70 {
lab=#net1}
N -20 -130 620 -130 {
lab=#net1}
N 630 -130 630 -70 {
lab=#net1}
N 620 -130 630 -130 {
lab=#net1}
N 410 -130 410 -70 {
lab=#net1}
N 190 -130 190 -70 {
lab=#net1}
N -20 -10 -20 40 {
lab=#net2}
N -20 40 630 40 {
lab=#net2}
N 630 -10 630 40 {
lab=#net2}
N 410 -10 410 40 {
lab=#net2}
N 190 -10 190 40 {
lab=#net2}
N -120 -40 -60 -40 {
lab=VG}
N 840 -40 910 -40 {
lab=VB}
N 1050 -40 1120 -40 {
lab=VB}
N 1270 -40 1340 -40 {
lab=VB}
N 1490 -40 1560 -40 {
lab=VB}
N 980 -40 1010 -40 {
lab=VG}
N 1200 -40 1230 -40 {
lab=VG}
N 1420 -40 1450 -40 {
lab=VG}
N 840 -130 840 -70 {
lab=#net1}
N 840 -130 1480 -130 {
lab=#net1}
N 1490 -130 1490 -70 {
lab=#net1}
N 1480 -130 1490 -130 {
lab=#net1}
N 1270 -130 1270 -70 {
lab=#net1}
N 1050 -130 1050 -70 {
lab=#net1}
N 840 -10 840 40 {
lab=#net2}
N 840 40 1490 40 {
lab=#net2}
N 1490 -10 1490 40 {
lab=#net2}
N 1270 -10 1270 40 {
lab=#net2}
N 1050 -10 1050 40 {
lab=#net2}
N 740 -40 800 -40 {
lab=VG}
N 630 -130 840 -130 {}
N 630 40 840 40 {}
N 1730 -40 1800 -40 {
lab=VB}
N 1940 -40 2010 -40 {
lab=VB}
N 2160 -40 2230 -40 {
lab=VB}
N 2380 -40 2450 -40 {
lab=VB}
N 1870 -40 1900 -40 {
lab=VG}
N 2090 -40 2120 -40 {
lab=VG}
N 2310 -40 2340 -40 {
lab=VG}
N 1730 -130 1730 -70 {
lab=#net1}
N 1730 -130 2370 -130 {
lab=#net1}
N 2380 -130 2380 -70 {
lab=#net1}
N 2370 -130 2380 -130 {
lab=#net1}
N 2160 -130 2160 -70 {
lab=#net1}
N 1940 -130 1940 -70 {
lab=#net1}
N 1730 -10 1730 40 {
lab=#net2}
N 1730 40 2380 40 {
lab=#net2}
N 2380 -10 2380 40 {
lab=#net2}
N 2160 -10 2160 40 {
lab=#net2}
N 1940 -10 1940 40 {
lab=#net2}
N 1630 -40 1690 -40 {
lab=VG}
N 2590 -40 2660 -40 {
lab=VB}
N 2800 -40 2870 -40 {
lab=VB}
N 3020 -40 3090 -40 {
lab=VB}
N 3240 -40 3310 -40 {
lab=VB}
N 2730 -40 2760 -40 {
lab=VG}
N 2950 -40 2980 -40 {
lab=VG}
N 3170 -40 3200 -40 {
lab=VG}
N 2590 -130 2590 -70 {
lab=#net1}
N 2590 -130 3230 -130 {
lab=#net1}
N 3240 -130 3240 -70 {
lab=#net1}
N 3230 -130 3240 -130 {
lab=#net1}
N 3020 -130 3020 -70 {
lab=#net1}
N 2800 -130 2800 -70 {
lab=#net1}
N 2590 -10 2590 40 {
lab=#net2}
N 2590 40 3240 40 {
lab=#net2}
N 3240 -10 3240 40 {
lab=#net2}
N 3020 -10 3020 40 {
lab=#net2}
N 2800 -10 2800 40 {
lab=#net2}
N 2490 -40 2550 -40 {
lab=VG}
N 2380 -130 2590 -130 {}
N 2380 40 2590 40 {}
N 3470 -40 3540 -40 {
lab=VB}
N 3680 -40 3750 -40 {
lab=VB}
N 3900 -40 3970 -40 {
lab=VB}
N 4120 -40 4190 -40 {
lab=VB}
N 3610 -40 3640 -40 {
lab=VG}
N 3830 -40 3860 -40 {
lab=VG}
N 4050 -40 4080 -40 {
lab=VG}
N 3470 -130 3470 -70 {
lab=#net1}
N 3470 -130 4110 -130 {
lab=#net1}
N 4120 -130 4120 -70 {
lab=#net1}
N 4110 -130 4120 -130 {
lab=#net1}
N 3900 -130 3900 -70 {
lab=#net1}
N 3680 -130 3680 -70 {
lab=#net1}
N 3470 -10 3470 40 {
lab=#net2}
N 3470 40 4120 40 {
lab=#net2}
N 4120 -10 4120 40 {
lab=#net2}
N 3900 -10 3900 40 {
lab=#net2}
N 3680 -10 3680 40 {
lab=#net2}
N 3370 -40 3430 -40 {
lab=VG}
N 4330 -40 4400 -40 {
lab=VB}
N 4540 -40 4610 -40 {
lab=VB}
N 4760 -40 4830 -40 {
lab=VB}
N 4980 -40 5050 -40 {
lab=VB}
N 4470 -40 4500 -40 {
lab=VG}
N 4690 -40 4720 -40 {
lab=VG}
N 4910 -40 4940 -40 {
lab=VG}
N 4330 -130 4330 -70 {
lab=#net1}
N 4330 -130 4970 -130 {
lab=#net1}
N 4980 -130 4980 -70 {
lab=#net1}
N 4970 -130 4980 -130 {
lab=#net1}
N 4760 -130 4760 -70 {
lab=#net1}
N 4540 -130 4540 -70 {
lab=#net1}
N 4330 -10 4330 40 {
lab=#net2}
N 4330 40 4980 40 {
lab=#net2}
N 4980 -10 4980 40 {
lab=#net2}
N 4760 -10 4760 40 {
lab=#net2}
N 4540 -10 4540 40 {
lab=#net2}
N 4230 -40 4290 -40 {
lab=VG}
N 4120 -130 4330 -130 {}
N 4120 40 4330 40 {}
N 5220 -40 5290 -40 {
lab=VB}
N 5430 -40 5500 -40 {
lab=VB}
N 5650 -40 5720 -40 {
lab=VB}
N 5870 -40 5940 -40 {
lab=VB}
N 5360 -40 5390 -40 {
lab=VG}
N 5580 -40 5610 -40 {
lab=VG}
N 5800 -40 5830 -40 {
lab=VG}
N 5220 -130 5220 -70 {
lab=#net1}
N 5220 -130 5860 -130 {
lab=#net1}
N 5870 -130 5870 -70 {
lab=#net1}
N 5860 -130 5870 -130 {
lab=#net1}
N 5650 -130 5650 -70 {
lab=#net1}
N 5430 -130 5430 -70 {
lab=#net1}
N 5220 -10 5220 40 {
lab=#net2}
N 5220 40 5870 40 {
lab=#net2}
N 5870 -10 5870 40 {
lab=#net2}
N 5650 -10 5650 40 {
lab=#net2}
N 5430 -10 5430 40 {
lab=#net2}
N 5120 -40 5180 -40 {
lab=VG}
N 6080 -40 6150 -40 {
lab=VB}
N 6290 -40 6360 -40 {
lab=VB}
N 6510 -40 6580 -40 {
lab=VB}
N 6730 -40 6800 -40 {
lab=VB}
N 6220 -40 6250 -40 {
lab=VG}
N 6440 -40 6470 -40 {
lab=VG}
N 6660 -40 6690 -40 {
lab=VG}
N 6080 -130 6080 -70 {
lab=#net1}
N 6080 -130 6720 -130 {
lab=#net1}
N 6730 -130 6730 -70 {
lab=#net1}
N 6720 -130 6730 -130 {
lab=#net1}
N 6510 -130 6510 -70 {
lab=#net1}
N 6290 -130 6290 -70 {
lab=#net1}
N 6080 -10 6080 40 {
lab=#net2}
N 6080 40 6730 40 {
lab=#net2}
N 6730 -10 6730 40 {
lab=#net2}
N 6510 -10 6510 40 {
lab=#net2}
N 6290 -10 6290 40 {
lab=#net2}
N 5980 -40 6040 -40 {
lab=VG}
N 5870 -130 6080 -130 {}
N 5870 40 6080 40 {}
N 6960 -40 7030 -40 {
lab=VB}
N 7170 -40 7240 -40 {
lab=VB}
N 7390 -40 7460 -40 {
lab=VB}
N 7610 -40 7680 -40 {
lab=VB}
N 7100 -40 7130 -40 {
lab=VG}
N 7320 -40 7350 -40 {
lab=VG}
N 7540 -40 7570 -40 {
lab=VG}
N 6960 -130 6960 -70 {
lab=#net1}
N 6960 -130 7600 -130 {
lab=#net1}
N 7610 -130 7610 -70 {
lab=#net1}
N 7600 -130 7610 -130 {
lab=#net1}
N 7390 -130 7390 -70 {
lab=#net1}
N 7170 -130 7170 -70 {
lab=#net1}
N 6960 -10 6960 40 {
lab=#net2}
N 6960 40 7610 40 {
lab=#net2}
N 7610 -10 7610 40 {
lab=#net2}
N 7390 -10 7390 40 {
lab=#net2}
N 7170 -10 7170 40 {
lab=#net2}
N 6860 -40 6920 -40 {
lab=VG}
N 7820 -40 7890 -40 {
lab=VB}
N 8030 -40 8100 -40 {
lab=VB}
N 8250 -40 8320 -40 {
lab=VB}
N 8470 -40 8540 -40 {
lab=VB}
N 7960 -40 7990 -40 {
lab=VG}
N 8180 -40 8210 -40 {
lab=VG}
N 8400 -40 8430 -40 {
lab=VG}
N 7820 -130 7820 -70 {
lab=#net1}
N 7820 -130 8460 -130 {
lab=#net1}
N 8470 -130 8470 -70 {
lab=#net1}
N 8460 -130 8470 -130 {
lab=#net1}
N 8250 -130 8250 -70 {
lab=#net1}
N 8030 -130 8030 -70 {
lab=#net1}
N 7820 -10 7820 40 {
lab=#net2}
N 7820 40 8470 40 {
lab=#net2}
N 8470 -10 8470 40 {
lab=#net2}
N 8250 -10 8250 40 {
lab=#net2}
N 8030 -10 8030 40 {
lab=#net2}
N 7720 -40 7780 -40 {
lab=VG}
N 7610 -130 7820 -130 {}
N 7610 40 7820 40 {}
N 8710 -40 8780 -40 {
lab=VB}
N 8920 -40 8990 -40 {
lab=VB}
N 9140 -40 9210 -40 {
lab=VB}
N 9360 -40 9430 -40 {
lab=VB}
N 8850 -40 8880 -40 {
lab=VG}
N 9070 -40 9100 -40 {
lab=VG}
N 9290 -40 9320 -40 {
lab=VG}
N 8710 -130 8710 -70 {
lab=#net1}
N 8710 -130 9350 -130 {
lab=#net1}
N 9360 -130 9360 -70 {
lab=#net1}
N 9350 -130 9360 -130 {
lab=#net1}
N 9140 -130 9140 -70 {
lab=#net1}
N 8920 -130 8920 -70 {
lab=#net1}
N 8710 -10 8710 40 {
lab=#net2}
N 8710 40 9360 40 {
lab=#net2}
N 9360 -10 9360 40 {
lab=#net2}
N 9140 -10 9140 40 {
lab=#net2}
N 8920 -10 8920 40 {
lab=#net2}
N 8610 -40 8670 -40 {
lab=VG}
N 9570 -40 9640 -40 {
lab=VB}
N 9780 -40 9850 -40 {
lab=VB}
N 10000 -40 10070 -40 {
lab=VB}
N 10220 -40 10290 -40 {
lab=VB}
N 9710 -40 9740 -40 {
lab=VG}
N 9930 -40 9960 -40 {
lab=VG}
N 10150 -40 10180 -40 {
lab=VG}
N 9570 -130 9570 -70 {
lab=#net1}
N 9570 -130 10210 -130 {
lab=#net1}
N 10220 -130 10220 -70 {
lab=#net1}
N 10210 -130 10220 -130 {
lab=#net1}
N 10000 -130 10000 -70 {
lab=#net1}
N 9780 -130 9780 -70 {
lab=#net1}
N 9570 -10 9570 40 {
lab=#net2}
N 9570 40 10220 40 {
lab=#net2}
N 10220 -10 10220 40 {
lab=#net2}
N 10000 -10 10000 40 {
lab=#net2}
N 9780 -10 9780 40 {
lab=#net2}
N 9470 -40 9530 -40 {
lab=VG}
N 9360 -130 9570 -130 {}
N 9360 40 9570 40 {}
N 10450 -40 10520 -40 {
lab=VB}
N 10660 -40 10730 -40 {
lab=VB}
N 10880 -40 10950 -40 {
lab=VB}
N 11100 -40 11170 -40 {
lab=VB}
N 10590 -40 10620 -40 {
lab=VG}
N 10810 -40 10840 -40 {
lab=VG}
N 11030 -40 11060 -40 {
lab=VG}
N 10450 -130 10450 -70 {
lab=#net1}
N 10450 -130 11090 -130 {
lab=#net1}
N 11100 -130 11100 -70 {
lab=#net1}
N 11090 -130 11100 -130 {
lab=#net1}
N 10880 -130 10880 -70 {
lab=#net1}
N 10660 -130 10660 -70 {
lab=#net1}
N 10450 -10 10450 40 {
lab=#net2}
N 10450 40 11100 40 {
lab=#net2}
N 11100 -10 11100 40 {
lab=#net2}
N 10880 -10 10880 40 {
lab=#net2}
N 10660 -10 10660 40 {
lab=#net2}
N 10350 -40 10410 -40 {
lab=VG}
N 11310 -40 11380 -40 {
lab=VB}
N 11520 -40 11590 -40 {
lab=VB}
N 11740 -40 11810 -40 {
lab=VB}
N 11960 -40 12030 -40 {
lab=VB}
N 11450 -40 11480 -40 {
lab=VG}
N 11670 -40 11700 -40 {
lab=VG}
N 11890 -40 11920 -40 {
lab=VG}
N 11310 -130 11310 -70 {
lab=#net1}
N 11310 -130 11950 -130 {
lab=#net1}
N 11960 -130 11960 -70 {
lab=#net1}
N 11950 -130 11960 -130 {
lab=#net1}
N 11740 -130 11740 -70 {
lab=#net1}
N 11520 -130 11520 -70 {
lab=#net1}
N 11310 -10 11310 40 {
lab=#net2}
N 11310 40 11960 40 {
lab=#net2}
N 11960 -10 11960 40 {
lab=#net2}
N 11740 -10 11740 40 {
lab=#net2}
N 11520 -10 11520 40 {
lab=#net2}
N 11210 -40 11270 -40 {
lab=VG}
N 11100 -130 11310 -130 {}
N 11100 40 11310 40 {}
N 12200 -40 12270 -40 {
lab=VB}
N 12410 -40 12480 -40 {
lab=VB}
N 12630 -40 12700 -40 {
lab=VB}
N 12850 -40 12920 -40 {
lab=VB}
N 12340 -40 12370 -40 {
lab=VG}
N 12560 -40 12590 -40 {
lab=VG}
N 12780 -40 12810 -40 {
lab=VG}
N 12200 -130 12200 -70 {
lab=#net1}
N 12200 -130 12840 -130 {
lab=#net1}
N 12850 -130 12850 -70 {
lab=#net1}
N 12840 -130 12850 -130 {
lab=#net1}
N 12630 -130 12630 -70 {
lab=#net1}
N 12410 -130 12410 -70 {
lab=#net1}
N 12200 -10 12200 40 {
lab=#net2}
N 12200 40 12850 40 {
lab=#net2}
N 12850 -10 12850 40 {
lab=#net2}
N 12630 -10 12630 40 {
lab=#net2}
N 12410 -10 12410 40 {
lab=#net2}
N 12100 -40 12160 -40 {
lab=VG}
N 13060 -40 13130 -40 {
lab=VB}
N 13270 -40 13340 -40 {
lab=VB}
N 13490 -40 13560 -40 {
lab=VB}
N 13710 -40 13780 -40 {
lab=VB}
N 13200 -40 13230 -40 {
lab=VG}
N 13420 -40 13450 -40 {
lab=VG}
N 13640 -40 13670 -40 {
lab=VG}
N 13060 -130 13060 -70 {
lab=#net1}
N 13060 -130 13700 -130 {
lab=#net1}
N 13710 -130 13710 -70 {
lab=#net1}
N 13700 -130 13710 -130 {
lab=#net1}
N 13490 -130 13490 -70 {
lab=#net1}
N 13270 -130 13270 -70 {
lab=#net1}
N 13060 -10 13060 40 {
lab=#net2}
N 13060 40 13710 40 {
lab=#net2}
N 13710 -10 13710 40 {
lab=#net2}
N 13490 -10 13490 40 {
lab=#net2}
N 13270 -10 13270 40 {
lab=#net2}
N 12960 -40 13020 -40 {
lab=VG}
N 12850 -130 13060 -130 {}
N 12850 40 13060 40 {}
N 13940 -40 14010 -40 {
lab=VB}
N 14150 -40 14220 -40 {
lab=VB}
N 14370 -40 14440 -40 {
lab=VB}
N 14590 -40 14660 -40 {
lab=VB}
N 14080 -40 14110 -40 {
lab=VG}
N 14300 -40 14330 -40 {
lab=VG}
N 14520 -40 14550 -40 {
lab=VG}
N 13940 -130 13940 -70 {
lab=#net1}
N 13940 -130 14580 -130 {
lab=#net1}
N 14590 -130 14590 -70 {
lab=#net1}
N 14580 -130 14590 -130 {
lab=#net1}
N 14370 -130 14370 -70 {
lab=#net1}
N 14150 -130 14150 -70 {
lab=#net1}
N 13940 -10 13940 40 {
lab=#net2}
N 13940 40 14590 40 {
lab=#net2}
N 14590 -10 14590 40 {
lab=#net2}
N 14370 -10 14370 40 {
lab=#net2}
N 14150 -10 14150 40 {
lab=#net2}
N 13840 -40 13900 -40 {
lab=VG}
N 14800 -40 14870 -40 {
lab=VB}
N 15010 -40 15080 -40 {
lab=VB}
N 15230 -40 15300 -40 {
lab=VB}
N 15450 -40 15520 -40 {
lab=VB}
N 14940 -40 14970 -40 {
lab=VG}
N 15160 -40 15190 -40 {
lab=VG}
N 15380 -40 15410 -40 {
lab=VG}
N 14800 -130 14800 -70 {
lab=#net1}
N 14800 -130 15440 -130 {
lab=#net1}
N 15450 -130 15450 -70 {
lab=#net1}
N 15440 -130 15450 -130 {
lab=#net1}
N 15230 -130 15230 -70 {
lab=#net1}
N 15010 -130 15010 -70 {
lab=#net1}
N 14800 -10 14800 40 {
lab=#net2}
N 14800 40 15450 40 {
lab=#net2}
N 15450 -10 15450 40 {
lab=#net2}
N 15230 -10 15230 40 {
lab=#net2}
N 15010 -10 15010 40 {
lab=#net2}
N 14700 -40 14760 -40 {
lab=VG}
N 14590 -130 14800 -130 {}
N 14590 40 14800 40 {}
N 15690 -40 15760 -40 {
lab=VB}
N 15900 -40 15970 -40 {
lab=VB}
N 16120 -40 16190 -40 {
lab=VB}
N 16340 -40 16410 -40 {
lab=VB}
N 15830 -40 15860 -40 {
lab=VG}
N 16050 -40 16080 -40 {
lab=VG}
N 16270 -40 16300 -40 {
lab=VG}
N 15690 -130 15690 -70 {
lab=#net1}
N 15690 -130 16330 -130 {
lab=#net1}
N 16340 -130 16340 -70 {
lab=#net1}
N 16330 -130 16340 -130 {
lab=#net1}
N 16120 -130 16120 -70 {
lab=#net1}
N 15900 -130 15900 -70 {
lab=#net1}
N 15690 -10 15690 40 {
lab=#net2}
N 15690 40 16340 40 {
lab=#net2}
N 16340 -10 16340 40 {
lab=#net2}
N 16120 -10 16120 40 {
lab=#net2}
N 15900 -10 15900 40 {
lab=#net2}
N 15590 -40 15650 -40 {
lab=VG}
N 16550 -40 16620 -40 {
lab=VB}
N 16760 -40 16830 -40 {
lab=VB}
N 16980 -40 17050 -40 {
lab=VB}
N 17200 -40 17270 -40 {
lab=VB}
N 16690 -40 16720 -40 {
lab=VG}
N 16910 -40 16940 -40 {
lab=VG}
N 17130 -40 17160 -40 {
lab=VG}
N 16550 -130 16550 -70 {
lab=#net1}
N 16550 -130 17190 -130 {
lab=#net1}
N 17200 -130 17200 -70 {
lab=#net1}
N 17190 -130 17200 -130 {
lab=#net1}
N 16980 -130 16980 -70 {
lab=#net1}
N 16760 -130 16760 -70 {
lab=#net1}
N 16550 -10 16550 40 {
lab=#net2}
N 16550 40 17200 40 {
lab=#net2}
N 17200 -10 17200 40 {
lab=#net2}
N 16980 -10 16980 40 {
lab=#net2}
N 16760 -10 16760 40 {
lab=#net2}
N 16450 -40 16510 -40 {
lab=VG}
N 16340 -130 16550 -130 {}
N 16340 40 16550 40 {}
N 17430 -40 17500 -40 {
lab=VB}
N 17640 -40 17710 -40 {
lab=VB}
N 17860 -40 17930 -40 {
lab=VB}
N 18080 -40 18150 -40 {
lab=VB}
N 17570 -40 17600 -40 {
lab=VG}
N 17790 -40 17820 -40 {
lab=VG}
N 18010 -40 18040 -40 {
lab=VG}
N 17430 -130 17430 -70 {
lab=#net1}
N 17430 -130 18070 -130 {
lab=#net1}
N 18080 -130 18080 -70 {
lab=#net1}
N 18070 -130 18080 -130 {
lab=#net1}
N 17860 -130 17860 -70 {
lab=#net1}
N 17640 -130 17640 -70 {
lab=#net1}
N 17430 -10 17430 40 {
lab=#net2}
N 17430 40 18080 40 {
lab=#net2}
N 18080 -10 18080 40 {
lab=#net2}
N 17860 -10 17860 40 {
lab=#net2}
N 17640 -10 17640 40 {
lab=#net2}
N 17330 -40 17390 -40 {
lab=VG}
N 18290 -40 18360 -40 {
lab=VB}
N 18500 -40 18570 -40 {
lab=VB}
N 18720 -40 18790 -40 {
lab=VB}
N 18940 -40 19010 -40 {
lab=VB}
N 18430 -40 18460 -40 {
lab=VG}
N 18650 -40 18680 -40 {
lab=VG}
N 18870 -40 18900 -40 {
lab=VG}
N 18290 -130 18290 -70 {
lab=#net1}
N 18290 -130 18930 -130 {
lab=#net1}
N 18940 -130 18940 -70 {
lab=#net1}
N 18930 -130 18940 -130 {
lab=#net1}
N 18720 -130 18720 -70 {
lab=#net1}
N 18500 -130 18500 -70 {
lab=#net1}
N 18290 -10 18290 40 {
lab=#net2}
N 18290 40 18940 40 {
lab=#net2}
N 18940 -10 18940 40 {
lab=#net2}
N 18720 -10 18720 40 {
lab=#net2}
N 18500 -10 18500 40 {
lab=#net2}
N 18190 -40 18250 -40 {
lab=VG}
N 18080 -130 18290 -130 {}
N 18080 40 18290 40 {}
N 19180 -40 19250 -40 {
lab=VB}
N 19390 -40 19460 -40 {
lab=VB}
N 19610 -40 19680 -40 {
lab=VB}
N 19830 -40 19900 -40 {
lab=VB}
N 19320 -40 19350 -40 {
lab=VG}
N 19540 -40 19570 -40 {
lab=VG}
N 19760 -40 19790 -40 {
lab=VG}
N 19180 -130 19180 -70 {
lab=#net1}
N 19180 -130 19820 -130 {
lab=#net1}
N 19830 -130 19830 -70 {
lab=#net1}
N 19820 -130 19830 -130 {
lab=#net1}
N 19610 -130 19610 -70 {
lab=#net1}
N 19390 -130 19390 -70 {
lab=#net1}
N 19180 -10 19180 40 {
lab=#net2}
N 19180 40 19830 40 {
lab=#net2}
N 19830 -10 19830 40 {
lab=#net2}
N 19610 -10 19610 40 {
lab=#net2}
N 19390 -10 19390 40 {
lab=#net2}
N 19080 -40 19140 -40 {
lab=VG}
N 20040 -40 20110 -40 {
lab=VB}
N 20250 -40 20320 -40 {
lab=VB}
N 20470 -40 20540 -40 {
lab=VB}
N 20690 -40 20760 -40 {
lab=VB}
N 20180 -40 20210 -40 {
lab=VG}
N 20400 -40 20430 -40 {
lab=VG}
N 20620 -40 20650 -40 {
lab=VG}
N 20040 -130 20040 -70 {
lab=#net1}
N 20040 -130 20680 -130 {
lab=#net1}
N 20690 -130 20690 -70 {
lab=#net1}
N 20680 -130 20690 -130 {
lab=#net1}
N 20470 -130 20470 -70 {
lab=#net1}
N 20250 -130 20250 -70 {
lab=#net1}
N 20040 -10 20040 40 {
lab=#net2}
N 20040 40 20690 40 {
lab=#net2}
N 20690 -10 20690 40 {
lab=#net2}
N 20470 -10 20470 40 {
lab=#net2}
N 20250 -10 20250 40 {
lab=#net2}
N 19940 -40 20000 -40 {
lab=VG}
N 19830 -130 20040 -130 {}
N 19830 40 20040 40 {}
C {symbols/pfet_03v3.sym} -40 -40 0 0 {name=M1
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 170 -40 0 0 {name=M11
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 390 -40 0 0 {name=M21
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 610 -40 0 0 {name=M31
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {devices/iopin.sym} 10 -130 3 0 {name=p4 lab=VS}
C {devices/iopin.sym} -120 -40 2 0 {name=p3 lab=VG}
C {devices/iopin.sym} -10 40 1 0 {name=p1 lab=VD
}
C {devices/iopin.sym} 50 -40 0 0 {name=p2 lab=VB}
C {devices/lab_wire.sym} 120 -40 0 0 {name=p6 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 340 -40 0 0 {name=p5 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 560 -40 0 0 {name=p7 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 260 -40 0 0 {name=p10 sig_type=std_logic lab=VB
}
C {devices/lab_wire.sym} 480 -40 0 0 {name=p11 sig_type=std_logic lab=VB
}
C {devices/lab_wire.sym} 700 -40 0 0 {name=p12 sig_type=std_logic lab=VB
}
C {symbols/pfet_03v3.sym} 820 -40 0 0 {name=M2
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 1030 -40 0 0 {name=M3
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 1250 -40 0 0 {name=M4
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 1470 -40 0 0 {name=M5
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {devices/lab_wire.sym} 980 -40 0 0 {name=p13 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 1200 -40 0 0 {name=p14 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 1420 -40 0 0 {name=p15 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 740 -40 0 0 {name=p16 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 910 -40 0 0 {name=p17 sig_type=std_logic lab=VB
}
C {devices/lab_wire.sym} 1120 -40 0 0 {name=p18 sig_type=std_logic lab=VB
}
C {devices/lab_wire.sym} 1340 -40 0 0 {name=p19 sig_type=std_logic lab=VB
}
C {devices/lab_wire.sym} 1560 -40 0 0 {name=p20 sig_type=std_logic lab=VB
}
C {symbols/pfet_03v3.sym} 1710 -40 0 0 {name=M6
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 1920 -40 0 0 {name=M7
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 2140 -40 0 0 {name=M8
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 2360 -40 0 0 {name=M9
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {devices/lab_wire.sym} 1870 -40 0 0 {name=p21 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 2090 -40 0 0 {name=p22 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 2310 -40 0 0 {name=p23 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 1630 -40 0 0 {name=p24 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 1800 -40 0 0 {name=p25 sig_type=std_logic lab=VB
}
C {devices/lab_wire.sym} 2010 -40 0 0 {name=p26 sig_type=std_logic lab=VB
}
C {devices/lab_wire.sym} 2230 -40 0 0 {name=p27 sig_type=std_logic lab=VB
}
C {devices/lab_wire.sym} 2450 -40 0 0 {name=p28 sig_type=std_logic lab=VB
}
C {symbols/pfet_03v3.sym} 2570 -40 0 0 {name=M10
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 2780 -40 0 0 {name=M12
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 3000 -40 0 0 {name=M13
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 3220 -40 0 0 {name=M14
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {devices/lab_wire.sym} 2730 -40 0 0 {name=p29 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 2950 -40 0 0 {name=p30 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 3170 -40 0 0 {name=p31 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 2490 -40 0 0 {name=p32 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 2660 -40 0 0 {name=p33 sig_type=std_logic lab=VB
}
C {devices/lab_wire.sym} 2870 -40 0 0 {name=p34 sig_type=std_logic lab=VB
}
C {devices/lab_wire.sym} 3090 -40 0 0 {name=p35 sig_type=std_logic lab=VB
}
C {devices/lab_wire.sym} 3310 -40 0 0 {name=p36 sig_type=std_logic lab=VB
}
C {symbols/pfet_03v3.sym} 3450 -40 0 0 {name=M15
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 3660 -40 0 0 {name=M16
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 3880 -40 0 0 {name=M17
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 4100 -40 0 0 {name=M18
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {devices/lab_wire.sym} 3610 -40 0 0 {name=p37 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 3830 -40 0 0 {name=p38 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 4050 -40 0 0 {name=p39 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 3370 -40 0 0 {name=p40 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 3540 -40 0 0 {name=p41 sig_type=std_logic lab=VB
}
C {devices/lab_wire.sym} 3750 -40 0 0 {name=p42 sig_type=std_logic lab=VB
}
C {devices/lab_wire.sym} 3970 -40 0 0 {name=p43 sig_type=std_logic lab=VB
}
C {devices/lab_wire.sym} 4190 -40 0 0 {name=p44 sig_type=std_logic lab=VB
}
C {symbols/pfet_03v3.sym} 4310 -40 0 0 {name=M19
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 4520 -40 0 0 {name=M20
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 4740 -40 0 0 {name=M22
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 4960 -40 0 0 {name=M23
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {devices/lab_wire.sym} 4470 -40 0 0 {name=p45 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 4690 -40 0 0 {name=p46 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 4910 -40 0 0 {name=p47 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 4230 -40 0 0 {name=p48 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 4400 -40 0 0 {name=p49 sig_type=std_logic lab=VB
}
C {devices/lab_wire.sym} 4610 -40 0 0 {name=p50 sig_type=std_logic lab=VB
}
C {devices/lab_wire.sym} 4830 -40 0 0 {name=p51 sig_type=std_logic lab=VB
}
C {devices/lab_wire.sym} 5050 -40 0 0 {name=p52 sig_type=std_logic lab=VB
}
C {symbols/pfet_03v3.sym} 5200 -40 0 0 {name=M24
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 5410 -40 0 0 {name=M25
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 5630 -40 0 0 {name=M26
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 5850 -40 0 0 {name=M27
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {devices/lab_wire.sym} 5360 -40 0 0 {name=p53 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 5580 -40 0 0 {name=p54 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 5800 -40 0 0 {name=p55 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 5120 -40 0 0 {name=p56 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 5290 -40 0 0 {name=p57 sig_type=std_logic lab=VB
}
C {devices/lab_wire.sym} 5500 -40 0 0 {name=p58 sig_type=std_logic lab=VB
}
C {devices/lab_wire.sym} 5720 -40 0 0 {name=p59 sig_type=std_logic lab=VB
}
C {devices/lab_wire.sym} 5940 -40 0 0 {name=p60 sig_type=std_logic lab=VB
}
C {symbols/pfet_03v3.sym} 6060 -40 0 0 {name=M28
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 6270 -40 0 0 {name=M29
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 6490 -40 0 0 {name=M30
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 6710 -40 0 0 {name=M32
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {devices/lab_wire.sym} 6220 -40 0 0 {name=p61 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 6440 -40 0 0 {name=p62 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 6660 -40 0 0 {name=p63 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 5980 -40 0 0 {name=p64 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 6150 -40 0 0 {name=p65 sig_type=std_logic lab=VB
}
C {devices/lab_wire.sym} 6360 -40 0 0 {name=p66 sig_type=std_logic lab=VB
}
C {devices/lab_wire.sym} 6580 -40 0 0 {name=p67 sig_type=std_logic lab=VB
}
C {devices/lab_wire.sym} 6800 -40 0 0 {name=p68 sig_type=std_logic lab=VB
}
C {symbols/pfet_03v3.sym} 6940 -40 0 0 {name=M33
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 7150 -40 0 0 {name=M34
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 7370 -40 0 0 {name=M35
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 7590 -40 0 0 {name=M36
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {devices/lab_wire.sym} 7100 -40 0 0 {name=p69 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 7320 -40 0 0 {name=p70 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 7540 -40 0 0 {name=p71 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 6860 -40 0 0 {name=p72 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 7030 -40 0 0 {name=p73 sig_type=std_logic lab=VB
}
C {devices/lab_wire.sym} 7240 -40 0 0 {name=p74 sig_type=std_logic lab=VB
}
C {devices/lab_wire.sym} 7460 -40 0 0 {name=p75 sig_type=std_logic lab=VB
}
C {devices/lab_wire.sym} 7680 -40 0 0 {name=p76 sig_type=std_logic lab=VB
}
C {symbols/pfet_03v3.sym} 7800 -40 0 0 {name=M37
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 8010 -40 0 0 {name=M38
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 8230 -40 0 0 {name=M39
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 8450 -40 0 0 {name=M40
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {devices/lab_wire.sym} 7960 -40 0 0 {name=p77 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 8180 -40 0 0 {name=p78 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 8400 -40 0 0 {name=p79 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 7720 -40 0 0 {name=p80 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 7890 -40 0 0 {name=p81 sig_type=std_logic lab=VB
}
C {devices/lab_wire.sym} 8100 -40 0 0 {name=p82 sig_type=std_logic lab=VB
}
C {devices/lab_wire.sym} 8320 -40 0 0 {name=p83 sig_type=std_logic lab=VB
}
C {devices/lab_wire.sym} 8540 -40 0 0 {name=p84 sig_type=std_logic lab=VB
}
C {symbols/pfet_03v3.sym} 8690 -40 0 0 {name=M41
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 8900 -40 0 0 {name=M42
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 9120 -40 0 0 {name=M43
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 9340 -40 0 0 {name=M44
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {devices/lab_wire.sym} 8850 -40 0 0 {name=p85 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 9070 -40 0 0 {name=p86 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 9290 -40 0 0 {name=p87 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 8610 -40 0 0 {name=p88 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 8780 -40 0 0 {name=p89 sig_type=std_logic lab=VB
}
C {devices/lab_wire.sym} 8990 -40 0 0 {name=p90 sig_type=std_logic lab=VB
}
C {devices/lab_wire.sym} 9210 -40 0 0 {name=p91 sig_type=std_logic lab=VB
}
C {devices/lab_wire.sym} 9430 -40 0 0 {name=p92 sig_type=std_logic lab=VB
}
C {symbols/pfet_03v3.sym} 9550 -40 0 0 {name=M45
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 9760 -40 0 0 {name=M46
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 9980 -40 0 0 {name=M47
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 10200 -40 0 0 {name=M48
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {devices/lab_wire.sym} 9710 -40 0 0 {name=p93 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 9930 -40 0 0 {name=p94 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 10150 -40 0 0 {name=p95 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 9470 -40 0 0 {name=p96 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 9640 -40 0 0 {name=p97 sig_type=std_logic lab=VB
}
C {devices/lab_wire.sym} 9850 -40 0 0 {name=p98 sig_type=std_logic lab=VB
}
C {devices/lab_wire.sym} 10070 -40 0 0 {name=p99 sig_type=std_logic lab=VB
}
C {devices/lab_wire.sym} 10290 -40 0 0 {name=p100 sig_type=std_logic lab=VB
}
C {symbols/pfet_03v3.sym} 10430 -40 0 0 {name=M49
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 10640 -40 0 0 {name=M50
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 10860 -40 0 0 {name=M51
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 11080 -40 0 0 {name=M52
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {devices/lab_wire.sym} 10590 -40 0 0 {name=p101 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 10810 -40 0 0 {name=p102 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 11030 -40 0 0 {name=p103 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 10350 -40 0 0 {name=p104 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 10520 -40 0 0 {name=p105 sig_type=std_logic lab=VB
}
C {devices/lab_wire.sym} 10730 -40 0 0 {name=p106 sig_type=std_logic lab=VB
}
C {devices/lab_wire.sym} 10950 -40 0 0 {name=p107 sig_type=std_logic lab=VB
}
C {devices/lab_wire.sym} 11170 -40 0 0 {name=p108 sig_type=std_logic lab=VB
}
C {symbols/pfet_03v3.sym} 11290 -40 0 0 {name=M53
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 11500 -40 0 0 {name=M54
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 11720 -40 0 0 {name=M55
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 11940 -40 0 0 {name=M56
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {devices/lab_wire.sym} 11450 -40 0 0 {name=p109 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 11670 -40 0 0 {name=p110 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 11890 -40 0 0 {name=p111 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 11210 -40 0 0 {name=p112 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 11380 -40 0 0 {name=p113 sig_type=std_logic lab=VB
}
C {devices/lab_wire.sym} 11590 -40 0 0 {name=p114 sig_type=std_logic lab=VB
}
C {devices/lab_wire.sym} 11810 -40 0 0 {name=p115 sig_type=std_logic lab=VB
}
C {devices/lab_wire.sym} 12030 -40 0 0 {name=p116 sig_type=std_logic lab=VB
}
C {symbols/pfet_03v3.sym} 12180 -40 0 0 {name=M57
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 12390 -40 0 0 {name=M58
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 12610 -40 0 0 {name=M59
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 12830 -40 0 0 {name=M60
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {devices/lab_wire.sym} 12340 -40 0 0 {name=p117 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 12560 -40 0 0 {name=p118 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 12780 -40 0 0 {name=p119 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 12100 -40 0 0 {name=p120 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 12270 -40 0 0 {name=p121 sig_type=std_logic lab=VB
}
C {devices/lab_wire.sym} 12480 -40 0 0 {name=p122 sig_type=std_logic lab=VB
}
C {devices/lab_wire.sym} 12700 -40 0 0 {name=p123 sig_type=std_logic lab=VB
}
C {devices/lab_wire.sym} 12920 -40 0 0 {name=p124 sig_type=std_logic lab=VB
}
C {symbols/pfet_03v3.sym} 13040 -40 0 0 {name=M61
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 13250 -40 0 0 {name=M62
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 13470 -40 0 0 {name=M63
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 13690 -40 0 0 {name=M64
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {devices/lab_wire.sym} 13200 -40 0 0 {name=p125 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 13420 -40 0 0 {name=p126 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 13640 -40 0 0 {name=p127 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 12960 -40 0 0 {name=p128 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 13130 -40 0 0 {name=p129 sig_type=std_logic lab=VB
}
C {devices/lab_wire.sym} 13340 -40 0 0 {name=p130 sig_type=std_logic lab=VB
}
C {devices/lab_wire.sym} 13560 -40 0 0 {name=p131 sig_type=std_logic lab=VB
}
C {devices/lab_wire.sym} 13780 -40 0 0 {name=p132 sig_type=std_logic lab=VB
}
C {symbols/pfet_03v3.sym} 13920 -40 0 0 {name=M65
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 14130 -40 0 0 {name=M66
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 14350 -40 0 0 {name=M67
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 14570 -40 0 0 {name=M68
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {devices/lab_wire.sym} 14080 -40 0 0 {name=p133 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 14300 -40 0 0 {name=p134 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 14520 -40 0 0 {name=p135 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 13840 -40 0 0 {name=p136 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 14010 -40 0 0 {name=p137 sig_type=std_logic lab=VB
}
C {devices/lab_wire.sym} 14220 -40 0 0 {name=p138 sig_type=std_logic lab=VB
}
C {devices/lab_wire.sym} 14440 -40 0 0 {name=p139 sig_type=std_logic lab=VB
}
C {devices/lab_wire.sym} 14660 -40 0 0 {name=p140 sig_type=std_logic lab=VB
}
C {symbols/pfet_03v3.sym} 14780 -40 0 0 {name=M69
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 14990 -40 0 0 {name=M70
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 15210 -40 0 0 {name=M71
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 15430 -40 0 0 {name=M72
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {devices/lab_wire.sym} 14940 -40 0 0 {name=p141 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 15160 -40 0 0 {name=p142 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 15380 -40 0 0 {name=p143 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 14700 -40 0 0 {name=p144 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 14870 -40 0 0 {name=p145 sig_type=std_logic lab=VB
}
C {devices/lab_wire.sym} 15080 -40 0 0 {name=p146 sig_type=std_logic lab=VB
}
C {devices/lab_wire.sym} 15300 -40 0 0 {name=p147 sig_type=std_logic lab=VB
}
C {devices/lab_wire.sym} 15520 -40 0 0 {name=p148 sig_type=std_logic lab=VB
}
C {symbols/pfet_03v3.sym} 15670 -40 0 0 {name=M73
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 15880 -40 0 0 {name=M74
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 16100 -40 0 0 {name=M75
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 16320 -40 0 0 {name=M76
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {devices/lab_wire.sym} 15830 -40 0 0 {name=p149 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 16050 -40 0 0 {name=p150 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 16270 -40 0 0 {name=p151 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 15590 -40 0 0 {name=p152 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 15760 -40 0 0 {name=p153 sig_type=std_logic lab=VB
}
C {devices/lab_wire.sym} 15970 -40 0 0 {name=p154 sig_type=std_logic lab=VB
}
C {devices/lab_wire.sym} 16190 -40 0 0 {name=p155 sig_type=std_logic lab=VB
}
C {devices/lab_wire.sym} 16410 -40 0 0 {name=p156 sig_type=std_logic lab=VB
}
C {symbols/pfet_03v3.sym} 16530 -40 0 0 {name=M77
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 16740 -40 0 0 {name=M78
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 16960 -40 0 0 {name=M79
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 17180 -40 0 0 {name=M80
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {devices/lab_wire.sym} 16690 -40 0 0 {name=p157 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 16910 -40 0 0 {name=p158 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 17130 -40 0 0 {name=p159 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 16450 -40 0 0 {name=p160 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 16620 -40 0 0 {name=p161 sig_type=std_logic lab=VB
}
C {devices/lab_wire.sym} 16830 -40 0 0 {name=p162 sig_type=std_logic lab=VB
}
C {devices/lab_wire.sym} 17050 -40 0 0 {name=p163 sig_type=std_logic lab=VB
}
C {devices/lab_wire.sym} 17270 -40 0 0 {name=p164 sig_type=std_logic lab=VB
}
C {symbols/pfet_03v3.sym} 17410 -40 0 0 {name=M81
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 17620 -40 0 0 {name=M82
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 17840 -40 0 0 {name=M83
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 18060 -40 0 0 {name=M84
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {devices/lab_wire.sym} 17570 -40 0 0 {name=p165 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 17790 -40 0 0 {name=p166 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 18010 -40 0 0 {name=p167 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 17330 -40 0 0 {name=p168 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 17500 -40 0 0 {name=p169 sig_type=std_logic lab=VB
}
C {devices/lab_wire.sym} 17710 -40 0 0 {name=p170 sig_type=std_logic lab=VB
}
C {devices/lab_wire.sym} 17930 -40 0 0 {name=p171 sig_type=std_logic lab=VB
}
C {devices/lab_wire.sym} 18150 -40 0 0 {name=p172 sig_type=std_logic lab=VB
}
C {symbols/pfet_03v3.sym} 18270 -40 0 0 {name=M85
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 18480 -40 0 0 {name=M86
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 18700 -40 0 0 {name=M87
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 18920 -40 0 0 {name=M88
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {devices/lab_wire.sym} 18430 -40 0 0 {name=p173 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 18650 -40 0 0 {name=p174 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 18870 -40 0 0 {name=p175 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 18190 -40 0 0 {name=p176 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 18360 -40 0 0 {name=p177 sig_type=std_logic lab=VB
}
C {devices/lab_wire.sym} 18570 -40 0 0 {name=p178 sig_type=std_logic lab=VB
}
C {devices/lab_wire.sym} 18790 -40 0 0 {name=p179 sig_type=std_logic lab=VB
}
C {devices/lab_wire.sym} 19010 -40 0 0 {name=p180 sig_type=std_logic lab=VB
}
C {symbols/pfet_03v3.sym} 19160 -40 0 0 {name=M89
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 19370 -40 0 0 {name=M90
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 19590 -40 0 0 {name=M91
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 19810 -40 0 0 {name=M92
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {devices/lab_wire.sym} 19320 -40 0 0 {name=p181 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 19540 -40 0 0 {name=p182 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 19760 -40 0 0 {name=p183 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 19080 -40 0 0 {name=p184 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 19250 -40 0 0 {name=p185 sig_type=std_logic lab=VB
}
C {devices/lab_wire.sym} 19460 -40 0 0 {name=p186 sig_type=std_logic lab=VB
}
C {devices/lab_wire.sym} 19680 -40 0 0 {name=p187 sig_type=std_logic lab=VB
}
C {devices/lab_wire.sym} 19900 -40 0 0 {name=p188 sig_type=std_logic lab=VB
}
C {symbols/pfet_03v3.sym} 20020 -40 0 0 {name=M93
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 20230 -40 0 0 {name=M94
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 20450 -40 0 0 {name=M95
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 20670 -40 0 0 {name=M96
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {devices/lab_wire.sym} 20180 -40 0 0 {name=p189 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 20400 -40 0 0 {name=p190 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 20620 -40 0 0 {name=p191 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 19940 -40 0 0 {name=p192 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 20110 -40 0 0 {name=p193 sig_type=std_logic lab=VB
}
C {devices/lab_wire.sym} 20320 -40 0 0 {name=p194 sig_type=std_logic lab=VB
}
C {devices/lab_wire.sym} 20540 -40 0 0 {name=p195 sig_type=std_logic lab=VB
}
C {devices/lab_wire.sym} 20760 -40 0 0 {name=p196 sig_type=std_logic lab=VB
}
C {devices/lab_wire.sym} 19230 -130 0 0 {name=p197 sig_type=std_logic lab=VS}
C {devices/lab_wire.sym} 19220 40 0 0 {name=p198 sig_type=std_logic lab=VD}
C {devices/lab_wire.sym} 17470 -130 0 0 {name=p199 sig_type=std_logic lab=VS}
C {devices/lab_wire.sym} 17460 40 0 0 {name=p200 sig_type=std_logic lab=VD}
C {devices/lab_wire.sym} 16290 -130 0 0 {name=p201 sig_type=std_logic lab=VS}
C {devices/lab_wire.sym} 16240 40 0 0 {name=p202 sig_type=std_logic lab=VD}
C {devices/lab_wire.sym} 14020 -130 0 0 {name=p203 sig_type=std_logic lab=VS}
C {devices/lab_wire.sym} 13970 40 0 0 {name=p204 sig_type=std_logic lab=VD}
C {devices/lab_wire.sym} 12280 -130 0 0 {name=p205 sig_type=std_logic lab=VS}
C {devices/lab_wire.sym} 12230 40 0 0 {name=p206 sig_type=std_logic lab=VD}
C {devices/lab_wire.sym} 10540 -130 0 0 {name=p207 sig_type=std_logic lab=VS}
C {devices/lab_wire.sym} 10490 40 0 0 {name=p208 sig_type=std_logic lab=VD}
C {devices/lab_wire.sym} 8810 -130 0 0 {name=p209 sig_type=std_logic lab=VS}
C {devices/lab_wire.sym} 8760 40 0 0 {name=p210 sig_type=std_logic lab=VD}
C {devices/lab_wire.sym} 7030 -130 0 0 {name=p211 sig_type=std_logic lab=VS}
C {devices/lab_wire.sym} 6980 40 0 0 {name=p212 sig_type=std_logic lab=VD}
C {devices/lab_wire.sym} 5340 -130 0 0 {name=p213 sig_type=std_logic lab=VS}
C {devices/lab_wire.sym} 5290 40 0 0 {name=p214 sig_type=std_logic lab=VD}
C {devices/lab_wire.sym} 3550 -130 0 0 {name=p215 sig_type=std_logic lab=VS}
C {devices/lab_wire.sym} 3500 40 0 0 {name=p216 sig_type=std_logic lab=VD}
C {devices/lab_wire.sym} 1840 -130 0 0 {name=p217 sig_type=std_logic lab=VS}
C {devices/lab_wire.sym} 1790 40 0 0 {name=p218 sig_type=std_logic lab=VD}
C {devices/lab_wire.sym} 290 -130 0 0 {name=p219 sig_type=std_logic lab=VS}
C {devices/lab_wire.sym} 240 40 0 0 {name=p220 sig_type=std_logic lab=VD}
