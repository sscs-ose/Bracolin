v {xschem version=3.4.0 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
N 0 0 0 30 {
lab=#net1}
N 0 90 0 120 {
lab=#net2}
N 0 180 0 210 {
lab=#net3}
N 0 270 0 300 {
lab=#net4}
N 0 360 0 400 {
lab=#net5}
N 0 460 0 490 {
lab=#net6}
N 0 550 0 580 {
lab=#net7}
N 0 640 0 670 {
lab=#net8}
N 0 730 0 760 {
lab=#net9}
N 0 -30 70 -30 {
lab=VB}
N 0 60 70 60 {
lab=VB}
N 0 150 70 150 {
lab=VB}
N 0 240 70 240 {
lab=VB}
N 0 330 70 330 {
lab=VB}
N 0 430 70 430 {
lab=VB}
N 0 520 70 520 {
lab=VB}
N 0 610 70 610 {
lab=VB}
N 0 700 70 700 {
lab=VB}
N -100 -30 -40 -30 {
lab=VG}
N -100 700 -40 700 {
lab=VG}
N -100 610 -40 610 {
lab=VG}
N -100 520 -40 520 {
lab=VG}
N -100 430 -40 430 {
lab=VG}
N -100 330 -40 330 {
lab=VG}
N -100 240 -40 240 {
lab=VG}
N -100 150 -40 150 {
lab=VG}
N -100 60 -40 60 {
lab=VG}
N 0 -130 0 -60 {
lab=VS}
N -100 -30 -100 610 {
lab=VG}
N 70 -30 70 610 {
lab=VB}
N 70 700 70 790 {
lab=VB}
N -100 610 -100 790 {
lab=VG}
N 70 610 70 700 {
lab=VB}
N 0 820 0 850 {
lab=#net10}
N 0 910 0 940 {
lab=#net11}
N 0 8630 0 8660 {
lab=VD}
N 0 880 70 880 {
lab=VB}
N 0 970 70 970 {
lab=VB}
N -100 970 -40 970 {
lab=VG}
N -100 880 -40 880 {
lab=VG}
N -100 790 -100 970 {
lab=VG}
N 70 790 70 970 {
lab=VB}
N 0 790 70 790 {
lab=VB}
N -100 790 -40 790 {
lab=VG}
N 340 -90 340 -60 {
lab=VS}
N 340 0 340 30 {
lab=#net12}
N 340 90 340 120 {
lab=#net13}
N 340 180 340 210 {
lab=#net14}
N 340 -30 410 -30 {
lab=VB}
N 340 60 410 60 {
lab=VB}
N 340 150 410 150 {
lab=VB}
N 240 150 300 150 {
lab=VG}
N 240 60 300 60 {
lab=VG}
N 240 -30 300 -30 {
lab=VG}
N 410 150 410 240 {
lab=VB}
N 240 60 240 240 {
lab=VG}
N 410 60 410 150 {
lab=VB}
N 240 240 300 240 {
lab=VG}
N 340 240 410 240 {
lab=VB}
N 340 270 340 300 {
lab=#net15}
N 340 360 340 390 {
lab=#net16}
N 340 330 410 330 {
lab=VB}
N 240 330 300 330 {
lab=VG}
N 410 330 410 420 {
lab=VB}
N 240 240 240 420 {
lab=VG}
N 340 450 340 480 {
lab=#net17}
N 340 540 340 570 {
lab=#net18}
N 340 630 340 660 {
lab=#net19}
N 340 720 340 750 {
lab=#net20}
N 340 510 410 510 {
lab=VB}
N 340 600 410 600 {
lab=VB}
N 340 690 410 690 {
lab=VB}
N 240 690 300 690 {
lab=VG}
N 240 600 300 600 {
lab=VG}
N 240 510 300 510 {
lab=VG}
N 410 690 410 780 {
lab=VB}
N 240 600 240 780 {
lab=VG}
N 410 600 410 690 {
lab=VB}
N 240 420 240 600 {
lab=VG}
N 410 420 410 600 {
lab=VB}
N 240 780 300 780 {
lab=VG}
N 340 780 410 780 {
lab=VB}
N 340 420 410 420 {
lab=VB}
N 240 420 300 420 {
lab=VG}
N 410 240 410 330 {
lab=VB}
N 340 810 340 840 {
lab=#net21}
N 340 900 340 930 {
lab=#net22}
N 340 870 410 870 {
lab=VB}
N 240 870 300 870 {
lab=VG}
N 410 870 410 960 {
lab=VB}
N 240 780 240 960 {
lab=VG}
N 410 780 410 870 {
lab=VB}
N 340 8620 340 8650 {
lab=VD}
N 340 960 410 960 {
lab=VB}
N 240 960 300 960 {
lab=VG}
N 240 -30 240 60 {
lab=VG}
N 410 -20 410 60 {
lab=VB}
N 410 -30 410 -20 {
lab=VB}
N 0 8660 0 8730 {
lab=VD}
N 340 8650 340 8720 {
lab=VD}
N 340 8720 340 8730 {
lab=VD}
N 0 -90 340 -90 {
lab=VS}
N 0 8730 340 8730 {
lab=VD}
N 0 1090 0 1120 {
lab=#net23}
N 0 1180 0 1210 {
lab=#net24}
N 0 1270 0 1300 {
lab=#net25}
N 0 1360 0 1390 {
lab=#net26}
N 0 1450 0 1490 {
lab=#net27}
N 0 1550 0 1580 {
lab=#net28}
N 0 1640 0 1670 {
lab=#net29}
N 0 1730 0 1760 {
lab=#net30}
N 0 1820 0 1850 {
lab=#net31}
N 0 1060 70 1060 {
lab=VB}
N 0 1150 70 1150 {
lab=VB}
N 0 1240 70 1240 {
lab=VB}
N 0 1330 70 1330 {
lab=VB}
N 0 1420 70 1420 {
lab=VB}
N 0 1520 70 1520 {
lab=VB}
N 0 1610 70 1610 {
lab=VB}
N 0 1700 70 1700 {
lab=VB}
N 0 1790 70 1790 {
lab=VB}
N -100 1060 -40 1060 {
lab=VG}
N -100 1790 -40 1790 {
lab=VG}
N -100 1700 -40 1700 {
lab=VG}
N -100 1610 -40 1610 {
lab=VG}
N -100 1520 -40 1520 {
lab=VG}
N -100 1420 -40 1420 {
lab=VG}
N -100 1330 -40 1330 {
lab=VG}
N -100 1240 -40 1240 {
lab=VG}
N -100 1150 -40 1150 {
lab=VG}
N -100 1060 -100 1700 {
lab=VG}
N 70 1060 70 1700 {
lab=VB}
N 70 1790 70 1880 {
lab=VB}
N -100 1700 -100 1880 {
lab=VG}
N 70 1700 70 1790 {
lab=VB}
N 0 1910 0 1940 {
lab=#net32}
N 0 2000 0 2030 {
lab=#net33}
N 0 1970 70 1970 {
lab=VB}
N 0 2060 70 2060 {
lab=VB}
N -100 2060 -40 2060 {
lab=VG}
N -100 1970 -40 1970 {
lab=VG}
N -100 1880 -100 2060 {
lab=VG}
N 70 1880 70 2060 {
lab=VB}
N 0 1880 70 1880 {
lab=VB}
N -100 1880 -40 1880 {
lab=VG}
N 340 1090 340 1120 {
lab=#net34}
N 340 1180 340 1210 {
lab=#net35}
N 340 1270 340 1300 {
lab=#net36}
N 340 1060 410 1060 {
lab=VB}
N 340 1150 410 1150 {
lab=VB}
N 340 1240 410 1240 {
lab=VB}
N 240 1240 300 1240 {
lab=VG}
N 240 1150 300 1150 {
lab=VG}
N 240 1060 300 1060 {
lab=VG}
N 410 1240 410 1330 {
lab=VB}
N 240 1150 240 1330 {
lab=VG}
N 410 1150 410 1240 {
lab=VB}
N 240 1330 300 1330 {
lab=VG}
N 340 1330 410 1330 {
lab=VB}
N 340 1360 340 1390 {
lab=#net37}
N 340 1450 340 1480 {
lab=#net38}
N 340 1420 410 1420 {
lab=VB}
N 240 1420 300 1420 {
lab=VG}
N 410 1420 410 1510 {
lab=VB}
N 240 1330 240 1510 {
lab=VG}
N 340 1540 340 1570 {
lab=#net39}
N 340 1630 340 1660 {
lab=#net40}
N 340 1720 340 1750 {
lab=#net41}
N 340 1810 340 1840 {
lab=#net42}
N 340 1600 410 1600 {
lab=VB}
N 340 1690 410 1690 {
lab=VB}
N 340 1780 410 1780 {
lab=VB}
N 240 1780 300 1780 {
lab=VG}
N 240 1690 300 1690 {
lab=VG}
N 240 1600 300 1600 {
lab=VG}
N 410 1780 410 1870 {
lab=VB}
N 240 1690 240 1870 {
lab=VG}
N 410 1690 410 1780 {
lab=VB}
N 240 1510 240 1690 {
lab=VG}
N 410 1510 410 1690 {
lab=VB}
N 240 1870 300 1870 {
lab=VG}
N 340 1870 410 1870 {
lab=VB}
N 340 1510 410 1510 {
lab=VB}
N 240 1510 300 1510 {
lab=VG}
N 410 1330 410 1420 {
lab=VB}
N 340 1900 340 1930 {
lab=#net43}
N 340 1990 340 2020 {
lab=#net44}
N 340 1960 410 1960 {
lab=VB}
N 240 1960 300 1960 {
lab=VG}
N 410 1960 410 2050 {
lab=VB}
N 240 1870 240 2050 {
lab=VG}
N 410 1870 410 1960 {
lab=VB}
N 340 2050 410 2050 {
lab=VB}
N 240 2050 300 2050 {
lab=VG}
N 240 1060 240 1150 {
lab=VG}
N 410 1070 410 1150 {
lab=VB}
N 410 1060 410 1070 {
lab=VB}
N 0 1000 0 1030 {
lab=#net45}
N 70 970 70 1060 {
lab=VB}
N -100 970 -100 1060 {
lab=VG}
N 240 960 240 1060 {
lab=VG}
N 340 990 340 1030 {
lab=#net46}
N 410 960 410 1060 {
lab=VB}
N 0 2180 0 2210 {
lab=#net1}
N 0 2270 0 2300 {
lab=#net2}
N 0 2360 0 2390 {
lab=#net3}
N 0 2450 0 2480 {
lab=#net4}
N 0 2540 0 2580 {
lab=#net5}
N 0 2640 0 2670 {
lab=#net6}
N 0 2730 0 2760 {
lab=#net7}
N 0 2820 0 2850 {
lab=#net8}
N 0 2910 0 2940 {
lab=#net9}
N 0 2150 70 2150 {
lab=VB}
N 0 2240 70 2240 {
lab=VB}
N 0 2330 70 2330 {
lab=VB}
N 0 2420 70 2420 {
lab=VB}
N 0 2510 70 2510 {
lab=VB}
N 0 2610 70 2610 {
lab=VB}
N 0 2700 70 2700 {
lab=VB}
N 0 2790 70 2790 {
lab=VB}
N 0 2880 70 2880 {
lab=VB}
N -100 2150 -40 2150 {
lab=VG}
N -100 2880 -40 2880 {
lab=VG}
N -100 2790 -40 2790 {
lab=VG}
N -100 2700 -40 2700 {
lab=VG}
N -100 2610 -40 2610 {
lab=VG}
N -100 2510 -40 2510 {
lab=VG}
N -100 2420 -40 2420 {
lab=VG}
N -100 2330 -40 2330 {
lab=VG}
N -100 2240 -40 2240 {
lab=VG}
N -100 2150 -100 2790 {
lab=VG}
N 70 2150 70 2790 {
lab=VB}
N 70 2880 70 2970 {
lab=VB}
N -100 2790 -100 2970 {
lab=VG}
N 70 2790 70 2880 {
lab=VB}
N 0 3000 0 3030 {
lab=#net10}
N 0 3090 0 3120 {
lab=#net11}
N 0 3060 70 3060 {
lab=VB}
N 0 3150 70 3150 {
lab=VB}
N -100 3150 -40 3150 {
lab=VG}
N -100 3060 -40 3060 {
lab=VG}
N -100 2970 -100 3150 {
lab=VG}
N 70 2970 70 3150 {
lab=VB}
N 0 2970 70 2970 {
lab=VB}
N -100 2970 -40 2970 {
lab=VG}
N 340 2180 340 2210 {
lab=#net12}
N 340 2270 340 2300 {
lab=#net13}
N 340 2360 340 2390 {
lab=#net14}
N 340 2150 410 2150 {
lab=VB}
N 340 2240 410 2240 {
lab=VB}
N 340 2330 410 2330 {
lab=VB}
N 240 2330 300 2330 {
lab=VG}
N 240 2240 300 2240 {
lab=VG}
N 240 2150 300 2150 {
lab=VG}
N 410 2330 410 2420 {
lab=VB}
N 240 2240 240 2420 {
lab=VG}
N 410 2240 410 2330 {
lab=VB}
N 240 2420 300 2420 {
lab=VG}
N 340 2420 410 2420 {
lab=VB}
N 340 2450 340 2480 {
lab=#net15}
N 340 2540 340 2570 {
lab=#net16}
N 340 2510 410 2510 {
lab=VB}
N 240 2510 300 2510 {
lab=VG}
N 410 2510 410 2600 {
lab=VB}
N 240 2420 240 2600 {
lab=VG}
N 340 2630 340 2660 {
lab=#net17}
N 340 2720 340 2750 {
lab=#net18}
N 340 2810 340 2840 {
lab=#net19}
N 340 2900 340 2930 {
lab=#net20}
N 340 2690 410 2690 {
lab=VB}
N 340 2780 410 2780 {
lab=VB}
N 340 2870 410 2870 {
lab=VB}
N 240 2870 300 2870 {
lab=VG}
N 240 2780 300 2780 {
lab=VG}
N 240 2690 300 2690 {
lab=VG}
N 410 2870 410 2960 {
lab=VB}
N 240 2780 240 2960 {
lab=VG}
N 410 2780 410 2870 {
lab=VB}
N 240 2600 240 2780 {
lab=VG}
N 410 2600 410 2780 {
lab=VB}
N 240 2960 300 2960 {
lab=VG}
N 340 2960 410 2960 {
lab=VB}
N 340 2600 410 2600 {
lab=VB}
N 240 2600 300 2600 {
lab=VG}
N 410 2420 410 2510 {
lab=VB}
N 340 2990 340 3020 {
lab=#net21}
N 340 3080 340 3110 {
lab=#net22}
N 340 3050 410 3050 {
lab=VB}
N 240 3050 300 3050 {
lab=VG}
N 410 3050 410 3140 {
lab=VB}
N 240 2960 240 3140 {
lab=VG}
N 410 2960 410 3050 {
lab=VB}
N 340 3140 410 3140 {
lab=VB}
N 240 3140 300 3140 {
lab=VG}
N 240 2150 240 2240 {
lab=VG}
N 410 2160 410 2240 {
lab=VB}
N 410 2150 410 2160 {
lab=VB}
N 0 3270 0 3300 {
lab=#net23}
N 0 3360 0 3390 {
lab=#net24}
N 0 3450 0 3480 {
lab=#net25}
N 0 3540 0 3570 {
lab=#net26}
N 0 3630 0 3670 {
lab=#net27}
N 0 3730 0 3760 {
lab=#net28}
N 0 3820 0 3850 {
lab=#net29}
N 0 3910 0 3940 {
lab=#net30}
N 0 4000 0 4030 {
lab=#net31}
N 0 3240 70 3240 {
lab=VB}
N 0 3330 70 3330 {
lab=VB}
N 0 3420 70 3420 {
lab=VB}
N 0 3510 70 3510 {
lab=VB}
N 0 3600 70 3600 {
lab=VB}
N 0 3700 70 3700 {
lab=VB}
N 0 3790 70 3790 {
lab=VB}
N 0 3880 70 3880 {
lab=VB}
N 0 3970 70 3970 {
lab=VB}
N -100 3240 -40 3240 {
lab=VG}
N -100 3970 -40 3970 {
lab=VG}
N -100 3880 -40 3880 {
lab=VG}
N -100 3790 -40 3790 {
lab=VG}
N -100 3700 -40 3700 {
lab=VG}
N -100 3600 -40 3600 {
lab=VG}
N -100 3510 -40 3510 {
lab=VG}
N -100 3420 -40 3420 {
lab=VG}
N -100 3330 -40 3330 {
lab=VG}
N -100 3240 -100 3880 {
lab=VG}
N 70 3240 70 3880 {
lab=VB}
N 70 3970 70 4060 {
lab=VB}
N -100 3880 -100 4060 {
lab=VG}
N 70 3880 70 3970 {
lab=VB}
N 0 4090 0 4120 {
lab=#net32}
N 0 4180 0 4210 {
lab=#net33}
N 0 4150 70 4150 {
lab=VB}
N 0 4240 70 4240 {
lab=VB}
N -100 4240 -40 4240 {
lab=VG}
N -100 4150 -40 4150 {
lab=VG}
N -100 4060 -100 4240 {
lab=VG}
N 70 4060 70 4240 {
lab=VB}
N 0 4060 70 4060 {
lab=VB}
N -100 4060 -40 4060 {
lab=VG}
N 340 3270 340 3300 {
lab=#net34}
N 340 3360 340 3390 {
lab=#net35}
N 340 3450 340 3480 {
lab=#net36}
N 340 3240 410 3240 {
lab=VB}
N 340 3330 410 3330 {
lab=VB}
N 340 3420 410 3420 {
lab=VB}
N 240 3420 300 3420 {
lab=VG}
N 240 3330 300 3330 {
lab=VG}
N 240 3240 300 3240 {
lab=VG}
N 410 3420 410 3510 {
lab=VB}
N 240 3330 240 3510 {
lab=VG}
N 410 3330 410 3420 {
lab=VB}
N 240 3510 300 3510 {
lab=VG}
N 340 3510 410 3510 {
lab=VB}
N 340 3540 340 3570 {
lab=#net37}
N 340 3630 340 3660 {
lab=#net38}
N 340 3600 410 3600 {
lab=VB}
N 240 3600 300 3600 {
lab=VG}
N 410 3600 410 3690 {
lab=VB}
N 240 3510 240 3690 {
lab=VG}
N 340 3720 340 3750 {
lab=#net39}
N 340 3810 340 3840 {
lab=#net40}
N 340 3900 340 3930 {
lab=#net41}
N 340 3990 340 4020 {
lab=#net42}
N 340 3780 410 3780 {
lab=VB}
N 340 3870 410 3870 {
lab=VB}
N 340 3960 410 3960 {
lab=VB}
N 240 3960 300 3960 {
lab=VG}
N 240 3870 300 3870 {
lab=VG}
N 240 3780 300 3780 {
lab=VG}
N 410 3960 410 4050 {
lab=VB}
N 240 3870 240 4050 {
lab=VG}
N 410 3870 410 3960 {
lab=VB}
N 240 3690 240 3870 {
lab=VG}
N 410 3690 410 3870 {
lab=VB}
N 240 4050 300 4050 {
lab=VG}
N 340 4050 410 4050 {
lab=VB}
N 340 3690 410 3690 {
lab=VB}
N 240 3690 300 3690 {
lab=VG}
N 410 3510 410 3600 {
lab=VB}
N 340 4080 340 4110 {
lab=#net43}
N 340 4170 340 4200 {
lab=#net44}
N 340 4140 410 4140 {
lab=VB}
N 240 4140 300 4140 {
lab=VG}
N 410 4140 410 4230 {
lab=VB}
N 240 4050 240 4230 {
lab=VG}
N 410 4050 410 4140 {
lab=VB}
N 340 4230 410 4230 {
lab=VB}
N 240 4230 300 4230 {
lab=VG}
N 240 3240 240 3330 {
lab=VG}
N 410 3250 410 3330 {
lab=VB}
N 410 3240 410 3250 {
lab=VB}
N 0 3180 0 3210 {
lab=#net45}
N 70 3150 70 3240 {
lab=VB}
N -100 3150 -100 3240 {
lab=VG}
N 240 3140 240 3240 {
lab=VG}
N 340 3170 340 3210 {
lab=#net46}
N 410 3140 410 3240 {
lab=VB}
N 0 2090 0 2120 {}
N -100 2060 -100 2150 {}
N 70 2060 70 2150 {}
N 240 2050 240 2150 {}
N 340 2080 340 2120 {}
N 410 2050 410 2150 {}
N 0 4360 0 4390 {
lab=#net1}
N 0 4450 0 4480 {
lab=#net2}
N 0 4540 0 4570 {
lab=#net3}
N 0 4630 0 4660 {
lab=#net4}
N 0 4720 0 4760 {
lab=#net5}
N 0 4820 0 4850 {
lab=#net6}
N 0 4910 0 4940 {
lab=#net7}
N 0 5000 0 5030 {
lab=#net8}
N 0 5090 0 5120 {
lab=#net9}
N 0 4330 70 4330 {
lab=VB}
N 0 4420 70 4420 {
lab=VB}
N 0 4510 70 4510 {
lab=VB}
N 0 4600 70 4600 {
lab=VB}
N 0 4690 70 4690 {
lab=VB}
N 0 4790 70 4790 {
lab=VB}
N 0 4880 70 4880 {
lab=VB}
N 0 4970 70 4970 {
lab=VB}
N 0 5060 70 5060 {
lab=VB}
N -100 4330 -40 4330 {
lab=VG}
N -100 5060 -40 5060 {
lab=VG}
N -100 4970 -40 4970 {
lab=VG}
N -100 4880 -40 4880 {
lab=VG}
N -100 4790 -40 4790 {
lab=VG}
N -100 4690 -40 4690 {
lab=VG}
N -100 4600 -40 4600 {
lab=VG}
N -100 4510 -40 4510 {
lab=VG}
N -100 4420 -40 4420 {
lab=VG}
N -100 4330 -100 4970 {
lab=VG}
N 70 4330 70 4970 {
lab=VB}
N 70 5060 70 5150 {
lab=VB}
N -100 4970 -100 5150 {
lab=VG}
N 70 4970 70 5060 {
lab=VB}
N 0 5180 0 5210 {
lab=#net10}
N 0 5270 0 5300 {
lab=#net11}
N 0 5240 70 5240 {
lab=VB}
N 0 5330 70 5330 {
lab=VB}
N -100 5330 -40 5330 {
lab=VG}
N -100 5240 -40 5240 {
lab=VG}
N -100 5150 -100 5330 {
lab=VG}
N 70 5150 70 5330 {
lab=VB}
N 0 5150 70 5150 {
lab=VB}
N -100 5150 -40 5150 {
lab=VG}
N 340 4360 340 4390 {
lab=#net12}
N 340 4450 340 4480 {
lab=#net13}
N 340 4540 340 4570 {
lab=#net14}
N 340 4330 410 4330 {
lab=VB}
N 340 4420 410 4420 {
lab=VB}
N 340 4510 410 4510 {
lab=VB}
N 240 4510 300 4510 {
lab=VG}
N 240 4420 300 4420 {
lab=VG}
N 240 4330 300 4330 {
lab=VG}
N 410 4510 410 4600 {
lab=VB}
N 240 4420 240 4600 {
lab=VG}
N 410 4420 410 4510 {
lab=VB}
N 240 4600 300 4600 {
lab=VG}
N 340 4600 410 4600 {
lab=VB}
N 340 4630 340 4660 {
lab=#net15}
N 340 4720 340 4750 {
lab=#net16}
N 340 4690 410 4690 {
lab=VB}
N 240 4690 300 4690 {
lab=VG}
N 410 4690 410 4780 {
lab=VB}
N 240 4600 240 4780 {
lab=VG}
N 340 4810 340 4840 {
lab=#net17}
N 340 4900 340 4930 {
lab=#net18}
N 340 4990 340 5020 {
lab=#net19}
N 340 5080 340 5110 {
lab=#net20}
N 340 4870 410 4870 {
lab=VB}
N 340 4960 410 4960 {
lab=VB}
N 340 5050 410 5050 {
lab=VB}
N 240 5050 300 5050 {
lab=VG}
N 240 4960 300 4960 {
lab=VG}
N 240 4870 300 4870 {
lab=VG}
N 410 5050 410 5140 {
lab=VB}
N 240 4960 240 5140 {
lab=VG}
N 410 4960 410 5050 {
lab=VB}
N 240 4780 240 4960 {
lab=VG}
N 410 4780 410 4960 {
lab=VB}
N 240 5140 300 5140 {
lab=VG}
N 340 5140 410 5140 {
lab=VB}
N 340 4780 410 4780 {
lab=VB}
N 240 4780 300 4780 {
lab=VG}
N 410 4600 410 4690 {
lab=VB}
N 340 5170 340 5200 {
lab=#net21}
N 340 5260 340 5290 {
lab=#net22}
N 340 5230 410 5230 {
lab=VB}
N 240 5230 300 5230 {
lab=VG}
N 410 5230 410 5320 {
lab=VB}
N 240 5140 240 5320 {
lab=VG}
N 410 5140 410 5230 {
lab=VB}
N 340 5320 410 5320 {
lab=VB}
N 240 5320 300 5320 {
lab=VG}
N 240 4330 240 4420 {
lab=VG}
N 410 4340 410 4420 {
lab=VB}
N 410 4330 410 4340 {
lab=VB}
N 0 5450 0 5480 {
lab=#net23}
N 0 5540 0 5570 {
lab=#net24}
N 0 5630 0 5660 {
lab=#net25}
N 0 5720 0 5750 {
lab=#net26}
N 0 5810 0 5850 {
lab=#net27}
N 0 5910 0 5940 {
lab=#net28}
N 0 6000 0 6030 {
lab=#net29}
N 0 6090 0 6120 {
lab=#net30}
N 0 6180 0 6210 {
lab=#net31}
N 0 5420 70 5420 {
lab=VB}
N 0 5510 70 5510 {
lab=VB}
N 0 5600 70 5600 {
lab=VB}
N 0 5690 70 5690 {
lab=VB}
N 0 5780 70 5780 {
lab=VB}
N 0 5880 70 5880 {
lab=VB}
N 0 5970 70 5970 {
lab=VB}
N 0 6060 70 6060 {
lab=VB}
N 0 6150 70 6150 {
lab=VB}
N -100 5420 -40 5420 {
lab=VG}
N -100 6150 -40 6150 {
lab=VG}
N -100 6060 -40 6060 {
lab=VG}
N -100 5970 -40 5970 {
lab=VG}
N -100 5880 -40 5880 {
lab=VG}
N -100 5780 -40 5780 {
lab=VG}
N -100 5690 -40 5690 {
lab=VG}
N -100 5600 -40 5600 {
lab=VG}
N -100 5510 -40 5510 {
lab=VG}
N -100 5420 -100 6060 {
lab=VG}
N 70 5420 70 6060 {
lab=VB}
N 70 6150 70 6240 {
lab=VB}
N -100 6060 -100 6240 {
lab=VG}
N 70 6060 70 6150 {
lab=VB}
N 0 6270 0 6300 {
lab=#net32}
N 0 6360 0 6390 {
lab=#net33}
N 0 6330 70 6330 {
lab=VB}
N 0 6420 70 6420 {
lab=VB}
N -100 6420 -40 6420 {
lab=VG}
N -100 6330 -40 6330 {
lab=VG}
N -100 6240 -100 6420 {
lab=VG}
N 70 6240 70 6420 {
lab=VB}
N 0 6240 70 6240 {
lab=VB}
N -100 6240 -40 6240 {
lab=VG}
N 340 5450 340 5480 {
lab=#net34}
N 340 5540 340 5570 {
lab=#net35}
N 340 5630 340 5660 {
lab=#net36}
N 340 5420 410 5420 {
lab=VB}
N 340 5510 410 5510 {
lab=VB}
N 340 5600 410 5600 {
lab=VB}
N 240 5600 300 5600 {
lab=VG}
N 240 5510 300 5510 {
lab=VG}
N 240 5420 300 5420 {
lab=VG}
N 410 5600 410 5690 {
lab=VB}
N 240 5510 240 5690 {
lab=VG}
N 410 5510 410 5600 {
lab=VB}
N 240 5690 300 5690 {
lab=VG}
N 340 5690 410 5690 {
lab=VB}
N 340 5720 340 5750 {
lab=#net37}
N 340 5810 340 5840 {
lab=#net38}
N 340 5780 410 5780 {
lab=VB}
N 240 5780 300 5780 {
lab=VG}
N 410 5780 410 5870 {
lab=VB}
N 240 5690 240 5870 {
lab=VG}
N 340 5900 340 5930 {
lab=#net39}
N 340 5990 340 6020 {
lab=#net40}
N 340 6080 340 6110 {
lab=#net41}
N 340 6170 340 6200 {
lab=#net42}
N 340 5960 410 5960 {
lab=VB}
N 340 6050 410 6050 {
lab=VB}
N 340 6140 410 6140 {
lab=VB}
N 240 6140 300 6140 {
lab=VG}
N 240 6050 300 6050 {
lab=VG}
N 240 5960 300 5960 {
lab=VG}
N 410 6140 410 6230 {
lab=VB}
N 240 6050 240 6230 {
lab=VG}
N 410 6050 410 6140 {
lab=VB}
N 240 5870 240 6050 {
lab=VG}
N 410 5870 410 6050 {
lab=VB}
N 240 6230 300 6230 {
lab=VG}
N 340 6230 410 6230 {
lab=VB}
N 340 5870 410 5870 {
lab=VB}
N 240 5870 300 5870 {
lab=VG}
N 410 5690 410 5780 {
lab=VB}
N 340 6260 340 6290 {
lab=#net43}
N 340 6350 340 6380 {
lab=#net44}
N 340 6320 410 6320 {
lab=VB}
N 240 6320 300 6320 {
lab=VG}
N 410 6320 410 6410 {
lab=VB}
N 240 6230 240 6410 {
lab=VG}
N 410 6230 410 6320 {
lab=VB}
N 340 6410 410 6410 {
lab=VB}
N 240 6410 300 6410 {
lab=VG}
N 240 5420 240 5510 {
lab=VG}
N 410 5430 410 5510 {
lab=VB}
N 410 5420 410 5430 {
lab=VB}
N 0 5360 0 5390 {
lab=#net45}
N 70 5330 70 5420 {
lab=VB}
N -100 5330 -100 5420 {
lab=VG}
N 240 5320 240 5420 {
lab=VG}
N 340 5350 340 5390 {
lab=#net46}
N 410 5320 410 5420 {
lab=VB}
N 0 4270 0 4300 {}
N 340 4260 340 4300 {}
N 0 6540 0 6570 {
lab=#net1}
N 0 6630 0 6660 {
lab=#net2}
N 0 6720 0 6750 {
lab=#net3}
N 0 6810 0 6840 {
lab=#net4}
N 0 6900 0 6940 {
lab=#net5}
N 0 7000 0 7030 {
lab=#net6}
N 0 7090 0 7120 {
lab=#net7}
N 0 7180 0 7210 {
lab=#net8}
N 0 7270 0 7300 {
lab=#net9}
N 0 6510 70 6510 {
lab=VB}
N 0 6600 70 6600 {
lab=VB}
N 0 6690 70 6690 {
lab=VB}
N 0 6780 70 6780 {
lab=VB}
N 0 6870 70 6870 {
lab=VB}
N 0 6970 70 6970 {
lab=VB}
N 0 7060 70 7060 {
lab=VB}
N 0 7150 70 7150 {
lab=VB}
N 0 7240 70 7240 {
lab=VB}
N -100 6510 -40 6510 {
lab=VG}
N -100 7240 -40 7240 {
lab=VG}
N -100 7150 -40 7150 {
lab=VG}
N -100 7060 -40 7060 {
lab=VG}
N -100 6970 -40 6970 {
lab=VG}
N -100 6870 -40 6870 {
lab=VG}
N -100 6780 -40 6780 {
lab=VG}
N -100 6690 -40 6690 {
lab=VG}
N -100 6600 -40 6600 {
lab=VG}
N -100 6510 -100 7150 {
lab=VG}
N 70 6510 70 7150 {
lab=VB}
N 70 7240 70 7330 {
lab=VB}
N -100 7150 -100 7330 {
lab=VG}
N 70 7150 70 7240 {
lab=VB}
N 0 7360 0 7390 {
lab=#net10}
N 0 7450 0 7480 {
lab=#net11}
N 0 7420 70 7420 {
lab=VB}
N 0 7510 70 7510 {
lab=VB}
N -100 7510 -40 7510 {
lab=VG}
N -100 7420 -40 7420 {
lab=VG}
N -100 7330 -100 7510 {
lab=VG}
N 70 7330 70 7510 {
lab=VB}
N 0 7330 70 7330 {
lab=VB}
N -100 7330 -40 7330 {
lab=VG}
N 340 6540 340 6570 {
lab=#net12}
N 340 6630 340 6660 {
lab=#net13}
N 340 6720 340 6750 {
lab=#net14}
N 340 6510 410 6510 {
lab=VB}
N 340 6600 410 6600 {
lab=VB}
N 340 6690 410 6690 {
lab=VB}
N 240 6690 300 6690 {
lab=VG}
N 240 6600 300 6600 {
lab=VG}
N 240 6510 300 6510 {
lab=VG}
N 410 6690 410 6780 {
lab=VB}
N 240 6600 240 6780 {
lab=VG}
N 410 6600 410 6690 {
lab=VB}
N 240 6780 300 6780 {
lab=VG}
N 340 6780 410 6780 {
lab=VB}
N 340 6810 340 6840 {
lab=#net15}
N 340 6900 340 6930 {
lab=#net16}
N 340 6870 410 6870 {
lab=VB}
N 240 6870 300 6870 {
lab=VG}
N 410 6870 410 6960 {
lab=VB}
N 240 6780 240 6960 {
lab=VG}
N 340 6990 340 7020 {
lab=#net17}
N 340 7080 340 7110 {
lab=#net18}
N 340 7170 340 7200 {
lab=#net19}
N 340 7260 340 7290 {
lab=#net20}
N 340 7050 410 7050 {
lab=VB}
N 340 7140 410 7140 {
lab=VB}
N 340 7230 410 7230 {
lab=VB}
N 240 7230 300 7230 {
lab=VG}
N 240 7140 300 7140 {
lab=VG}
N 240 7050 300 7050 {
lab=VG}
N 410 7230 410 7320 {
lab=VB}
N 240 7140 240 7320 {
lab=VG}
N 410 7140 410 7230 {
lab=VB}
N 240 6960 240 7140 {
lab=VG}
N 410 6960 410 7140 {
lab=VB}
N 240 7320 300 7320 {
lab=VG}
N 340 7320 410 7320 {
lab=VB}
N 340 6960 410 6960 {
lab=VB}
N 240 6960 300 6960 {
lab=VG}
N 410 6780 410 6870 {
lab=VB}
N 340 7350 340 7380 {
lab=#net21}
N 340 7440 340 7470 {
lab=#net22}
N 340 7410 410 7410 {
lab=VB}
N 240 7410 300 7410 {
lab=VG}
N 410 7410 410 7500 {
lab=VB}
N 240 7320 240 7500 {
lab=VG}
N 410 7320 410 7410 {
lab=VB}
N 340 7500 410 7500 {
lab=VB}
N 240 7500 300 7500 {
lab=VG}
N 240 6510 240 6600 {
lab=VG}
N 410 6520 410 6600 {
lab=VB}
N 410 6510 410 6520 {
lab=VB}
N 0 7630 0 7660 {
lab=#net23}
N 0 7720 0 7750 {
lab=#net24}
N 0 7810 0 7840 {
lab=#net25}
N 0 7900 0 7930 {
lab=#net26}
N 0 7990 0 8030 {
lab=#net27}
N 0 8090 0 8120 {
lab=#net28}
N 0 8180 0 8210 {
lab=#net29}
N 0 8270 0 8300 {
lab=#net30}
N 0 8360 0 8390 {
lab=#net31}
N 0 7600 70 7600 {
lab=VB}
N 0 7690 70 7690 {
lab=VB}
N 0 7780 70 7780 {
lab=VB}
N 0 7870 70 7870 {
lab=VB}
N 0 7960 70 7960 {
lab=VB}
N 0 8060 70 8060 {
lab=VB}
N 0 8150 70 8150 {
lab=VB}
N 0 8240 70 8240 {
lab=VB}
N 0 8330 70 8330 {
lab=VB}
N -100 7600 -40 7600 {
lab=VG}
N -100 8330 -40 8330 {
lab=VG}
N -100 8240 -40 8240 {
lab=VG}
N -100 8150 -40 8150 {
lab=VG}
N -100 8060 -40 8060 {
lab=VG}
N -100 7960 -40 7960 {
lab=VG}
N -100 7870 -40 7870 {
lab=VG}
N -100 7780 -40 7780 {
lab=VG}
N -100 7690 -40 7690 {
lab=VG}
N -100 7600 -100 8240 {
lab=VG}
N 70 7600 70 8240 {
lab=VB}
N 70 8330 70 8420 {
lab=VB}
N -100 8240 -100 8420 {
lab=VG}
N 70 8240 70 8330 {
lab=VB}
N 0 8450 0 8480 {
lab=#net32}
N 0 8540 0 8570 {
lab=#net33}
N 0 8510 70 8510 {
lab=VB}
N 0 8600 70 8600 {
lab=VB}
N -100 8600 -40 8600 {
lab=VG}
N -100 8510 -40 8510 {
lab=VG}
N -100 8420 -100 8600 {
lab=VG}
N 70 8420 70 8600 {
lab=VB}
N 0 8420 70 8420 {
lab=VB}
N -100 8420 -40 8420 {
lab=VG}
N 340 7630 340 7660 {
lab=#net34}
N 340 7720 340 7750 {
lab=#net35}
N 340 7810 340 7840 {
lab=#net36}
N 340 7600 410 7600 {
lab=VB}
N 340 7690 410 7690 {
lab=VB}
N 340 7780 410 7780 {
lab=VB}
N 240 7780 300 7780 {
lab=VG}
N 240 7690 300 7690 {
lab=VG}
N 240 7600 300 7600 {
lab=VG}
N 410 7780 410 7870 {
lab=VB}
N 240 7690 240 7870 {
lab=VG}
N 410 7690 410 7780 {
lab=VB}
N 240 7870 300 7870 {
lab=VG}
N 340 7870 410 7870 {
lab=VB}
N 340 7900 340 7930 {
lab=#net37}
N 340 7990 340 8020 {
lab=#net38}
N 340 7960 410 7960 {
lab=VB}
N 240 7960 300 7960 {
lab=VG}
N 410 7960 410 8050 {
lab=VB}
N 240 7870 240 8050 {
lab=VG}
N 340 8080 340 8110 {
lab=#net39}
N 340 8170 340 8200 {
lab=#net40}
N 340 8260 340 8290 {
lab=#net41}
N 340 8350 340 8380 {
lab=#net42}
N 340 8140 410 8140 {
lab=VB}
N 340 8230 410 8230 {
lab=VB}
N 340 8320 410 8320 {
lab=VB}
N 240 8320 300 8320 {
lab=VG}
N 240 8230 300 8230 {
lab=VG}
N 240 8140 300 8140 {
lab=VG}
N 410 8320 410 8410 {
lab=VB}
N 240 8230 240 8410 {
lab=VG}
N 410 8230 410 8320 {
lab=VB}
N 240 8050 240 8230 {
lab=VG}
N 410 8050 410 8230 {
lab=VB}
N 240 8410 300 8410 {
lab=VG}
N 340 8410 410 8410 {
lab=VB}
N 340 8050 410 8050 {
lab=VB}
N 240 8050 300 8050 {
lab=VG}
N 410 7870 410 7960 {
lab=VB}
N 340 8440 340 8470 {
lab=#net43}
N 340 8530 340 8560 {
lab=#net44}
N 340 8500 410 8500 {
lab=VB}
N 240 8500 300 8500 {
lab=VG}
N 410 8500 410 8590 {
lab=VB}
N 240 8410 240 8590 {
lab=VG}
N 410 8410 410 8500 {
lab=VB}
N 340 8590 410 8590 {
lab=VB}
N 240 8590 300 8590 {
lab=VG}
N 240 7600 240 7690 {
lab=VG}
N 410 7610 410 7690 {
lab=VB}
N 410 7600 410 7610 {
lab=VB}
N 0 7540 0 7570 {
lab=#net45}
N 70 7510 70 7600 {
lab=VB}
N -100 7510 -100 7600 {
lab=VG}
N 240 7500 240 7600 {
lab=VG}
N 340 7530 340 7570 {
lab=#net46}
N 410 7500 410 7600 {
lab=VB}
N 0 6450 0 6480 {}
N 340 6440 340 6480 {}
N 70 6420 70 6510 {}
N -100 6420 -100 6510 {}
N 240 6410 240 6510 {}
N 410 6410 410 6510 {}
N -100 4240 -100 4330 {}
N 70 4240 70 4330 {}
N 240 4230 240 4320 {}
N 410 4230 410 4320 {}
N 410 4320 410 4330 {}
N 240 4320 240 4330 {}
C {devices/iopin.sym} 170 8730 1 0 {name=p1 lab=VD}
C {devices/iopin.sym} 70 380 0 0 {name=p2 lab=VB}
C {devices/iopin.sym} -100 380 2 0 {name=p3 lab=VG}
C {devices/iopin.sym} 0 -130 3 0 {name=p4 lab=VS}
C {devices/lab_wire.sym} 70 110 0 0 {name=p23 sig_type=std_logic lab=VB}
C {symbols/pfet_03v3.sym} -20 -30 0 0 {name=M1
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -20 60 0 0 {name=M2
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -20 150 0 0 {name=M3
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -20 240 0 0 {name=M4
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -20 330 0 0 {name=M5
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -20 430 0 0 {name=M6
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -20 520 0 0 {name=M7
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -20 610 0 0 {name=M8
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -20 700 0 0 {name=M9
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -20 790 0 0 {name=M10
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -20 880 0 0 {name=M41
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -20 970 0 0 {name=M42
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 -30 0 0 {name=M93
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 60 0 0 {name=M94
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 150 0 0 {name=M95
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 240 0 0 {name=M96
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 330 0 0 {name=M109
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 420 0 0 {name=M110
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 510 0 0 {name=M117
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 600 0 0 {name=M118
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 690 0 0 {name=M119
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 780 0 0 {name=M120
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 870 0 0 {name=M21
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 960 0 0 {name=M22
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {devices/lab_wire.sym} 240 120 0 0 {name=p5 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 410 110 0 0 {name=p7 sig_type=std_logic lab=VB}
C {devices/lab_wire.sym} 70 1200 0 0 {name=p9 sig_type=std_logic lab=VB}
C {symbols/pfet_03v3.sym} -20 1060 0 0 {name=M11
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -20 1150 0 0 {name=M12
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -20 1240 0 0 {name=M13
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -20 1330 0 0 {name=M14
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -20 1420 0 0 {name=M15
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -20 1520 0 0 {name=M16
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -20 1610 0 0 {name=M17
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -20 1700 0 0 {name=M18
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -20 1790 0 0 {name=M19
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -20 1880 0 0 {name=M20
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -20 1970 0 0 {name=M23
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -20 2060 0 0 {name=M24
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 1060 0 0 {name=M25
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 1150 0 0 {name=M26
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 1240 0 0 {name=M27
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 1330 0 0 {name=M28
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 1420 0 0 {name=M29
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 1510 0 0 {name=M30
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 1600 0 0 {name=M31
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 1690 0 0 {name=M32
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 1780 0 0 {name=M33
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 1870 0 0 {name=M34
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 1960 0 0 {name=M35
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 2050 0 0 {name=M36
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {devices/lab_wire.sym} 240 1210 0 0 {name=p10 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 410 1200 0 0 {name=p11 sig_type=std_logic lab=VB}
C {devices/lab_wire.sym} 70 2290 0 0 {name=p12 sig_type=std_logic lab=VB}
C {symbols/pfet_03v3.sym} -20 2150 0 0 {name=M37
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -20 2240 0 0 {name=M38
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -20 2330 0 0 {name=M39
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -20 2420 0 0 {name=M40
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -20 2510 0 0 {name=M43
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -20 2610 0 0 {name=M44
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -20 2700 0 0 {name=M45
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -20 2790 0 0 {name=M46
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -20 2880 0 0 {name=M47
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -20 2970 0 0 {name=M48
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -20 3060 0 0 {name=M49
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -20 3150 0 0 {name=M50
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 2150 0 0 {name=M51
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 2240 0 0 {name=M52
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 2330 0 0 {name=M53
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 2420 0 0 {name=M54
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 2510 0 0 {name=M55
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 2600 0 0 {name=M56
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 2690 0 0 {name=M57
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 2780 0 0 {name=M58
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 2870 0 0 {name=M59
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 2960 0 0 {name=M60
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 3050 0 0 {name=M61
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 3140 0 0 {name=M62
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {devices/lab_wire.sym} 240 2300 0 0 {name=p13 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 410 2290 0 0 {name=p14 sig_type=std_logic lab=VB}
C {devices/lab_wire.sym} 70 3380 0 0 {name=p15 sig_type=std_logic lab=VB}
C {symbols/pfet_03v3.sym} -20 3240 0 0 {name=M63
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -20 3330 0 0 {name=M64
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -20 3420 0 0 {name=M65
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -20 3510 0 0 {name=M66
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -20 3600 0 0 {name=M67
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -20 3700 0 0 {name=M68
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -20 3790 0 0 {name=M69
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -20 3880 0 0 {name=M70
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -20 3970 0 0 {name=M71
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -20 4060 0 0 {name=M72
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -20 4150 0 0 {name=M73
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -20 4240 0 0 {name=M74
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 3240 0 0 {name=M75
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 3330 0 0 {name=M76
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 3420 0 0 {name=M77
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 3510 0 0 {name=M78
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 3600 0 0 {name=M79
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 3690 0 0 {name=M80
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 3780 0 0 {name=M81
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 3870 0 0 {name=M82
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 3960 0 0 {name=M83
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 4050 0 0 {name=M84
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 4140 0 0 {name=M85
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 4230 0 0 {name=M86
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {devices/lab_wire.sym} 240 3390 0 0 {name=p16 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 410 3380 0 0 {name=p17 sig_type=std_logic lab=VB}
C {devices/lab_wire.sym} 70 4470 0 0 {name=p20 sig_type=std_logic lab=VB}
C {symbols/pfet_03v3.sym} -20 4330 0 0 {name=M87
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -20 4420 0 0 {name=M88
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -20 4510 0 0 {name=M89
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -20 4600 0 0 {name=M90
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -20 4690 0 0 {name=M91
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -20 4790 0 0 {name=M92
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -20 4880 0 0 {name=M97
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -20 4970 0 0 {name=M98
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -20 5060 0 0 {name=M99
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -20 5150 0 0 {name=M100
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -20 5240 0 0 {name=M101
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -20 5330 0 0 {name=M102
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 4330 0 0 {name=M103
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 4420 0 0 {name=M104
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 4510 0 0 {name=M105
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 4600 0 0 {name=M106
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 4690 0 0 {name=M107
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 4780 0 0 {name=M108
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 4870 0 0 {name=M111
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 4960 0 0 {name=M112
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 5050 0 0 {name=M113
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 5140 0 0 {name=M114
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 5230 0 0 {name=M115
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 5320 0 0 {name=M116
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {devices/lab_wire.sym} 240 4480 0 0 {name=p21 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 410 4470 0 0 {name=p22 sig_type=std_logic lab=VB}
C {devices/lab_wire.sym} 70 5560 0 0 {name=p24 sig_type=std_logic lab=VB}
C {symbols/pfet_03v3.sym} -20 5420 0 0 {name=M121
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -20 5510 0 0 {name=M122
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -20 5600 0 0 {name=M123
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -20 5690 0 0 {name=M124
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -20 5780 0 0 {name=M125
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -20 5880 0 0 {name=M126
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -20 5970 0 0 {name=M127
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -20 6060 0 0 {name=M128
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -20 6150 0 0 {name=M129
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -20 6240 0 0 {name=M130
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -20 6330 0 0 {name=M131
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -20 6420 0 0 {name=M132
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 5420 0 0 {name=M133
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 5510 0 0 {name=M134
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 5600 0 0 {name=M135
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 5690 0 0 {name=M136
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 5780 0 0 {name=M137
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 5870 0 0 {name=M138
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 5960 0 0 {name=M139
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 6050 0 0 {name=M140
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 6140 0 0 {name=M141
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 6230 0 0 {name=M142
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 6320 0 0 {name=M143
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 6410 0 0 {name=M144
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {devices/lab_wire.sym} 240 5570 0 0 {name=p25 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 410 5560 0 0 {name=p26 sig_type=std_logic lab=VB}
C {devices/lab_wire.sym} 70 6650 0 0 {name=p29 sig_type=std_logic lab=VB}
C {symbols/pfet_03v3.sym} -20 6510 0 0 {name=M145
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -20 6600 0 0 {name=M146
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -20 6690 0 0 {name=M147
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -20 6780 0 0 {name=M148
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -20 6870 0 0 {name=M149
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -20 6970 0 0 {name=M150
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -20 7060 0 0 {name=M151
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -20 7150 0 0 {name=M152
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -20 7240 0 0 {name=M153
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -20 7330 0 0 {name=M154
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -20 7420 0 0 {name=M155
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -20 7510 0 0 {name=M156
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 6510 0 0 {name=M157
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 6600 0 0 {name=M158
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 6690 0 0 {name=M159
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 6780 0 0 {name=M160
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 6870 0 0 {name=M161
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 6960 0 0 {name=M162
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 7050 0 0 {name=M163
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 7140 0 0 {name=M164
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 7230 0 0 {name=M165
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 7320 0 0 {name=M166
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 7410 0 0 {name=M167
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 7500 0 0 {name=M168
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {devices/lab_wire.sym} 240 6660 0 0 {name=p30 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 410 6650 0 0 {name=p31 sig_type=std_logic lab=VB}
C {devices/lab_wire.sym} 70 7740 0 0 {name=p32 sig_type=std_logic lab=VB}
C {symbols/pfet_03v3.sym} -20 7600 0 0 {name=M169
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -20 7690 0 0 {name=M170
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -20 7780 0 0 {name=M171
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -20 7870 0 0 {name=M172
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -20 7960 0 0 {name=M173
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -20 8060 0 0 {name=M174
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -20 8150 0 0 {name=M175
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -20 8240 0 0 {name=M176
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -20 8330 0 0 {name=M177
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -20 8420 0 0 {name=M178
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -20 8510 0 0 {name=M179
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -20 8600 0 0 {name=M180
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 7600 0 0 {name=M181
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 7690 0 0 {name=M182
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 7780 0 0 {name=M183
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 7870 0 0 {name=M184
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 7960 0 0 {name=M185
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 8050 0 0 {name=M186
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 8140 0 0 {name=M187
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 8230 0 0 {name=M188
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 8320 0 0 {name=M189
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 8410 0 0 {name=M190
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 8500 0 0 {name=M191
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 320 8590 0 0 {name=M192
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {devices/lab_wire.sym} 240 7750 0 0 {name=p33 sig_type=std_logic lab=VG}
C {devices/lab_wire.sym} 410 7740 0 0 {name=p34 sig_type=std_logic lab=VB}
