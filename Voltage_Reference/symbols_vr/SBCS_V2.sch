v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
L 4 470 50 470 820 {}
L 4 470 820 1660 820 {}
L 4 470 50 1660 50 {}
L 4 1660 50 1660 820 {}
L 4 2380 -410 2380 310 {}
L 4 2380 310 2840 310 {}
L 4 2840 -410 2840 310 {}
L 4 2380 -410 2840 -410 {}
T {SCM_W.I} 2180 430 0 0 1 1 {}
T {W.I} 1610 -20 0 0 1 1 {}
T {SCM_M.I} -360 510 0 0 1 1 {}
T {OUT} 2570 -500 0 0 1 1 {}
N -30 320 50 320 {
lab=VG_SCM_M_I}
N 50 470 50 490 {
lab=VX}
N -60 320 -30 320 {
lab=VG_SCM_M_I}
N -60 410 -30 410 {
lab=VG_SCM_M_I}
N 140 3770 140 3800 {
lab=gnd}
N 2110 270 2110 320 {
lab=gnd}
N 2110 680 2110 730 {
lab=gnd}
N 2040 330 2040 400 {
lab=VY}
N 2040 740 2040 810 {
lab=gnd}
N 960 310 960 360 {
lab=gnd}
N 820 210 820 310 {
lab=VG_M9}
N 890 220 890 250 {
lab=#net1}
N 1270 310 1270 360 {
lab=gnd}
N 460 -370 890 -370 {
lab=vdd}
N 890 -370 2140 -370 {
lab=vdd}
N 750 -30 890 -30 {
lab=VG_M6}
N 1270 -370 2040 -370 {
lab=vdd}
N 2040 170 2040 210 {
lab=VG_SCM_W_I}
N 890 -20 890 0 {
lab=VG_M6}
N 50 260 50 320 {
lab=VG_SCM_M_I}
N 50 320 50 350 {
lab=VG_SCM_M_I}
N 1960 640 1960 680 {
lab=VG_SCM_W_I}
N 2040 570 2040 600 {
lab=#net2}
N 2040 600 2040 620 {
lab=#net2}
N 960 -370 960 -350 {
lab=vdd}
N 750 -90 810 -90 {
lab=VG_M6}
N 750 -90 750 -30 {
lab=VG_M6}
N 960 -160 960 -90 {
lab=#net3}
N 890 -290 890 -280 {
lab=#net4}
N 890 -370 890 -350 {
lab=vdd}
N 890 -30 890 -20 {
lab=VG_M6}
N 1970 170 2040 170 {
lab=VG_SCM_W_I}
N 1960 170 1960 270 {
lab=VG_SCM_W_I}
N 1960 170 1970 170 {
lab=VG_SCM_W_I}
N 2040 1270 2220 1270 {
lab=gnd}
N 50 -370 460 -370 {
lab=vdd}
N 140 3750 140 3770 {
lab=gnd}
N 2040 1080 2040 1270 {
lab=gnd}
N 2040 810 2040 1080 {
lab=gnd}
N 890 380 890 410 {
lab=VX}
N 1200 380 1200 410 {
lab=#net2}
N 890 370 890 380 {
lab=VX}
N 1200 370 1200 380 {
lab=#net2}
N 890 410 890 560 {
lab=VX}
N 2110 -370 2640 -370 {
lab=vdd}
N 890 -280 890 -200 {
lab=#net4}
N 890 -200 890 -150 {
lab=#net4}
N 140 3620 140 3750 {
lab=gnd}
N 50 100 50 140 {
lab=#net5}
N -30 -90 -30 -30 {
lab=VG_M6}
N 50 140 50 200 {
lab=#net5}
N 1200 40 1200 60 {
lab=#net6}
N 2040 -370 2110 -370 {
lab=vdd}
N 1200 -370 1200 -150 {
lab=vdd}
N 1200 -30 1200 40 {
lab=#net6}
N 1120 -90 1120 20 {
lab=VG_M6}
N 1270 -240 1270 -90 {
lab=#net7}
N 1270 -370 1270 -300 {
lab=vdd}
N 1200 -370 1270 -370 {
lab=vdd}
N 2040 40 2040 60 {
lab=#net8}
N 2040 120 2040 130 {
lab=VG_SCM_W_I}
N 2040 -370 2040 -150 {
lab=vdd}
N 2040 -30 2040 40 {
lab=#net8}
N 1960 -90 1960 20 {
lab=VG_M6}
N 2110 -240 2110 -90 {
lab=#net9}
N 2110 -370 2110 -300 {
lab=vdd}
N 2040 -370 2110 -370 {
lab=vdd}
N 2640 -370 2710 -370 {
lab=vdd}
N 2640 40 2640 60 {
lab=#net10}
N 2640 120 2640 130 {
lab=i_out}
N 2640 -370 2640 -150 {
lab=vdd}
N 2640 -30 2640 40 {
lab=#net10}
N 2560 -90 2560 20 {
lab=VG_M6}
N 2710 -240 2710 -90 {
lab=#net11}
N 2710 -370 2710 -300 {
lab=vdd}
N 2640 -370 2710 -370 {
lab=vdd}
N 2640 130 2640 160 {
lab=i_out}
N -30 410 -20 410 {
lab=VG_SCM_M_I}
N -60 320 -60 410 {
lab=VG_SCM_M_I}
N 50 750 50 790 {
lab=#net12}
N 50 490 50 630 {
lab=VX}
N -60 410 -60 850 {
lab=VG_SCM_M_I}
N -60 850 -20 850 {
lab=VG_SCM_M_I}
N -60 690 -20 690 {
lab=VG_SCM_M_I}
N 120 690 150 690 {
lab=gnd}
N 150 690 150 850 {
lab=gnd}
N 120 850 150 850 {
lab=gnd}
N 50 560 870 560 {
lab=VX}
N 870 560 890 560 {
lab=VX}
N 890 180 890 220 {
lab=#net1}
N 1200 120 1200 250 {
lab=VG_M9}
N 1130 220 1130 310 {
lab=VG_M9}
N 1130 220 1200 220 {
lab=VG_M9}
N 1200 410 1200 560 {
lab=#net2}
N 1200 560 1950 560 {
lab=#net2}
N 2040 130 2040 170 {
lab=VG_SCM_W_I}
N 1950 560 2040 560 {
lab=#net2}
N 2040 560 2040 570 {
lab=#net2}
N 2040 460 2040 560 {
lab=#net2}
N 890 -0 890 120 {
lab=VG_M6}
N 960 -290 960 -160 {
lab=#net3}
N 120 -280 120 -90 {
lab=#net13}
N 120 -370 120 -340 {
lab=vdd}
N 50 -370 50 -340 {
lab=vdd}
N 50 -280 50 -150 {
lab=#net14}
N 50 -30 50 100 {
lab=#net5}
N 120 410 160 410 {
lab=gnd}
N 160 410 160 460 {
lab=gnd}
N 50 910 50 950 {
lab=#net15}
N -60 850 -60 1010 {
lab=VG_SCM_M_I}
N 150 850 150 1010 {
lab=gnd}
N 40 1200 40 1230 {
lab=#net16}
N 40 1290 40 1320 {
lab=#net17}
N 40 1380 40 1410 {
lab=#net18}
N 40 1470 40 1500 {
lab=#net19}
N 40 1560 40 1600 {
lab=#net20}
N 40 1660 40 1690 {
lab=#net21}
N 40 1750 40 1780 {
lab=#net22}
N 40 1840 40 1870 {
lab=#net23}
N 40 1930 40 1960 {
lab=#net24}
N 40 1990 110 1990 {
lab=gnd}
N 110 1170 110 1990 {
lab=gnd}
N 40 1170 110 1170 {
lab=gnd}
N 40 1260 110 1260 {
lab=gnd}
N 40 1350 110 1350 {
lab=gnd}
N 40 1440 110 1440 {
lab=gnd}
N 40 1530 110 1530 {
lab=gnd}
N 40 1630 110 1630 {
lab=gnd}
N 40 1720 110 1720 {
lab=gnd}
N 40 1810 110 1810 {
lab=gnd}
N 40 1900 110 1900 {
lab=gnd}
N -60 1170 0 1170 {
lab=VG_SCM_M_I}
N -60 1170 -60 1990 {
lab=VG_SCM_M_I}
N -60 1990 0 1990 {
lab=VG_SCM_M_I}
N -60 1900 0 1900 {
lab=VG_SCM_M_I}
N -60 1810 0 1810 {
lab=VG_SCM_M_I}
N -60 1720 0 1720 {
lab=VG_SCM_M_I}
N -60 1630 0 1630 {
lab=VG_SCM_M_I}
N -60 1530 0 1530 {
lab=VG_SCM_M_I}
N -60 1440 0 1440 {
lab=VG_SCM_M_I}
N -60 1350 0 1350 {
lab=VG_SCM_M_I}
N -60 1260 0 1260 {
lab=VG_SCM_M_I}
N 40 1070 40 1140 {
lab=#net15}
N 250 1200 250 1230 {
lab=#net25}
N 250 1290 250 1320 {
lab=#net26}
N 250 1380 250 1410 {
lab=#net27}
N 250 1470 250 1500 {
lab=#net28}
N 250 1560 250 1600 {
lab=#net29}
N 250 1660 250 1690 {
lab=#net30}
N 250 1750 250 1780 {
lab=#net31}
N 250 1840 250 1870 {
lab=#net32}
N 250 1930 250 1960 {
lab=#net33}
N 250 1990 320 1990 {
lab=gnd}
N 320 1170 320 1990 {
lab=gnd}
N 250 1170 320 1170 {
lab=gnd}
N 250 1260 320 1260 {
lab=gnd}
N 250 1350 320 1350 {
lab=gnd}
N 250 1440 320 1440 {
lab=gnd}
N 250 1530 320 1530 {
lab=gnd}
N 250 1630 320 1630 {
lab=gnd}
N 250 1720 320 1720 {
lab=gnd}
N 250 1810 320 1810 {
lab=gnd}
N 250 1900 320 1900 {
lab=gnd}
N 190 1170 210 1170 {
lab=VG_SCM_M_I}
N 190 1170 190 1990 {
lab=VG_SCM_M_I}
N 190 1990 210 1990 {
lab=VG_SCM_M_I}
N 190 1900 210 1900 {
lab=VG_SCM_M_I}
N 190 1810 210 1810 {
lab=VG_SCM_M_I}
N 190 1720 210 1720 {
lab=VG_SCM_M_I}
N 190 1630 210 1630 {
lab=VG_SCM_M_I}
N 190 1530 210 1530 {
lab=VG_SCM_M_I}
N 190 1440 210 1440 {
lab=VG_SCM_M_I}
N 190 1350 210 1350 {
lab=VG_SCM_M_I}
N 190 1260 210 1260 {
lab=VG_SCM_M_I}
N 250 1120 250 1140 {
lab=#net15}
N 40 1120 250 1120 {
lab=#net15}
N 40 2120 40 2150 {
lab=#net34}
N 40 2210 40 2240 {
lab=#net35}
N 40 2300 40 2330 {
lab=#net36}
N 40 2390 40 2420 {
lab=#net37}
N 40 2480 40 2520 {
lab=#net38}
N 40 2580 40 2610 {
lab=#net39}
N 40 2670 40 2700 {
lab=#net40}
N 40 2760 40 2790 {
lab=#net41}
N 40 2850 40 2880 {
lab=#net42}
N 40 2910 110 2910 {
lab=gnd}
N 110 2090 110 2910 {
lab=gnd}
N 40 2090 110 2090 {
lab=gnd}
N 40 2180 110 2180 {
lab=gnd}
N 40 2270 110 2270 {
lab=gnd}
N 40 2360 110 2360 {
lab=gnd}
N 40 2450 110 2450 {
lab=gnd}
N 40 2550 110 2550 {
lab=gnd}
N 40 2640 110 2640 {
lab=gnd}
N 40 2730 110 2730 {
lab=gnd}
N 40 2820 110 2820 {
lab=gnd}
N -60 2090 0 2090 {
lab=VG_SCM_M_I}
N -60 2090 -60 2910 {
lab=VG_SCM_M_I}
N -60 2910 0 2910 {
lab=VG_SCM_M_I}
N -60 2820 0 2820 {
lab=VG_SCM_M_I}
N -60 2730 0 2730 {
lab=VG_SCM_M_I}
N -60 2640 0 2640 {
lab=VG_SCM_M_I}
N -60 2550 0 2550 {
lab=VG_SCM_M_I}
N -60 2450 0 2450 {
lab=VG_SCM_M_I}
N -60 2360 0 2360 {
lab=VG_SCM_M_I}
N -60 2270 0 2270 {
lab=VG_SCM_M_I}
N -60 2180 0 2180 {
lab=VG_SCM_M_I}
N 250 2120 250 2150 {
lab=#net43}
N 250 2210 250 2240 {
lab=#net44}
N 250 2300 250 2330 {
lab=#net45}
N 250 2390 250 2420 {
lab=#net46}
N 250 2480 250 2520 {
lab=#net47}
N 250 2580 250 2610 {
lab=#net48}
N 250 2670 250 2700 {
lab=#net49}
N 250 2760 250 2790 {
lab=#net50}
N 250 2850 250 2880 {
lab=#net51}
N 250 2910 320 2910 {
lab=gnd}
N 320 2090 320 2910 {
lab=gnd}
N 250 2090 320 2090 {
lab=gnd}
N 250 2180 320 2180 {
lab=gnd}
N 250 2270 320 2270 {
lab=gnd}
N 250 2360 320 2360 {
lab=gnd}
N 250 2450 320 2450 {
lab=gnd}
N 250 2550 320 2550 {
lab=gnd}
N 250 2640 320 2640 {
lab=gnd}
N 250 2730 320 2730 {
lab=gnd}
N 250 2820 320 2820 {
lab=gnd}
N 190 2090 210 2090 {
lab=VG_SCM_M_I}
N 190 2090 190 2910 {
lab=VG_SCM_M_I}
N 190 2910 210 2910 {
lab=VG_SCM_M_I}
N 190 2820 210 2820 {
lab=VG_SCM_M_I}
N 190 2730 210 2730 {
lab=VG_SCM_M_I}
N 190 2640 210 2640 {
lab=VG_SCM_M_I}
N 190 2550 210 2550 {
lab=VG_SCM_M_I}
N 190 2450 210 2450 {
lab=VG_SCM_M_I}
N 190 2360 210 2360 {
lab=VG_SCM_M_I}
N 190 2270 210 2270 {
lab=VG_SCM_M_I}
N 190 2180 210 2180 {
lab=VG_SCM_M_I}
N 40 2020 40 2060 {
lab=#net52}
N 250 2020 250 2060 {
lab=#net53}
N 320 2000 320 2090 {
lab=gnd}
N 320 1990 320 2000 {
lab=gnd}
N 190 1990 190 2090 {
lab=VG_SCM_M_I}
N 110 1990 110 2090 {
lab=gnd}
N -60 1990 -60 2090 {
lab=VG_SCM_M_I}
N 40 2940 40 2970 {
lab=#net54}
N 40 3000 110 3000 {
lab=gnd}
N -60 3000 0 3000 {
lab=VG_SCM_M_I}
N 250 2940 250 2970 {
lab=#net55}
N 250 3000 320 3000 {
lab=gnd}
N 190 3000 210 3000 {
lab=VG_SCM_M_I}
N -60 1010 -60 1170 {
lab=VG_SCM_M_I}
N 150 1010 320 1010 {
lab=gnd}
N 320 1010 320 1170 {
lab=gnd}
N 50 950 50 1070 {
lab=#net15}
N 40 1070 50 1070 {
lab=#net15}
N -60 2910 -60 3000 {
lab=VG_SCM_M_I}
N 110 2910 110 3000 {
lab=gnd}
N 190 2910 190 3000 {
lab=VG_SCM_M_I}
N 320 2910 320 3000 {
lab=gnd}
N 250 3570 250 3620 {
lab=gnd}
N 140 3620 250 3620 {
lab=gnd}
N 40 3620 140 3620 {
lab=gnd}
N 40 3570 40 3620 {
lab=gnd}
N 40 3030 40 3060 {
lab=#net56}
N 40 3120 40 3150 {
lab=#net57}
N 40 3210 40 3240 {
lab=#net58}
N 40 3270 110 3270 {
lab=gnd}
N 40 3090 110 3090 {
lab=gnd}
N 40 3180 110 3180 {
lab=gnd}
N -60 3270 0 3270 {
lab=VG_SCM_M_I}
N -60 3180 0 3180 {
lab=VG_SCM_M_I}
N -60 3090 0 3090 {
lab=VG_SCM_M_I}
N 250 3030 250 3060 {
lab=#net59}
N 250 3120 250 3150 {
lab=#net60}
N 250 3210 250 3240 {
lab=#net61}
N 250 3270 320 3270 {
lab=gnd}
N 250 3090 320 3090 {
lab=gnd}
N 250 3180 320 3180 {
lab=gnd}
N 190 3270 210 3270 {
lab=VG_SCM_M_I}
N 190 3180 210 3180 {
lab=VG_SCM_M_I}
N 190 3090 210 3090 {
lab=VG_SCM_M_I}
N 40 3300 40 3330 {
lab=#net62}
N 40 3360 110 3360 {
lab=gnd}
N -60 3360 0 3360 {
lab=VG_SCM_M_I}
N 250 3300 250 3330 {
lab=#net63}
N 250 3360 320 3360 {
lab=gnd}
N 190 3360 210 3360 {
lab=VG_SCM_M_I}
N -60 3270 -60 3360 {
lab=VG_SCM_M_I}
N 110 3270 110 3360 {
lab=gnd}
N 190 3270 190 3360 {
lab=VG_SCM_M_I}
N 320 3270 320 3360 {
lab=gnd}
N -60 3000 -60 3270 {
lab=VG_SCM_M_I}
N 110 3000 110 3270 {
lab=gnd}
N 190 3000 190 3260 {
lab=VG_SCM_M_I}
N 190 3260 190 3270 {
lab=VG_SCM_M_I}
N 320 3000 320 3270 {
lab=gnd}
N 40 3390 40 3420 {
lab=#net64}
N 40 3450 110 3450 {
lab=gnd}
N -60 3450 0 3450 {
lab=VG_SCM_M_I}
N 250 3390 250 3420 {
lab=#net65}
N 250 3450 320 3450 {
lab=gnd}
N 190 3450 210 3450 {
lab=VG_SCM_M_I}
N 40 3480 40 3510 {
lab=#net66}
N 40 3540 110 3540 {
lab=gnd}
N -60 3540 0 3540 {
lab=VG_SCM_M_I}
N 250 3480 250 3510 {
lab=#net67}
N 250 3540 320 3540 {
lab=gnd}
N 190 3540 210 3540 {
lab=VG_SCM_M_I}
N -60 3450 -60 3540 {
lab=VG_SCM_M_I}
N 110 3450 110 3540 {
lab=gnd}
N 190 3450 190 3540 {
lab=VG_SCM_M_I}
N 320 3450 320 3540 {
lab=gnd}
N 190 3440 190 3450 {
lab=VG_SCM_M_I}
N 190 3360 190 3440 {
lab=VG_SCM_M_I}
N 320 3360 320 3450 {
lab=gnd}
N -60 3360 -60 3450 {
lab=VG_SCM_M_I}
N 110 3360 110 3450 {
lab=gnd}
N 810 -90 850 -90 {
lab=VG_M6}
N 890 -60 890 -30 {
lab=VG_M6}
N 890 -150 890 -120 {
lab=#net4}
N 890 -90 960 -90 {
lab=#net3}
N 1120 -90 1160 -90 {
lab=VG_M6}
N 1200 -90 1270 -90 {
lab=#net7}
N 1200 -150 1200 -120 {
lab=vdd}
N 1200 -60 1200 -30 {
lab=#net6}
N 2560 -90 2600 -90 {
lab=VG_M6}
N 2640 -150 2640 -120 {
lab=vdd}
N 2640 -90 2710 -90 {
lab=#net11}
N 2640 -60 2640 -30 {
lab=#net10}
N 1960 -90 2000 -90 {
lab=VG_M6}
N 2040 -150 2040 -120 {
lab=vdd}
N 2040 -60 2040 -30 {
lab=#net8}
N 2040 -90 2110 -90 {
lab=#net9}
N -30 -90 10 -90 {
lab=VG_M6}
N 50 -150 50 -120 {
lab=#net14}
N 50 -90 120 -90 {
lab=#net13}
N 50 -60 50 -30 {
lab=#net5}
C {devices/lab_wire.sym} 2110 320 0 0 {name=p8 sig_type=std_logic lab=gnd}
C {devices/lab_wire.sym} 2110 730 0 0 {name=p24 sig_type=std_logic lab=gnd}
C {devices/lab_wire.sym} 960 360 0 0 {name=p26 sig_type=std_logic lab=gnd}
C {devices/lab_wire.sym} 1270 360 0 0 {name=p27 sig_type=std_logic lab=gnd}
C {devices/lab_wire.sym} 1130 220 0 0 {name=p33 sig_type=std_logic lab=VG_M9}
C {devices/lab_wire.sym} 820 210 0 1 {name=p34 sig_type=std_logic lab=VG_M9}
C {devices/lab_wire.sym} 750 -60 0 0 {name=p50 sig_type=std_logic lab=VG_M6}
C {devices/lab_wire.sym} 1120 20 0 0 {name=p51 sig_type=std_logic lab=VG_M6}
C {devices/lab_wire.sym} 2040 360 0 0 {name=p52 sig_type=std_logic lab=VY}
C {symbols_vr/NMOS_association_10u_6u_V2.sym} 970 310 0 0 {name=x24[1:4]}
C {symbols_vr/NMOS_association_10u_6u_V2.sym} 1280 310 0 0 {name=x40[1:4]}
C {devices/lab_wire.sym} 1260 -370 0 0 {name=p57 sig_type=std_logic lab=vdd}
C {devices/lab_wire.sym} 50 310 0 1 {name=p58 sig_type=std_logic lab=VG_SCM_M_I}
C {devices/ammeter.sym} 1200 90 0 0 {name=Vmeas2}
C {devices/ammeter.sym} 890 150 0 0 {name=Vmeas3}
C {devices/ammeter.sym} 50 230 0 0 {name=Vmeas4}
C {devices/lab_wire.sym} 130 560 0 1 {name=p59 sig_type=std_logic lab=VX}
C {devices/lab_wire.sym} 1990 170 0 0 {name=p60 sig_type=std_logic lab=VG_SCM_W_I}
C {devices/lab_wire.sym} 1960 640 0 1 {name=p67 sig_type=std_logic lab=VG_SCM_W_I}
C {devices/ammeter.sym} 2040 430 0 0 {name=Vmeas5}
C {devices/ammeter.sym} 960 -320 0 0 {name=Vmeas6}
C {devices/ammeter.sym} 890 -320 0 0 {name=Vmeas7}
C {devices/iopin.sym} 1070 -370 3 0 {name=p55 lab=vdd}
C {devices/iopin.sym} 140 3800 1 0 {name=p56 lab=gnd}
C {devices/iopin.sym} 2640 160 1 0 {name=p68 lab=i_out}
C {devices/lab_wire.sym} 2160 1270 0 0 {name=p77 sig_type=std_logic lab=gnd}
C {symbols_vr/NMOS_association_13u_2u.sym} 2040 330 0 0 {name=x5[1:6]}
C {symbols_vr/NMOS_association_18u_5u.sym} 2170 810 0 0 {name=x7}
C {devices/lab_wire.sym} -30 -30 0 0 {name=p13 sig_type=std_logic lab=VG_M6}
C {devices/ammeter.sym} 50 -310 0 0 {name=Vmeas10}
C {devices/ammeter.sym} 120 -310 0 0 {name=Vmeas11}
C {devices/ammeter.sym} 1270 -270 0 0 {name=Vmeas8}
C {devices/lab_wire.sym} 1960 20 0 0 {name=p1 sig_type=std_logic lab=VG_M6}
C {devices/ammeter.sym} 2040 90 0 0 {name=Vmeas1}
C {devices/ammeter.sym} 2110 -270 0 0 {name=Vmeas9}
C {devices/lab_wire.sym} 2560 20 0 0 {name=p2 sig_type=std_logic lab=VG_M6}
C {devices/ammeter.sym} 2640 90 0 0 {name=Vmeas12}
C {devices/ammeter.sym} 2710 -270 0 0 {name=Vmeas13}
C {symbols_vr/NMOS_association_MI_1.sym} 50 410 0 0 {name=x6}
C {symbols_vr/NMOS_association_MI_1.sym} 50 690 0 0 {name=x1}
C {symbols_vr/NMOS_association_MI_1.sym} 50 850 0 0 {name=x2}
C {devices/lab_wire.sym} 160 460 0 0 {name=p3 sig_type=std_logic lab=gnd}
C {devices/lab_wire.sym} 150 770 0 0 {name=p4 sig_type=std_logic lab=gnd}
C {symbols/nfet_03v3.sym} 20 1170 0 0 {name=MN1
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 20 1260 0 0 {name=MN2
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 20 1350 0 0 {name=MN3
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 20 1440 0 0 {name=MN4
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 20 1530 0 0 {name=MN5
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 20 1630 0 0 {name=MN6
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 20 1720 0 0 {name=MN7
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 20 1810 0 0 {name=MN8
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 20 1900 0 0 {name=MN9
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 20 1990 0 0 {name=MN10
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 230 1170 0 0 {name=MN11
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 230 1260 0 0 {name=MN12
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 230 1350 0 0 {name=MN13
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 230 1440 0 0 {name=MN14
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 230 1530 0 0 {name=MN15
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 230 1630 0 0 {name=MN16
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 230 1720 0 0 {name=MN17
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 230 1810 0 0 {name=MN18
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 230 1900 0 0 {name=MN19
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 230 1990 0 0 {name=MN20
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 20 2090 0 0 {name=MN21
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 20 2180 0 0 {name=MN22
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 20 2270 0 0 {name=MN23
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 20 2360 0 0 {name=MN24
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 20 2450 0 0 {name=MN25
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 20 2550 0 0 {name=MN26
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 20 2640 0 0 {name=MN27
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 20 2730 0 0 {name=MN28
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 20 2820 0 0 {name=MN29
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 20 2910 0 0 {name=MN30
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 230 2090 0 0 {name=MN31
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 230 2180 0 0 {name=MN32
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 230 2270 0 0 {name=MN33
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 230 2360 0 0 {name=MN34
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 230 2450 0 0 {name=MN35
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 230 2550 0 0 {name=MN36
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 230 2640 0 0 {name=MN37
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 230 2730 0 0 {name=MN38
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 230 2820 0 0 {name=MN39
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 230 2910 0 0 {name=MN40
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 20 3000 0 0 {name=MN41
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 230 3000 0 0 {name=MN44
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {devices/lab_wire.sym} 110 1400 0 0 {name=p5 sig_type=std_logic lab=gnd}
C {devices/lab_wire.sym} 190 1400 0 1 {name=p6 sig_type=std_logic lab=VG_SCM_M_I}
C {symbols/nfet_03v3.sym} 20 3090 0 0 {name=MN42
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 20 3180 0 0 {name=MN43
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 20 3270 0 0 {name=MN45
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 230 3090 0 0 {name=MN46
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 230 3180 0 0 {name=MN47
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 230 3270 0 0 {name=MN48
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 20 3360 0 0 {name=MN49
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 230 3360 0 0 {name=MN50
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 20 3450 0 0 {name=MN51
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 230 3450 0 0 {name=MN52
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 20 3540 0 0 {name=MN53
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 230 3540 0 0 {name=MN54
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols_vr/PMOS_association_current_mirror.sym} 870 -90 0 0 {name=x7[1:2]}
C {symbols_vr/PMOS_association_current_mirror_2.sym} 1180 -90 0 0 {name=x6[1:8]}
C {symbols_vr/PMOS_association_current_mirror_2.sym} 2020 -90 0 0 {name=x1[1:8]}
C {symbols_vr/PMOS_association_current_mirror_2.sym} 2620 -90 0 0 {name=x2[1:8]}
C {symbols_vr/PMOS_association_current_mirror_2.sym} 30 -90 0 0 {name=x4[1:20]}
